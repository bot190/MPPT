HERP_DERP_WHY_THE_FUCK_NOT
VTHR 1 0 PWL(
+ 0.0000ms,3.3V 0.0001ms,3.3
+ 0.0002ms,0.0V 0.0199ms,0.0
+ 0.0200ms,3.3V 0.0201ms,3.3
+ 0.0202ms,0.0V 0.0399ms,0.0
+ 0.0400ms,3.3V 0.0401ms,3.3
+ 0.0402ms,0.0V 0.0599ms,0.0
+ 0.0600ms,3.3V 0.0601ms,3.3
+ 0.0602ms,0.0V 0.0799ms,0.0
+ 0.0800ms,3.3V 0.0801ms,3.3
+ 0.0802ms,0.0V 0.0999ms,0.0
+ 0.1000ms,3.3V 0.1001ms,3.3
+ 0.1002ms,0.0V 0.1199ms,0.0
+ 0.1200ms,3.3V 0.1201ms,3.3
+ 0.1202ms,0.0V 0.1399ms,0.0
+ 0.1400ms,3.3V 0.1401ms,3.3
+ 0.1402ms,0.0V 0.1599ms,0.0
+ 0.1600ms,3.3V 0.1601ms,3.3
+ 0.1602ms,0.0V 0.1799ms,0.0
+ 0.1800ms,3.3V 0.1801ms,3.3
+ 0.1802ms,0.0V 0.1999ms,0.0
+ 0.2000ms,3.3V 0.2001ms,3.3
+ 0.2002ms,0.0V 0.2199ms,0.0
+ 0.2200ms,3.3V 0.2201ms,3.3
+ 0.2202ms,0.0V 0.2399ms,0.0
+ 0.2400ms,3.3V 0.2401ms,3.3
+ 0.2402ms,0.0V 0.2599ms,0.0
+ 0.2600ms,3.3V 0.2601ms,3.3
+ 0.2602ms,0.0V 0.2799ms,0.0
+ 0.2800ms,3.3V 0.2801ms,3.3
+ 0.2802ms,0.0V 0.2999ms,0.0
+ 0.3000ms,3.3V 0.3001ms,3.3
+ 0.3002ms,0.0V 0.3199ms,0.0
+ 0.3200ms,3.3V 0.3201ms,3.3
+ 0.3202ms,0.0V 0.3399ms,0.0
+ 0.3400ms,3.3V 0.3401ms,3.3
+ 0.3402ms,0.0V 0.3599ms,0.0
+ 0.3600ms,3.3V 0.3601ms,3.3
+ 0.3602ms,0.0V 0.3799ms,0.0
+ 0.3800ms,3.3V 0.3801ms,3.3
+ 0.3802ms,0.0V 0.3999ms,0.0
+ 0.4000ms,3.3V 0.4001ms,3.3
+ 0.4002ms,0.0V 0.4199ms,0.0
+ 0.4200ms,3.3V 0.4201ms,3.3
+ 0.4202ms,0.0V 0.4399ms,0.0
+ 0.4400ms,3.3V 0.4401ms,3.3
+ 0.4402ms,0.0V 0.4599ms,0.0
+ 0.4600ms,3.3V 0.4601ms,3.3
+ 0.4602ms,0.0V 0.4799ms,0.0
+ 0.4800ms,3.3V 0.4801ms,3.3
+ 0.4802ms,0.0V 0.4999ms,0.0
+ 0.5000ms,3.3V 0.5001ms,3.3
+ 0.5002ms,0.0V 0.5199ms,0.0
+ 0.5200ms,3.3V 0.5201ms,3.3
+ 0.5202ms,0.0V 0.5399ms,0.0
+ 0.5400ms,3.3V 0.5401ms,3.3
+ 0.5402ms,0.0V 0.5599ms,0.0
+ 0.5600ms,3.3V 0.5601ms,3.3
+ 0.5602ms,0.0V 0.5799ms,0.0
+ 0.5800ms,3.3V 0.5801ms,3.3
+ 0.5802ms,0.0V 0.5999ms,0.0
+ 0.6000ms,3.3V 0.6001ms,3.3
+ 0.6002ms,0.0V 0.6199ms,0.0
+ 0.6200ms,3.3V 0.6201ms,3.3
+ 0.6202ms,0.0V 0.6399ms,0.0
+ 0.6400ms,3.3V 0.6401ms,3.3
+ 0.6402ms,0.0V 0.6599ms,0.0
+ 0.6600ms,3.3V 0.6601ms,3.3
+ 0.6602ms,0.0V 0.6799ms,0.0
+ 0.6800ms,3.3V 0.6801ms,3.3
+ 0.6802ms,0.0V 0.6999ms,0.0
+ 0.7000ms,3.3V 0.7001ms,3.3
+ 0.7002ms,0.0V 0.7199ms,0.0
+ 0.7200ms,3.3V 0.7201ms,3.3
+ 0.7202ms,0.0V 0.7399ms,0.0
+ 0.7400ms,3.3V 0.7401ms,3.3
+ 0.7402ms,0.0V 0.7599ms,0.0
+ 0.7600ms,3.3V 0.7601ms,3.3
+ 0.7602ms,0.0V 0.7799ms,0.0
+ 0.7800ms,3.3V 0.7801ms,3.3
+ 0.7802ms,0.0V 0.7999ms,0.0
+ 0.8000ms,3.3V 0.8001ms,3.3
+ 0.8002ms,0.0V 0.8199ms,0.0
+ 0.8200ms,3.3V 0.8201ms,3.3
+ 0.8202ms,0.0V 0.8399ms,0.0
+ 0.8400ms,3.3V 0.8401ms,3.3
+ 0.8402ms,0.0V 0.8599ms,0.0
+ 0.8600ms,3.3V 0.8601ms,3.3
+ 0.8602ms,0.0V 0.8799ms,0.0
+ 0.8800ms,3.3V 0.8801ms,3.3
+ 0.8802ms,0.0V 0.8999ms,0.0
+ 0.9000ms,3.3V 0.9001ms,3.3
+ 0.9002ms,0.0V 0.9199ms,0.0
+ 0.9200ms,3.3V 0.9201ms,3.3
+ 0.9202ms,0.0V 0.9399ms,0.0
+ 0.9400ms,3.3V 0.9401ms,3.3
+ 0.9402ms,0.0V 0.9599ms,0.0
+ 0.9600ms,3.3V 0.9601ms,3.3
+ 0.9602ms,0.0V 0.9799ms,0.0
+ 0.9800ms,3.3V 0.9801ms,3.3
+ 0.9802ms,0.0V 0.9999ms,0.0
+ 1.0000ms,3.3V 1.0001ms,3.3
+ 1.0002ms,0.0V 1.0199ms,0.0
+ 1.0200ms,3.3V 1.0201ms,3.3
+ 1.0202ms,0.0V 1.0399ms,0.0
+ 1.0400ms,3.3V 1.0401ms,3.3
+ 1.0402ms,0.0V 1.0599ms,0.0
+ 1.0600ms,3.3V 1.0601ms,3.3
+ 1.0602ms,0.0V 1.0799ms,0.0
+ 1.0800ms,3.3V 1.0801ms,3.3
+ 1.0802ms,0.0V 1.0999ms,0.0
+ 1.1000ms,3.3V 1.1001ms,3.3
+ 1.1002ms,0.0V 1.1199ms,0.0
+ 1.1200ms,3.3V 1.1201ms,3.3
+ 1.1202ms,0.0V 1.1399ms,0.0
+ 1.1400ms,3.3V 1.1401ms,3.3
+ 1.1402ms,0.0V 1.1599ms,0.0
+ 1.1600ms,3.3V 1.1601ms,3.3
+ 1.1602ms,0.0V 1.1799ms,0.0
+ 1.1800ms,3.3V 1.1801ms,3.3
+ 1.1802ms,0.0V 1.1999ms,0.0
+ 1.2000ms,3.3V 1.2001ms,3.3
+ 1.2002ms,0.0V 1.2199ms,0.0
+ 1.2200ms,3.3V 1.2201ms,3.3
+ 1.2202ms,0.0V 1.2399ms,0.0
+ 1.2400ms,3.3V 1.2401ms,3.3
+ 1.2402ms,0.0V 1.2599ms,0.0
+ 1.2600ms,3.3V 1.2601ms,3.3
+ 1.2602ms,0.0V 1.2799ms,0.0
+ 1.2800ms,3.3V 1.2801ms,3.3
+ 1.2802ms,0.0V 1.2999ms,0.0
+ 1.3000ms,3.3V 1.3001ms,3.3
+ 1.3002ms,0.0V 1.3199ms,0.0
+ 1.3200ms,3.3V 1.3201ms,3.3
+ 1.3202ms,0.0V 1.3399ms,0.0
+ 1.3400ms,3.3V 1.3401ms,3.3
+ 1.3402ms,0.0V 1.3599ms,0.0
+ 1.3600ms,3.3V 1.3601ms,3.3
+ 1.3602ms,0.0V 1.3799ms,0.0
+ 1.3800ms,3.3V 1.3801ms,3.3
+ 1.3802ms,0.0V 1.3999ms,0.0
+ 1.4000ms,3.3V 1.4001ms,3.3
+ 1.4002ms,0.0V 1.4199ms,0.0
+ 1.4200ms,3.3V 1.4201ms,3.3
+ 1.4202ms,0.0V 1.4399ms,0.0
+ 1.4400ms,3.3V 1.4401ms,3.3
+ 1.4402ms,0.0V 1.4599ms,0.0
+ 1.4600ms,3.3V 1.4601ms,3.3
+ 1.4602ms,0.0V 1.4799ms,0.0
+ 1.4800ms,3.3V 1.4801ms,3.3
+ 1.4802ms,0.0V 1.4999ms,0.0
+ 1.5000ms,3.3V 1.5001ms,3.3
+ 1.5002ms,0.0V 1.5199ms,0.0
+ 1.5200ms,3.3V 1.5201ms,3.3
+ 1.5202ms,0.0V 1.5399ms,0.0
+ 1.5400ms,3.3V 1.5401ms,3.3
+ 1.5402ms,0.0V 1.5599ms,0.0
+ 1.5600ms,3.3V 1.5601ms,3.3
+ 1.5602ms,0.0V 1.5799ms,0.0
+ 1.5800ms,3.3V 1.5801ms,3.3
+ 1.5802ms,0.0V 1.5999ms,0.0
+ 1.6000ms,3.3V 1.6001ms,3.3
+ 1.6002ms,0.0V 1.6199ms,0.0
+ 1.6200ms,3.3V 1.6201ms,3.3
+ 1.6202ms,0.0V 1.6399ms,0.0
+ 1.6400ms,3.3V 1.6401ms,3.3
+ 1.6402ms,0.0V 1.6599ms,0.0
+ 1.6600ms,3.3V 1.6601ms,3.3
+ 1.6602ms,0.0V 1.6799ms,0.0
+ 1.6800ms,3.3V 1.6801ms,3.3
+ 1.6802ms,0.0V 1.6999ms,0.0
+ 1.7000ms,3.3V 1.7001ms,3.3
+ 1.7002ms,0.0V 1.7199ms,0.0
+ 1.7200ms,3.3V 1.7201ms,3.3
+ 1.7202ms,0.0V 1.7399ms,0.0
+ 1.7400ms,3.3V 1.7401ms,3.3
+ 1.7402ms,0.0V 1.7599ms,0.0
+ 1.7600ms,3.3V 1.7601ms,3.3
+ 1.7602ms,0.0V 1.7799ms,0.0
+ 1.7800ms,3.3V 1.7801ms,3.3
+ 1.7802ms,0.0V 1.7999ms,0.0
+ 1.8000ms,3.3V 1.8001ms,3.3
+ 1.8002ms,0.0V 1.8199ms,0.0
+ 1.8200ms,3.3V 1.8201ms,3.3
+ 1.8202ms,0.0V 1.8399ms,0.0
+ 1.8400ms,3.3V 1.8401ms,3.3
+ 1.8402ms,0.0V 1.8599ms,0.0
+ 1.8600ms,3.3V 1.8601ms,3.3
+ 1.8602ms,0.0V 1.8799ms,0.0
+ 1.8800ms,3.3V 1.8801ms,3.3
+ 1.8802ms,0.0V 1.8999ms,0.0
+ 1.9000ms,3.3V 1.9001ms,3.3
+ 1.9002ms,0.0V 1.9199ms,0.0
+ 1.9200ms,3.3V 1.9201ms,3.3
+ 1.9202ms,0.0V 1.9399ms,0.0
+ 1.9400ms,3.3V 1.9401ms,3.3
+ 1.9402ms,0.0V 1.9599ms,0.0
+ 1.9600ms,3.3V 1.9601ms,3.3
+ 1.9602ms,0.0V 1.9799ms,0.0
+ 1.9800ms,3.3V 1.9801ms,3.3
+ 1.9802ms,0.0V 1.9999ms,0.0
+ 2.0000ms,3.3V 2.0001ms,3.3
+ 2.0002ms,0.0V 2.0199ms,0.0
+ 2.0200ms,3.3V 2.0201ms,3.3
+ 2.0202ms,0.0V 2.0399ms,0.0
+ 2.0400ms,3.3V 2.0401ms,3.3
+ 2.0402ms,0.0V 2.0599ms,0.0
+ 2.0600ms,3.3V 2.0601ms,3.3
+ 2.0602ms,0.0V 2.0799ms,0.0
+ 2.0800ms,3.3V 2.0801ms,3.3
+ 2.0802ms,0.0V 2.0999ms,0.0
+ 2.1000ms,3.3V 2.1001ms,3.3
+ 2.1002ms,0.0V 2.1199ms,0.0
+ 2.1200ms,3.3V 2.1201ms,3.3
+ 2.1202ms,0.0V 2.1399ms,0.0
+ 2.1400ms,3.3V 2.1401ms,3.3
+ 2.1402ms,0.0V 2.1599ms,0.0
+ 2.1600ms,3.3V 2.1601ms,3.3
+ 2.1602ms,0.0V 2.1799ms,0.0
+ 2.1800ms,3.3V 2.1801ms,3.3
+ 2.1802ms,0.0V 2.1999ms,0.0
+ 2.2000ms,3.3V 2.2001ms,3.3
+ 2.2002ms,0.0V 2.2199ms,0.0
+ 2.2200ms,3.3V 2.2201ms,3.3
+ 2.2202ms,0.0V 2.2399ms,0.0
+ 2.2400ms,3.3V 2.2401ms,3.3
+ 2.2402ms,0.0V 2.2599ms,0.0
+ 2.2600ms,3.3V 2.2601ms,3.3
+ 2.2602ms,0.0V 2.2799ms,0.0
+ 2.2800ms,3.3V 2.2801ms,3.3
+ 2.2802ms,0.0V 2.2999ms,0.0
+ 2.3000ms,3.3V 2.3001ms,3.3
+ 2.3002ms,0.0V 2.3199ms,0.0
+ 2.3200ms,3.3V 2.3201ms,3.3
+ 2.3202ms,0.0V 2.3399ms,0.0
+ 2.3400ms,3.3V 2.3401ms,3.3
+ 2.3402ms,0.0V 2.3599ms,0.0
+ 2.3600ms,3.3V 2.3601ms,3.3
+ 2.3602ms,0.0V 2.3799ms,0.0
+ 2.3800ms,3.3V 2.3801ms,3.3
+ 2.3802ms,0.0V 2.3999ms,0.0
+ 2.4000ms,3.3V 2.4001ms,3.3
+ 2.4002ms,0.0V 2.4199ms,0.0
+ 2.4200ms,3.3V 2.4201ms,3.3
+ 2.4202ms,0.0V 2.4399ms,0.0
+ 2.4400ms,3.3V 2.4401ms,3.3
+ 2.4402ms,0.0V 2.4599ms,0.0
+ 2.4600ms,3.3V 2.4601ms,3.3
+ 2.4602ms,0.0V 2.4799ms,0.0
+ 2.4800ms,3.3V 2.4801ms,3.3
+ 2.4802ms,0.0V 2.4999ms,0.0
+ 2.5000ms,3.3V 2.5001ms,3.3
+ 2.5002ms,0.0V 2.5199ms,0.0
+ 2.5200ms,3.3V 2.5201ms,3.3
+ 2.5202ms,0.0V 2.5399ms,0.0
+ 2.5400ms,3.3V 2.5401ms,3.3
+ 2.5402ms,0.0V 2.5599ms,0.0
+ 2.5600ms,3.3V 2.5601ms,3.3
+ 2.5602ms,0.0V 2.5799ms,0.0
+ 2.5800ms,3.3V 2.5801ms,3.3
+ 2.5802ms,0.0V 2.5999ms,0.0
+ 2.6000ms,3.3V 2.6001ms,3.3
+ 2.6002ms,0.0V 2.6199ms,0.0
+ 2.6200ms,3.3V 2.6201ms,3.3
+ 2.6202ms,0.0V 2.6399ms,0.0
+ 2.6400ms,3.3V 2.6401ms,3.3
+ 2.6402ms,0.0V 2.6599ms,0.0
+ 2.6600ms,3.3V 2.6601ms,3.3
+ 2.6602ms,0.0V 2.6799ms,0.0
+ 2.6800ms,3.3V 2.6801ms,3.3
+ 2.6802ms,0.0V 2.6999ms,0.0
+ 2.7000ms,3.3V 2.7001ms,3.3
+ 2.7002ms,0.0V 2.7199ms,0.0
+ 2.7200ms,3.3V 2.7201ms,3.3
+ 2.7202ms,0.0V 2.7399ms,0.0
+ 2.7400ms,3.3V 2.7401ms,3.3
+ 2.7402ms,0.0V 2.7599ms,0.0
+ 2.7600ms,3.3V 2.7601ms,3.3
+ 2.7602ms,0.0V 2.7799ms,0.0
+ 2.7800ms,3.3V 2.7801ms,3.3
+ 2.7802ms,0.0V 2.7999ms,0.0
+ 2.8000ms,3.3V 2.8001ms,3.3
+ 2.8002ms,0.0V 2.8199ms,0.0
+ 2.8200ms,3.3V 2.8201ms,3.3
+ 2.8202ms,0.0V 2.8399ms,0.0
+ 2.8400ms,3.3V 2.8401ms,3.3
+ 2.8402ms,0.0V 2.8599ms,0.0
+ 2.8600ms,3.3V 2.8601ms,3.3
+ 2.8602ms,0.0V 2.8799ms,0.0
+ 2.8800ms,3.3V 2.8801ms,3.3
+ 2.8802ms,0.0V 2.8999ms,0.0
+ 2.9000ms,3.3V 2.9001ms,3.3
+ 2.9002ms,0.0V 2.9199ms,0.0
+ 2.9200ms,3.3V 2.9201ms,3.3
+ 2.9202ms,0.0V 2.9399ms,0.0
+ 2.9400ms,3.3V 2.9401ms,3.3
+ 2.9402ms,0.0V 2.9599ms,0.0
+ 2.9600ms,3.3V 2.9601ms,3.3
+ 2.9602ms,0.0V 2.9799ms,0.0
+ 2.9800ms,3.3V 2.9801ms,3.3
+ 2.9802ms,0.0V 2.9999ms,0.0
+ 3.0000ms,3.3V 3.0001ms,3.3
+ 3.0002ms,0.0V 3.0199ms,0.0
+ 3.0200ms,3.3V 3.0201ms,3.3
+ 3.0202ms,0.0V 3.0399ms,0.0
+ 3.0400ms,3.3V 3.0401ms,3.3
+ 3.0402ms,0.0V 3.0599ms,0.0
+ 3.0600ms,3.3V 3.0601ms,3.3
+ 3.0602ms,0.0V 3.0799ms,0.0
+ 3.0800ms,3.3V 3.0801ms,3.3
+ 3.0802ms,0.0V 3.0999ms,0.0
+ 3.1000ms,3.3V 3.1001ms,3.3
+ 3.1002ms,0.0V 3.1199ms,0.0
+ 3.1200ms,3.3V 3.1201ms,3.3
+ 3.1202ms,0.0V 3.1399ms,0.0
+ 3.1400ms,3.3V 3.1401ms,3.3
+ 3.1402ms,0.0V 3.1599ms,0.0
+ 3.1600ms,3.3V 3.1601ms,3.3
+ 3.1602ms,0.0V 3.1799ms,0.0
+ 3.1800ms,3.3V 3.1801ms,3.3
+ 3.1802ms,0.0V 3.1999ms,0.0
+ 3.2000ms,3.3V 3.2001ms,3.3
+ 3.2002ms,0.0V 3.2199ms,0.0
+ 3.2200ms,3.3V 3.2201ms,3.3
+ 3.2202ms,0.0V 3.2399ms,0.0
+ 3.2400ms,3.3V 3.2401ms,3.3
+ 3.2402ms,0.0V 3.2599ms,0.0
+ 3.2600ms,3.3V 3.2601ms,3.3
+ 3.2602ms,0.0V 3.2799ms,0.0
+ 3.2800ms,3.3V 3.2801ms,3.3
+ 3.2802ms,0.0V 3.2999ms,0.0
+ 3.3000ms,3.3V 3.3001ms,3.3
+ 3.3002ms,0.0V 3.3199ms,0.0
+ 3.3200ms,3.3V 3.3201ms,3.3
+ 3.3202ms,0.0V 3.3399ms,0.0
+ 3.3400ms,3.3V 3.3401ms,3.3
+ 3.3402ms,0.0V 3.3599ms,0.0
+ 3.3600ms,3.3V 3.3601ms,3.3
+ 3.3602ms,0.0V 3.3799ms,0.0
+ 3.3800ms,3.3V 3.3801ms,3.3
+ 3.3802ms,0.0V 3.3999ms,0.0
+ 3.4000ms,3.3V 3.4001ms,3.3
+ 3.4002ms,0.0V 3.4199ms,0.0
+ 3.4200ms,3.3V 3.4201ms,3.3
+ 3.4202ms,0.0V 3.4399ms,0.0
+ 3.4400ms,3.3V 3.4401ms,3.3
+ 3.4402ms,0.0V 3.4599ms,0.0
+ 3.4600ms,3.3V 3.4601ms,3.3
+ 3.4602ms,0.0V 3.4799ms,0.0
+ 3.4800ms,3.3V 3.4801ms,3.3
+ 3.4802ms,0.0V 3.4999ms,0.0
+ 3.5000ms,3.3V 3.5001ms,3.3
+ 3.5002ms,0.0V 3.5199ms,0.0
+ 3.5200ms,3.3V 3.5201ms,3.3
+ 3.5202ms,0.0V 3.5399ms,0.0
+ 3.5400ms,3.3V 3.5401ms,3.3
+ 3.5402ms,0.0V 3.5599ms,0.0
+ 3.5600ms,3.3V 3.5601ms,3.3
+ 3.5602ms,0.0V 3.5799ms,0.0
+ 3.5800ms,3.3V 3.5801ms,3.3
+ 3.5802ms,0.0V 3.5999ms,0.0
+ 3.6000ms,3.3V 3.6001ms,3.3
+ 3.6002ms,0.0V 3.6199ms,0.0
+ 3.6200ms,3.3V 3.6201ms,3.3
+ 3.6202ms,0.0V 3.6399ms,0.0
+ 3.6400ms,3.3V 3.6401ms,3.3
+ 3.6402ms,0.0V 3.6599ms,0.0
+ 3.6600ms,3.3V 3.6601ms,3.3
+ 3.6602ms,0.0V 3.6799ms,0.0
+ 3.6800ms,3.3V 3.6801ms,3.3
+ 3.6802ms,0.0V 3.6999ms,0.0
+ 3.7000ms,3.3V 3.7001ms,3.3
+ 3.7002ms,0.0V 3.7199ms,0.0
+ 3.7200ms,3.3V 3.7201ms,3.3
+ 3.7202ms,0.0V 3.7399ms,0.0
+ 3.7400ms,3.3V 3.7401ms,3.3
+ 3.7402ms,0.0V 3.7599ms,0.0
+ 3.7600ms,3.3V 3.7601ms,3.3
+ 3.7602ms,0.0V 3.7799ms,0.0
+ 3.7800ms,3.3V 3.7801ms,3.3
+ 3.7802ms,0.0V 3.7999ms,0.0
+ 3.8000ms,3.3V 3.8001ms,3.3
+ 3.8002ms,0.0V 3.8199ms,0.0
+ 3.8200ms,3.3V 3.8201ms,3.3
+ 3.8202ms,0.0V 3.8399ms,0.0
+ 3.8400ms,3.3V 3.8401ms,3.3
+ 3.8402ms,0.0V 3.8599ms,0.0
+ 3.8600ms,3.3V 3.8601ms,3.3
+ 3.8602ms,0.0V 3.8799ms,0.0
+ 3.8800ms,3.3V 3.8801ms,3.3
+ 3.8802ms,0.0V 3.8999ms,0.0
+ 3.9000ms,3.3V 3.9001ms,3.3
+ 3.9002ms,0.0V 3.9199ms,0.0
+ 3.9200ms,3.3V 3.9201ms,3.3
+ 3.9202ms,0.0V 3.9399ms,0.0
+ 3.9400ms,3.3V 3.9401ms,3.3
+ 3.9402ms,0.0V 3.9599ms,0.0
+ 3.9600ms,3.3V 3.9601ms,3.3
+ 3.9602ms,0.0V 3.9799ms,0.0
+ 3.9800ms,3.3V 3.9801ms,3.3
+ 3.9802ms,0.0V 3.9999ms,0.0
+ 4.0000ms,3.3V 4.0001ms,3.3
+ 4.0002ms,0.0V 4.0199ms,0.0
+ 4.0200ms,3.3V 4.0201ms,3.3
+ 4.0202ms,0.0V 4.0399ms,0.0
+ 4.0400ms,3.3V 4.0401ms,3.3
+ 4.0402ms,0.0V 4.0599ms,0.0
+ 4.0600ms,3.3V 4.0601ms,3.3
+ 4.0602ms,0.0V 4.0799ms,0.0
+ 4.0800ms,3.3V 4.0801ms,3.3
+ 4.0802ms,0.0V 4.0999ms,0.0
+ 4.1000ms,3.3V 4.1001ms,3.3
+ 4.1002ms,0.0V 4.1199ms,0.0
+ 4.1200ms,3.3V 4.1201ms,3.3
+ 4.1202ms,0.0V 4.1399ms,0.0
+ 4.1400ms,3.3V 4.1401ms,3.3
+ 4.1402ms,0.0V 4.1599ms,0.0
+ 4.1600ms,3.3V 4.1601ms,3.3
+ 4.1602ms,0.0V 4.1799ms,0.0
+ 4.1800ms,3.3V 4.1801ms,3.3
+ 4.1802ms,0.0V 4.1999ms,0.0
+ 4.2000ms,3.3V 4.2001ms,3.3
+ 4.2002ms,0.0V 4.2199ms,0.0
+ 4.2200ms,3.3V 4.2201ms,3.3
+ 4.2202ms,0.0V 4.2399ms,0.0
+ 4.2400ms,3.3V 4.2401ms,3.3
+ 4.2402ms,0.0V 4.2599ms,0.0
+ 4.2600ms,3.3V 4.2601ms,3.3
+ 4.2602ms,0.0V 4.2799ms,0.0
+ 4.2800ms,3.3V 4.2801ms,3.3
+ 4.2802ms,0.0V 4.2999ms,0.0
+ 4.3000ms,3.3V 4.3001ms,3.3
+ 4.3002ms,0.0V 4.3199ms,0.0
+ 4.3200ms,3.3V 4.3201ms,3.3
+ 4.3202ms,0.0V 4.3399ms,0.0
+ 4.3400ms,3.3V 4.3401ms,3.3
+ 4.3402ms,0.0V 4.3599ms,0.0
+ 4.3600ms,3.3V 4.3601ms,3.3
+ 4.3602ms,0.0V 4.3799ms,0.0
+ 4.3800ms,3.3V 4.3801ms,3.3
+ 4.3802ms,0.0V 4.3999ms,0.0
+ 4.4000ms,3.3V 4.4001ms,3.3
+ 4.4002ms,0.0V 4.4199ms,0.0
+ 4.4200ms,3.3V 4.4201ms,3.3
+ 4.4202ms,0.0V 4.4399ms,0.0
+ 4.4400ms,3.3V 4.4401ms,3.3
+ 4.4402ms,0.0V 4.4599ms,0.0
+ 4.4600ms,3.3V 4.4601ms,3.3
+ 4.4602ms,0.0V 4.4799ms,0.0
+ 4.4800ms,3.3V 4.4801ms,3.3
+ 4.4802ms,0.0V 4.4999ms,0.0
+ 4.5000ms,3.3V 4.5001ms,3.3
+ 4.5002ms,0.0V 4.5199ms,0.0
+ 4.5200ms,3.3V 4.5201ms,3.3
+ 4.5202ms,0.0V 4.5399ms,0.0
+ 4.5400ms,3.3V 4.5401ms,3.3
+ 4.5402ms,0.0V 4.5599ms,0.0
+ 4.5600ms,3.3V 4.5601ms,3.3
+ 4.5602ms,0.0V 4.5799ms,0.0
+ 4.5800ms,3.3V 4.5801ms,3.3
+ 4.5802ms,0.0V 4.5999ms,0.0
+ 4.6000ms,3.3V 4.6001ms,3.3
+ 4.6002ms,0.0V 4.6199ms,0.0
+ 4.6200ms,3.3V 4.6201ms,3.3
+ 4.6202ms,0.0V 4.6399ms,0.0
+ 4.6400ms,3.3V 4.6401ms,3.3
+ 4.6402ms,0.0V 4.6599ms,0.0
+ 4.6600ms,3.3V 4.6601ms,3.3
+ 4.6602ms,0.0V 4.6799ms,0.0
+ 4.6800ms,3.3V 4.6801ms,3.3
+ 4.6802ms,0.0V 4.6999ms,0.0
+ 4.7000ms,3.3V 4.7001ms,3.3
+ 4.7002ms,0.0V 4.7199ms,0.0
+ 4.7200ms,3.3V 4.7201ms,3.3
+ 4.7202ms,0.0V 4.7399ms,0.0
+ 4.7400ms,3.3V 4.7401ms,3.3
+ 4.7402ms,0.0V 4.7599ms,0.0
+ 4.7600ms,3.3V 4.7601ms,3.3
+ 4.7602ms,0.0V 4.7799ms,0.0
+ 4.7800ms,3.3V 4.7801ms,3.3
+ 4.7802ms,0.0V 4.7999ms,0.0
+ 4.8000ms,3.3V 4.8001ms,3.3
+ 4.8002ms,0.0V 4.8199ms,0.0
+ 4.8200ms,3.3V 4.8201ms,3.3
+ 4.8202ms,0.0V 4.8399ms,0.0
+ 4.8400ms,3.3V 4.8401ms,3.3
+ 4.8402ms,0.0V 4.8599ms,0.0
+ 4.8600ms,3.3V 4.8601ms,3.3
+ 4.8602ms,0.0V 4.8799ms,0.0
+ 4.8800ms,3.3V 4.8801ms,3.3
+ 4.8802ms,0.0V 4.8999ms,0.0
+ 4.9000ms,3.3V 4.9001ms,3.3
+ 4.9002ms,0.0V 4.9199ms,0.0
+ 4.9200ms,3.3V 4.9201ms,3.3
+ 4.9202ms,0.0V 4.9399ms,0.0
+ 4.9400ms,3.3V 4.9401ms,3.3
+ 4.9402ms,0.0V 4.9599ms,0.0
+ 4.9600ms,3.3V 4.9601ms,3.3
+ 4.9602ms,0.0V 4.9799ms,0.0
+ 4.9800ms,3.3V 4.9801ms,3.3
+ 4.9802ms,0.0V 4.9999ms,0.0
+ 5.0000ms,3.3V 5.0001ms,3.3
+ 5.0002ms,0.0V 5.0199ms,0.0
+ 5.0200ms,3.3V 5.0203ms,3.3
+ 5.0204ms,0.0V 5.0399ms,0.0
+ 5.0400ms,3.3V 5.0403ms,3.3
+ 5.0404ms,0.0V 5.0599ms,0.0
+ 5.0600ms,3.3V 5.0603ms,3.3
+ 5.0604ms,0.0V 5.0799ms,0.0
+ 5.0800ms,3.3V 5.0803ms,3.3
+ 5.0804ms,0.0V 5.0999ms,0.0
+ 5.1000ms,3.3V 5.1003ms,3.3
+ 5.1004ms,0.0V 5.1199ms,0.0
+ 5.1200ms,3.3V 5.1203ms,3.3
+ 5.1204ms,0.0V 5.1399ms,0.0
+ 5.1400ms,3.3V 5.1403ms,3.3
+ 5.1404ms,0.0V 5.1599ms,0.0
+ 5.1600ms,3.3V 5.1603ms,3.3
+ 5.1604ms,0.0V 5.1799ms,0.0
+ 5.1800ms,3.3V 5.1803ms,3.3
+ 5.1804ms,0.0V 5.1999ms,0.0
+ 5.2000ms,3.3V 5.2003ms,3.3
+ 5.2004ms,0.0V 5.2199ms,0.0
+ 5.2200ms,3.3V 5.2203ms,3.3
+ 5.2204ms,0.0V 5.2399ms,0.0
+ 5.2400ms,3.3V 5.2403ms,3.3
+ 5.2404ms,0.0V 5.2599ms,0.0
+ 5.2600ms,3.3V 5.2603ms,3.3
+ 5.2604ms,0.0V 5.2799ms,0.0
+ 5.2800ms,3.3V 5.2803ms,3.3
+ 5.2804ms,0.0V 5.2999ms,0.0
+ 5.3000ms,3.3V 5.3003ms,3.3
+ 5.3004ms,0.0V 5.3199ms,0.0
+ 5.3200ms,3.3V 5.3203ms,3.3
+ 5.3204ms,0.0V 5.3399ms,0.0
+ 5.3400ms,3.3V 5.3403ms,3.3
+ 5.3404ms,0.0V 5.3599ms,0.0
+ 5.3600ms,3.3V 5.3603ms,3.3
+ 5.3604ms,0.0V 5.3799ms,0.0
+ 5.3800ms,3.3V 5.3803ms,3.3
+ 5.3804ms,0.0V 5.3999ms,0.0
+ 5.4000ms,3.3V 5.4003ms,3.3
+ 5.4004ms,0.0V 5.4199ms,0.0
+ 5.4200ms,3.3V 5.4203ms,3.3
+ 5.4204ms,0.0V 5.4399ms,0.0
+ 5.4400ms,3.3V 5.4403ms,3.3
+ 5.4404ms,0.0V 5.4599ms,0.0
+ 5.4600ms,3.3V 5.4603ms,3.3
+ 5.4604ms,0.0V 5.4799ms,0.0
+ 5.4800ms,3.3V 5.4803ms,3.3
+ 5.4804ms,0.0V 5.4999ms,0.0
+ 5.5000ms,3.3V 5.5003ms,3.3
+ 5.5004ms,0.0V 5.5199ms,0.0
+ 5.5200ms,3.3V 5.5203ms,3.3
+ 5.5204ms,0.0V 5.5399ms,0.0
+ 5.5400ms,3.3V 5.5403ms,3.3
+ 5.5404ms,0.0V 5.5599ms,0.0
+ 5.5600ms,3.3V 5.5603ms,3.3
+ 5.5604ms,0.0V 5.5799ms,0.0
+ 5.5800ms,3.3V 5.5803ms,3.3
+ 5.5804ms,0.0V 5.5999ms,0.0
+ 5.6000ms,3.3V 5.6003ms,3.3
+ 5.6004ms,0.0V 5.6199ms,0.0
+ 5.6200ms,3.3V 5.6203ms,3.3
+ 5.6204ms,0.0V 5.6399ms,0.0
+ 5.6400ms,3.3V 5.6403ms,3.3
+ 5.6404ms,0.0V 5.6599ms,0.0
+ 5.6600ms,3.3V 5.6603ms,3.3
+ 5.6604ms,0.0V 5.6799ms,0.0
+ 5.6800ms,3.3V 5.6803ms,3.3
+ 5.6804ms,0.0V 5.6999ms,0.0
+ 5.7000ms,3.3V 5.7003ms,3.3
+ 5.7004ms,0.0V 5.7199ms,0.0
+ 5.7200ms,3.3V 5.7203ms,3.3
+ 5.7204ms,0.0V 5.7399ms,0.0
+ 5.7400ms,3.3V 5.7403ms,3.3
+ 5.7404ms,0.0V 5.7599ms,0.0
+ 5.7600ms,3.3V 5.7603ms,3.3
+ 5.7604ms,0.0V 5.7799ms,0.0
+ 5.7800ms,3.3V 5.7803ms,3.3
+ 5.7804ms,0.0V 5.7999ms,0.0
+ 5.8000ms,3.3V 5.8003ms,3.3
+ 5.8004ms,0.0V 5.8199ms,0.0
+ 5.8200ms,3.3V 5.8203ms,3.3
+ 5.8204ms,0.0V 5.8399ms,0.0
+ 5.8400ms,3.3V 5.8403ms,3.3
+ 5.8404ms,0.0V 5.8599ms,0.0
+ 5.8600ms,3.3V 5.8603ms,3.3
+ 5.8604ms,0.0V 5.8799ms,0.0
+ 5.8800ms,3.3V 5.8803ms,3.3
+ 5.8804ms,0.0V 5.8999ms,0.0
+ 5.9000ms,3.3V 5.9003ms,3.3
+ 5.9004ms,0.0V 5.9199ms,0.0
+ 5.9200ms,3.3V 5.9203ms,3.3
+ 5.9204ms,0.0V 5.9399ms,0.0
+ 5.9400ms,3.3V 5.9403ms,3.3
+ 5.9404ms,0.0V 5.9599ms,0.0
+ 5.9600ms,3.3V 5.9603ms,3.3
+ 5.9604ms,0.0V 5.9799ms,0.0
+ 5.9800ms,3.3V 5.9803ms,3.3
+ 5.9804ms,0.0V 5.9999ms,0.0
+ 6.0000ms,3.3V 6.0003ms,3.3
+ 6.0004ms,0.0V 6.0199ms,0.0
+ 6.0200ms,3.3V 6.0203ms,3.3
+ 6.0204ms,0.0V 6.0399ms,0.0
+ 6.0400ms,3.3V 6.0403ms,3.3
+ 6.0404ms,0.0V 6.0599ms,0.0
+ 6.0600ms,3.3V 6.0603ms,3.3
+ 6.0604ms,0.0V 6.0799ms,0.0
+ 6.0800ms,3.3V 6.0803ms,3.3
+ 6.0804ms,0.0V 6.0999ms,0.0
+ 6.1000ms,3.3V 6.1003ms,3.3
+ 6.1004ms,0.0V 6.1199ms,0.0
+ 6.1200ms,3.3V 6.1203ms,3.3
+ 6.1204ms,0.0V 6.1399ms,0.0
+ 6.1400ms,3.3V 6.1403ms,3.3
+ 6.1404ms,0.0V 6.1599ms,0.0
+ 6.1600ms,3.3V 6.1603ms,3.3
+ 6.1604ms,0.0V 6.1799ms,0.0
+ 6.1800ms,3.3V 6.1803ms,3.3
+ 6.1804ms,0.0V 6.1999ms,0.0
+ 6.2000ms,3.3V 6.2003ms,3.3
+ 6.2004ms,0.0V 6.2199ms,0.0
+ 6.2200ms,3.3V 6.2203ms,3.3
+ 6.2204ms,0.0V 6.2399ms,0.0
+ 6.2400ms,3.3V 6.2403ms,3.3
+ 6.2404ms,0.0V 6.2599ms,0.0
+ 6.2600ms,3.3V 6.2603ms,3.3
+ 6.2604ms,0.0V 6.2799ms,0.0
+ 6.2800ms,3.3V 6.2803ms,3.3
+ 6.2804ms,0.0V 6.2999ms,0.0
+ 6.3000ms,3.3V 6.3003ms,3.3
+ 6.3004ms,0.0V 6.3199ms,0.0
+ 6.3200ms,3.3V 6.3203ms,3.3
+ 6.3204ms,0.0V 6.3399ms,0.0
+ 6.3400ms,3.3V 6.3403ms,3.3
+ 6.3404ms,0.0V 6.3599ms,0.0
+ 6.3600ms,3.3V 6.3603ms,3.3
+ 6.3604ms,0.0V 6.3799ms,0.0
+ 6.3800ms,3.3V 6.3803ms,3.3
+ 6.3804ms,0.0V 6.3999ms,0.0
+ 6.4000ms,3.3V 6.4003ms,3.3
+ 6.4004ms,0.0V 6.4199ms,0.0
+ 6.4200ms,3.3V 6.4203ms,3.3
+ 6.4204ms,0.0V 6.4399ms,0.0
+ 6.4400ms,3.3V 6.4403ms,3.3
+ 6.4404ms,0.0V 6.4599ms,0.0
+ 6.4600ms,3.3V 6.4603ms,3.3
+ 6.4604ms,0.0V 6.4799ms,0.0
+ 6.4800ms,3.3V 6.4803ms,3.3
+ 6.4804ms,0.0V 6.4999ms,0.0
+ 6.5000ms,3.3V 6.5003ms,3.3
+ 6.5004ms,0.0V 6.5199ms,0.0
+ 6.5200ms,3.3V 6.5203ms,3.3
+ 6.5204ms,0.0V 6.5399ms,0.0
+ 6.5400ms,3.3V 6.5403ms,3.3
+ 6.5404ms,0.0V 6.5599ms,0.0
+ 6.5600ms,3.3V 6.5603ms,3.3
+ 6.5604ms,0.0V 6.5799ms,0.0
+ 6.5800ms,3.3V 6.5803ms,3.3
+ 6.5804ms,0.0V 6.5999ms,0.0
+ 6.6000ms,3.3V 6.6003ms,3.3
+ 6.6004ms,0.0V 6.6199ms,0.0
+ 6.6200ms,3.3V 6.6203ms,3.3
+ 6.6204ms,0.0V 6.6399ms,0.0
+ 6.6400ms,3.3V 6.6403ms,3.3
+ 6.6404ms,0.0V 6.6599ms,0.0
+ 6.6600ms,3.3V 6.6603ms,3.3
+ 6.6604ms,0.0V 6.6799ms,0.0
+ 6.6800ms,3.3V 6.6803ms,3.3
+ 6.6804ms,0.0V 6.6999ms,0.0
+ 6.7000ms,3.3V 6.7003ms,3.3
+ 6.7004ms,0.0V 6.7199ms,0.0
+ 6.7200ms,3.3V 6.7203ms,3.3
+ 6.7204ms,0.0V 6.7399ms,0.0
+ 6.7400ms,3.3V 6.7403ms,3.3
+ 6.7404ms,0.0V 6.7599ms,0.0
+ 6.7600ms,3.3V 6.7603ms,3.3
+ 6.7604ms,0.0V 6.7799ms,0.0
+ 6.7800ms,3.3V 6.7803ms,3.3
+ 6.7804ms,0.0V 6.7999ms,0.0
+ 6.8000ms,3.3V 6.8003ms,3.3
+ 6.8004ms,0.0V 6.8199ms,0.0
+ 6.8200ms,3.3V 6.8203ms,3.3
+ 6.8204ms,0.0V 6.8399ms,0.0
+ 6.8400ms,3.3V 6.8403ms,3.3
+ 6.8404ms,0.0V 6.8599ms,0.0
+ 6.8600ms,3.3V 6.8603ms,3.3
+ 6.8604ms,0.0V 6.8799ms,0.0
+ 6.8800ms,3.3V 6.8803ms,3.3
+ 6.8804ms,0.0V 6.8999ms,0.0
+ 6.9000ms,3.3V 6.9003ms,3.3
+ 6.9004ms,0.0V 6.9199ms,0.0
+ 6.9200ms,3.3V 6.9203ms,3.3
+ 6.9204ms,0.0V 6.9399ms,0.0
+ 6.9400ms,3.3V 6.9403ms,3.3
+ 6.9404ms,0.0V 6.9599ms,0.0
+ 6.9600ms,3.3V 6.9603ms,3.3
+ 6.9604ms,0.0V 6.9799ms,0.0
+ 6.9800ms,3.3V 6.9803ms,3.3
+ 6.9804ms,0.0V 6.9999ms,0.0
+ 7.0000ms,3.3V 7.0003ms,3.3
+ 7.0004ms,0.0V 7.0199ms,0.0
+ 7.0200ms,3.3V 7.0203ms,3.3
+ 7.0204ms,0.0V 7.0399ms,0.0
+ 7.0400ms,3.3V 7.0403ms,3.3
+ 7.0404ms,0.0V 7.0599ms,0.0
+ 7.0600ms,3.3V 7.0603ms,3.3
+ 7.0604ms,0.0V 7.0799ms,0.0
+ 7.0800ms,3.3V 7.0803ms,3.3
+ 7.0804ms,0.0V 7.0999ms,0.0
+ 7.1000ms,3.3V 7.1003ms,3.3
+ 7.1004ms,0.0V 7.1199ms,0.0
+ 7.1200ms,3.3V 7.1203ms,3.3
+ 7.1204ms,0.0V 7.1399ms,0.0
+ 7.1400ms,3.3V 7.1403ms,3.3
+ 7.1404ms,0.0V 7.1599ms,0.0
+ 7.1600ms,3.3V 7.1603ms,3.3
+ 7.1604ms,0.0V 7.1799ms,0.0
+ 7.1800ms,3.3V 7.1803ms,3.3
+ 7.1804ms,0.0V 7.1999ms,0.0
+ 7.2000ms,3.3V 7.2003ms,3.3
+ 7.2004ms,0.0V 7.2199ms,0.0
+ 7.2200ms,3.3V 7.2203ms,3.3
+ 7.2204ms,0.0V 7.2399ms,0.0
+ 7.2400ms,3.3V 7.2403ms,3.3
+ 7.2404ms,0.0V 7.2599ms,0.0
+ 7.2600ms,3.3V 7.2603ms,3.3
+ 7.2604ms,0.0V 7.2799ms,0.0
+ 7.2800ms,3.3V 7.2803ms,3.3
+ 7.2804ms,0.0V 7.2999ms,0.0
+ 7.3000ms,3.3V 7.3003ms,3.3
+ 7.3004ms,0.0V 7.3199ms,0.0
+ 7.3200ms,3.3V 7.3203ms,3.3
+ 7.3204ms,0.0V 7.3399ms,0.0
+ 7.3400ms,3.3V 7.3403ms,3.3
+ 7.3404ms,0.0V 7.3599ms,0.0
+ 7.3600ms,3.3V 7.3603ms,3.3
+ 7.3604ms,0.0V 7.3799ms,0.0
+ 7.3800ms,3.3V 7.3803ms,3.3
+ 7.3804ms,0.0V 7.3999ms,0.0
+ 7.4000ms,3.3V 7.4003ms,3.3
+ 7.4004ms,0.0V 7.4199ms,0.0
+ 7.4200ms,3.3V 7.4203ms,3.3
+ 7.4204ms,0.0V 7.4399ms,0.0
+ 7.4400ms,3.3V 7.4403ms,3.3
+ 7.4404ms,0.0V 7.4599ms,0.0
+ 7.4600ms,3.3V 7.4603ms,3.3
+ 7.4604ms,0.0V 7.4799ms,0.0
+ 7.4800ms,3.3V 7.4803ms,3.3
+ 7.4804ms,0.0V 7.4999ms,0.0
+ 7.5000ms,3.3V 7.5003ms,3.3
+ 7.5004ms,0.0V 7.5199ms,0.0
+ 7.5200ms,3.3V 7.5203ms,3.3
+ 7.5204ms,0.0V 7.5399ms,0.0
+ 7.5400ms,3.3V 7.5403ms,3.3
+ 7.5404ms,0.0V 7.5599ms,0.0
+ 7.5600ms,3.3V 7.5603ms,3.3
+ 7.5604ms,0.0V 7.5799ms,0.0
+ 7.5800ms,3.3V 7.5803ms,3.3
+ 7.5804ms,0.0V 7.5999ms,0.0
+ 7.6000ms,3.3V 7.6003ms,3.3
+ 7.6004ms,0.0V 7.6199ms,0.0
+ 7.6200ms,3.3V 7.6203ms,3.3
+ 7.6204ms,0.0V 7.6399ms,0.0
+ 7.6400ms,3.3V 7.6403ms,3.3
+ 7.6404ms,0.0V 7.6599ms,0.0
+ 7.6600ms,3.3V 7.6603ms,3.3
+ 7.6604ms,0.0V 7.6799ms,0.0
+ 7.6800ms,3.3V 7.6803ms,3.3
+ 7.6804ms,0.0V 7.6999ms,0.0
+ 7.7000ms,3.3V 7.7003ms,3.3
+ 7.7004ms,0.0V 7.7199ms,0.0
+ 7.7200ms,3.3V 7.7203ms,3.3
+ 7.7204ms,0.0V 7.7399ms,0.0
+ 7.7400ms,3.3V 7.7403ms,3.3
+ 7.7404ms,0.0V 7.7599ms,0.0
+ 7.7600ms,3.3V 7.7603ms,3.3
+ 7.7604ms,0.0V 7.7799ms,0.0
+ 7.7800ms,3.3V 7.7803ms,3.3
+ 7.7804ms,0.0V 7.7999ms,0.0
+ 7.8000ms,3.3V 7.8003ms,3.3
+ 7.8004ms,0.0V 7.8199ms,0.0
+ 7.8200ms,3.3V 7.8203ms,3.3
+ 7.8204ms,0.0V 7.8399ms,0.0
+ 7.8400ms,3.3V 7.8403ms,3.3
+ 7.8404ms,0.0V 7.8599ms,0.0
+ 7.8600ms,3.3V 7.8603ms,3.3
+ 7.8604ms,0.0V 7.8799ms,0.0
+ 7.8800ms,3.3V 7.8803ms,3.3
+ 7.8804ms,0.0V 7.8999ms,0.0
+ 7.9000ms,3.3V 7.9003ms,3.3
+ 7.9004ms,0.0V 7.9199ms,0.0
+ 7.9200ms,3.3V 7.9203ms,3.3
+ 7.9204ms,0.0V 7.9399ms,0.0
+ 7.9400ms,3.3V 7.9403ms,3.3
+ 7.9404ms,0.0V 7.9599ms,0.0
+ 7.9600ms,3.3V 7.9603ms,3.3
+ 7.9604ms,0.0V 7.9799ms,0.0
+ 7.9800ms,3.3V 7.9803ms,3.3
+ 7.9804ms,0.0V 7.9999ms,0.0
+ 8.0000ms,3.3V 8.0003ms,3.3
+ 8.0004ms,0.0V 8.0199ms,0.0
+ 8.0200ms,3.3V 8.0203ms,3.3
+ 8.0204ms,0.0V 8.0399ms,0.0
+ 8.0400ms,3.3V 8.0403ms,3.3
+ 8.0404ms,0.0V 8.0599ms,0.0
+ 8.0600ms,3.3V 8.0603ms,3.3
+ 8.0604ms,0.0V 8.0799ms,0.0
+ 8.0800ms,3.3V 8.0803ms,3.3
+ 8.0804ms,0.0V 8.0999ms,0.0
+ 8.1000ms,3.3V 8.1003ms,3.3
+ 8.1004ms,0.0V 8.1199ms,0.0
+ 8.1200ms,3.3V 8.1203ms,3.3
+ 8.1204ms,0.0V 8.1399ms,0.0
+ 8.1400ms,3.3V 8.1403ms,3.3
+ 8.1404ms,0.0V 8.1599ms,0.0
+ 8.1600ms,3.3V 8.1603ms,3.3
+ 8.1604ms,0.0V 8.1799ms,0.0
+ 8.1800ms,3.3V 8.1803ms,3.3
+ 8.1804ms,0.0V 8.1999ms,0.0
+ 8.2000ms,3.3V 8.2003ms,3.3
+ 8.2004ms,0.0V 8.2199ms,0.0
+ 8.2200ms,3.3V 8.2203ms,3.3
+ 8.2204ms,0.0V 8.2399ms,0.0
+ 8.2400ms,3.3V 8.2403ms,3.3
+ 8.2404ms,0.0V 8.2599ms,0.0
+ 8.2600ms,3.3V 8.2603ms,3.3
+ 8.2604ms,0.0V 8.2799ms,0.0
+ 8.2800ms,3.3V 8.2803ms,3.3
+ 8.2804ms,0.0V 8.2999ms,0.0
+ 8.3000ms,3.3V 8.3003ms,3.3
+ 8.3004ms,0.0V 8.3199ms,0.0
+ 8.3200ms,3.3V 8.3203ms,3.3
+ 8.3204ms,0.0V 8.3399ms,0.0
+ 8.3400ms,3.3V 8.3403ms,3.3
+ 8.3404ms,0.0V 8.3599ms,0.0
+ 8.3600ms,3.3V 8.3603ms,3.3
+ 8.3604ms,0.0V 8.3799ms,0.0
+ 8.3800ms,3.3V 8.3803ms,3.3
+ 8.3804ms,0.0V 8.3999ms,0.0
+ 8.4000ms,3.3V 8.4003ms,3.3
+ 8.4004ms,0.0V 8.4199ms,0.0
+ 8.4200ms,3.3V 8.4203ms,3.3
+ 8.4204ms,0.0V 8.4399ms,0.0
+ 8.4400ms,3.3V 8.4403ms,3.3
+ 8.4404ms,0.0V 8.4599ms,0.0
+ 8.4600ms,3.3V 8.4603ms,3.3
+ 8.4604ms,0.0V 8.4799ms,0.0
+ 8.4800ms,3.3V 8.4803ms,3.3
+ 8.4804ms,0.0V 8.4999ms,0.0
+ 8.5000ms,3.3V 8.5003ms,3.3
+ 8.5004ms,0.0V 8.5199ms,0.0
+ 8.5200ms,3.3V 8.5203ms,3.3
+ 8.5204ms,0.0V 8.5399ms,0.0
+ 8.5400ms,3.3V 8.5403ms,3.3
+ 8.5404ms,0.0V 8.5599ms,0.0
+ 8.5600ms,3.3V 8.5603ms,3.3
+ 8.5604ms,0.0V 8.5799ms,0.0
+ 8.5800ms,3.3V 8.5803ms,3.3
+ 8.5804ms,0.0V 8.5999ms,0.0
+ 8.6000ms,3.3V 8.6003ms,3.3
+ 8.6004ms,0.0V 8.6199ms,0.0
+ 8.6200ms,3.3V 8.6203ms,3.3
+ 8.6204ms,0.0V 8.6399ms,0.0
+ 8.6400ms,3.3V 8.6403ms,3.3
+ 8.6404ms,0.0V 8.6599ms,0.0
+ 8.6600ms,3.3V 8.6603ms,3.3
+ 8.6604ms,0.0V 8.6799ms,0.0
+ 8.6800ms,3.3V 8.6803ms,3.3
+ 8.6804ms,0.0V 8.6999ms,0.0
+ 8.7000ms,3.3V 8.7003ms,3.3
+ 8.7004ms,0.0V 8.7199ms,0.0
+ 8.7200ms,3.3V 8.7203ms,3.3
+ 8.7204ms,0.0V 8.7399ms,0.0
+ 8.7400ms,3.3V 8.7403ms,3.3
+ 8.7404ms,0.0V 8.7599ms,0.0
+ 8.7600ms,3.3V 8.7603ms,3.3
+ 8.7604ms,0.0V 8.7799ms,0.0
+ 8.7800ms,3.3V 8.7803ms,3.3
+ 8.7804ms,0.0V 8.7999ms,0.0
+ 8.8000ms,3.3V 8.8003ms,3.3
+ 8.8004ms,0.0V 8.8199ms,0.0
+ 8.8200ms,3.3V 8.8203ms,3.3
+ 8.8204ms,0.0V 8.8399ms,0.0
+ 8.8400ms,3.3V 8.8403ms,3.3
+ 8.8404ms,0.0V 8.8599ms,0.0
+ 8.8600ms,3.3V 8.8603ms,3.3
+ 8.8604ms,0.0V 8.8799ms,0.0
+ 8.8800ms,3.3V 8.8803ms,3.3
+ 8.8804ms,0.0V 8.8999ms,0.0
+ 8.9000ms,3.3V 8.9003ms,3.3
+ 8.9004ms,0.0V 8.9199ms,0.0
+ 8.9200ms,3.3V 8.9203ms,3.3
+ 8.9204ms,0.0V 8.9399ms,0.0
+ 8.9400ms,3.3V 8.9403ms,3.3
+ 8.9404ms,0.0V 8.9599ms,0.0
+ 8.9600ms,3.3V 8.9603ms,3.3
+ 8.9604ms,0.0V 8.9799ms,0.0
+ 8.9800ms,3.3V 8.9803ms,3.3
+ 8.9804ms,0.0V 8.9999ms,0.0
+ 9.0000ms,3.3V 9.0003ms,3.3
+ 9.0004ms,0.0V 9.0199ms,0.0
+ 9.0200ms,3.3V 9.0203ms,3.3
+ 9.0204ms,0.0V 9.0399ms,0.0
+ 9.0400ms,3.3V 9.0403ms,3.3
+ 9.0404ms,0.0V 9.0599ms,0.0
+ 9.0600ms,3.3V 9.0603ms,3.3
+ 9.0604ms,0.0V 9.0799ms,0.0
+ 9.0800ms,3.3V 9.0803ms,3.3
+ 9.0804ms,0.0V 9.0999ms,0.0
+ 9.1000ms,3.3V 9.1003ms,3.3
+ 9.1004ms,0.0V 9.1199ms,0.0
+ 9.1200ms,3.3V 9.1203ms,3.3
+ 9.1204ms,0.0V 9.1399ms,0.0
+ 9.1400ms,3.3V 9.1403ms,3.3
+ 9.1404ms,0.0V 9.1599ms,0.0
+ 9.1600ms,3.3V 9.1603ms,3.3
+ 9.1604ms,0.0V 9.1799ms,0.0
+ 9.1800ms,3.3V 9.1803ms,3.3
+ 9.1804ms,0.0V 9.1999ms,0.0
+ 9.2000ms,3.3V 9.2003ms,3.3
+ 9.2004ms,0.0V 9.2199ms,0.0
+ 9.2200ms,3.3V 9.2203ms,3.3
+ 9.2204ms,0.0V 9.2399ms,0.0
+ 9.2400ms,3.3V 9.2403ms,3.3
+ 9.2404ms,0.0V 9.2599ms,0.0
+ 9.2600ms,3.3V 9.2603ms,3.3
+ 9.2604ms,0.0V 9.2799ms,0.0
+ 9.2800ms,3.3V 9.2803ms,3.3
+ 9.2804ms,0.0V 9.2999ms,0.0
+ 9.3000ms,3.3V 9.3003ms,3.3
+ 9.3004ms,0.0V 9.3199ms,0.0
+ 9.3200ms,3.3V 9.3203ms,3.3
+ 9.3204ms,0.0V 9.3399ms,0.0
+ 9.3400ms,3.3V 9.3403ms,3.3
+ 9.3404ms,0.0V 9.3599ms,0.0
+ 9.3600ms,3.3V 9.3603ms,3.3
+ 9.3604ms,0.0V 9.3799ms,0.0
+ 9.3800ms,3.3V 9.3803ms,3.3
+ 9.3804ms,0.0V 9.3999ms,0.0
+ 9.4000ms,3.3V 9.4003ms,3.3
+ 9.4004ms,0.0V 9.4199ms,0.0
+ 9.4200ms,3.3V 9.4203ms,3.3
+ 9.4204ms,0.0V 9.4399ms,0.0
+ 9.4400ms,3.3V 9.4403ms,3.3
+ 9.4404ms,0.0V 9.4599ms,0.0
+ 9.4600ms,3.3V 9.4603ms,3.3
+ 9.4604ms,0.0V 9.4799ms,0.0
+ 9.4800ms,3.3V 9.4803ms,3.3
+ 9.4804ms,0.0V 9.4999ms,0.0
+ 9.5000ms,3.3V 9.5003ms,3.3
+ 9.5004ms,0.0V 9.5199ms,0.0
+ 9.5200ms,3.3V 9.5203ms,3.3
+ 9.5204ms,0.0V 9.5399ms,0.0
+ 9.5400ms,3.3V 9.5403ms,3.3
+ 9.5404ms,0.0V 9.5599ms,0.0
+ 9.5600ms,3.3V 9.5603ms,3.3
+ 9.5604ms,0.0V 9.5799ms,0.0
+ 9.5800ms,3.3V 9.5803ms,3.3
+ 9.5804ms,0.0V 9.5999ms,0.0
+ 9.6000ms,3.3V 9.6003ms,3.3
+ 9.6004ms,0.0V 9.6199ms,0.0
+ 9.6200ms,3.3V 9.6203ms,3.3
+ 9.6204ms,0.0V 9.6399ms,0.0
+ 9.6400ms,3.3V 9.6403ms,3.3
+ 9.6404ms,0.0V 9.6599ms,0.0
+ 9.6600ms,3.3V 9.6603ms,3.3
+ 9.6604ms,0.0V 9.6799ms,0.0
+ 9.6800ms,3.3V 9.6803ms,3.3
+ 9.6804ms,0.0V 9.6999ms,0.0
+ 9.7000ms,3.3V 9.7003ms,3.3
+ 9.7004ms,0.0V 9.7199ms,0.0
+ 9.7200ms,3.3V 9.7203ms,3.3
+ 9.7204ms,0.0V 9.7399ms,0.0
+ 9.7400ms,3.3V 9.7403ms,3.3
+ 9.7404ms,0.0V 9.7599ms,0.0
+ 9.7600ms,3.3V 9.7603ms,3.3
+ 9.7604ms,0.0V 9.7799ms,0.0
+ 9.7800ms,3.3V 9.7803ms,3.3
+ 9.7804ms,0.0V 9.7999ms,0.0
+ 9.8000ms,3.3V 9.8003ms,3.3
+ 9.8004ms,0.0V 9.8199ms,0.0
+ 9.8200ms,3.3V 9.8203ms,3.3
+ 9.8204ms,0.0V 9.8399ms,0.0
+ 9.8400ms,3.3V 9.8403ms,3.3
+ 9.8404ms,0.0V 9.8599ms,0.0
+ 9.8600ms,3.3V 9.8603ms,3.3
+ 9.8604ms,0.0V 9.8799ms,0.0
+ 9.8800ms,3.3V 9.8803ms,3.3
+ 9.8804ms,0.0V 9.8999ms,0.0
+ 9.9000ms,3.3V 9.9003ms,3.3
+ 9.9004ms,0.0V 9.9199ms,0.0
+ 9.9200ms,3.3V 9.9203ms,3.3
+ 9.9204ms,0.0V 9.9399ms,0.0
+ 9.9400ms,3.3V 9.9403ms,3.3
+ 9.9404ms,0.0V 9.9599ms,0.0
+ 9.9600ms,3.3V 9.9603ms,3.3
+ 9.9604ms,0.0V 9.9799ms,0.0
+ 9.9800ms,3.3V 9.9803ms,3.3
+ 9.9804ms,0.0V 9.9999ms,0.0
+ 10.0000ms,3.3V 10.0003ms,3.3
+ 10.0004ms,0.0V 10.0199ms,0.0
+ 10.0200ms,3.3V 10.0203ms,3.3
+ 10.0204ms,0.0V 10.0399ms,0.0
+ 10.0400ms,3.3V 10.0405ms,3.3
+ 10.0406ms,0.0V 10.0599ms,0.0
+ 10.0600ms,3.3V 10.0605ms,3.3
+ 10.0606ms,0.0V 10.0799ms,0.0
+ 10.0800ms,3.3V 10.0805ms,3.3
+ 10.0806ms,0.0V 10.0999ms,0.0
+ 10.1000ms,3.3V 10.1005ms,3.3
+ 10.1006ms,0.0V 10.1199ms,0.0
+ 10.1200ms,3.3V 10.1205ms,3.3
+ 10.1206ms,0.0V 10.1399ms,0.0
+ 10.1400ms,3.3V 10.1405ms,3.3
+ 10.1406ms,0.0V 10.1599ms,0.0
+ 10.1600ms,3.3V 10.1605ms,3.3
+ 10.1606ms,0.0V 10.1799ms,0.0
+ 10.1800ms,3.3V 10.1805ms,3.3
+ 10.1806ms,0.0V 10.1999ms,0.0
+ 10.2000ms,3.3V 10.2005ms,3.3
+ 10.2006ms,0.0V 10.2199ms,0.0
+ 10.2200ms,3.3V 10.2205ms,3.3
+ 10.2206ms,0.0V 10.2399ms,0.0
+ 10.2400ms,3.3V 10.2405ms,3.3
+ 10.2406ms,0.0V 10.2599ms,0.0
+ 10.2600ms,3.3V 10.2605ms,3.3
+ 10.2606ms,0.0V 10.2799ms,0.0
+ 10.2800ms,3.3V 10.2805ms,3.3
+ 10.2806ms,0.0V 10.2999ms,0.0
+ 10.3000ms,3.3V 10.3005ms,3.3
+ 10.3006ms,0.0V 10.3199ms,0.0
+ 10.3200ms,3.3V 10.3205ms,3.3
+ 10.3206ms,0.0V 10.3399ms,0.0
+ 10.3400ms,3.3V 10.3405ms,3.3
+ 10.3406ms,0.0V 10.3599ms,0.0
+ 10.3600ms,3.3V 10.3605ms,3.3
+ 10.3606ms,0.0V 10.3799ms,0.0
+ 10.3800ms,3.3V 10.3805ms,3.3
+ 10.3806ms,0.0V 10.3999ms,0.0
+ 10.4000ms,3.3V 10.4005ms,3.3
+ 10.4006ms,0.0V 10.4199ms,0.0
+ 10.4200ms,3.3V 10.4205ms,3.3
+ 10.4206ms,0.0V 10.4399ms,0.0
+ 10.4400ms,3.3V 10.4405ms,3.3
+ 10.4406ms,0.0V 10.4599ms,0.0
+ 10.4600ms,3.3V 10.4605ms,3.3
+ 10.4606ms,0.0V 10.4799ms,0.0
+ 10.4800ms,3.3V 10.4805ms,3.3
+ 10.4806ms,0.0V 10.4999ms,0.0
+ 10.5000ms,3.3V 10.5005ms,3.3
+ 10.5006ms,0.0V 10.5199ms,0.0
+ 10.5200ms,3.3V 10.5205ms,3.3
+ 10.5206ms,0.0V 10.5399ms,0.0
+ 10.5400ms,3.3V 10.5405ms,3.3
+ 10.5406ms,0.0V 10.5599ms,0.0
+ 10.5600ms,3.3V 10.5605ms,3.3
+ 10.5606ms,0.0V 10.5799ms,0.0
+ 10.5800ms,3.3V 10.5805ms,3.3
+ 10.5806ms,0.0V 10.5999ms,0.0
+ 10.6000ms,3.3V 10.6005ms,3.3
+ 10.6006ms,0.0V 10.6199ms,0.0
+ 10.6200ms,3.3V 10.6205ms,3.3
+ 10.6206ms,0.0V 10.6399ms,0.0
+ 10.6400ms,3.3V 10.6405ms,3.3
+ 10.6406ms,0.0V 10.6599ms,0.0
+ 10.6600ms,3.3V 10.6605ms,3.3
+ 10.6606ms,0.0V 10.6799ms,0.0
+ 10.6800ms,3.3V 10.6805ms,3.3
+ 10.6806ms,0.0V 10.6999ms,0.0
+ 10.7000ms,3.3V 10.7005ms,3.3
+ 10.7006ms,0.0V 10.7199ms,0.0
+ 10.7200ms,3.3V 10.7205ms,3.3
+ 10.7206ms,0.0V 10.7399ms,0.0
+ 10.7400ms,3.3V 10.7405ms,3.3
+ 10.7406ms,0.0V 10.7599ms,0.0
+ 10.7600ms,3.3V 10.7605ms,3.3
+ 10.7606ms,0.0V 10.7799ms,0.0
+ 10.7800ms,3.3V 10.7805ms,3.3
+ 10.7806ms,0.0V 10.7999ms,0.0
+ 10.8000ms,3.3V 10.8005ms,3.3
+ 10.8006ms,0.0V 10.8199ms,0.0
+ 10.8200ms,3.3V 10.8205ms,3.3
+ 10.8206ms,0.0V 10.8399ms,0.0
+ 10.8400ms,3.3V 10.8405ms,3.3
+ 10.8406ms,0.0V 10.8599ms,0.0
+ 10.8600ms,3.3V 10.8605ms,3.3
+ 10.8606ms,0.0V 10.8799ms,0.0
+ 10.8800ms,3.3V 10.8805ms,3.3
+ 10.8806ms,0.0V 10.8999ms,0.0
+ 10.9000ms,3.3V 10.9005ms,3.3
+ 10.9006ms,0.0V 10.9199ms,0.0
+ 10.9200ms,3.3V 10.9205ms,3.3
+ 10.9206ms,0.0V 10.9399ms,0.0
+ 10.9400ms,3.3V 10.9405ms,3.3
+ 10.9406ms,0.0V 10.9599ms,0.0
+ 10.9600ms,3.3V 10.9605ms,3.3
+ 10.9606ms,0.0V 10.9799ms,0.0
+ 10.9800ms,3.3V 10.9805ms,3.3
+ 10.9806ms,0.0V 10.9999ms,0.0
+ 11.0000ms,3.3V 11.0005ms,3.3
+ 11.0006ms,0.0V 11.0199ms,0.0
+ 11.0200ms,3.3V 11.0205ms,3.3
+ 11.0206ms,0.0V 11.0399ms,0.0
+ 11.0400ms,3.3V 11.0405ms,3.3
+ 11.0406ms,0.0V 11.0599ms,0.0
+ 11.0600ms,3.3V 11.0605ms,3.3
+ 11.0606ms,0.0V 11.0799ms,0.0
+ 11.0800ms,3.3V 11.0805ms,3.3
+ 11.0806ms,0.0V 11.0999ms,0.0
+ 11.1000ms,3.3V 11.1005ms,3.3
+ 11.1006ms,0.0V 11.1199ms,0.0
+ 11.1200ms,3.3V 11.1205ms,3.3
+ 11.1206ms,0.0V 11.1399ms,0.0
+ 11.1400ms,3.3V 11.1405ms,3.3
+ 11.1406ms,0.0V 11.1599ms,0.0
+ 11.1600ms,3.3V 11.1605ms,3.3
+ 11.1606ms,0.0V 11.1799ms,0.0
+ 11.1800ms,3.3V 11.1805ms,3.3
+ 11.1806ms,0.0V 11.1999ms,0.0
+ 11.2000ms,3.3V 11.2005ms,3.3
+ 11.2006ms,0.0V 11.2199ms,0.0
+ 11.2200ms,3.3V 11.2205ms,3.3
+ 11.2206ms,0.0V 11.2399ms,0.0
+ 11.2400ms,3.3V 11.2405ms,3.3
+ 11.2406ms,0.0V 11.2599ms,0.0
+ 11.2600ms,3.3V 11.2605ms,3.3
+ 11.2606ms,0.0V 11.2799ms,0.0
+ 11.2800ms,3.3V 11.2805ms,3.3
+ 11.2806ms,0.0V 11.2999ms,0.0
+ 11.3000ms,3.3V 11.3005ms,3.3
+ 11.3006ms,0.0V 11.3199ms,0.0
+ 11.3200ms,3.3V 11.3205ms,3.3
+ 11.3206ms,0.0V 11.3399ms,0.0
+ 11.3400ms,3.3V 11.3405ms,3.3
+ 11.3406ms,0.0V 11.3599ms,0.0
+ 11.3600ms,3.3V 11.3605ms,3.3
+ 11.3606ms,0.0V 11.3799ms,0.0
+ 11.3800ms,3.3V 11.3805ms,3.3
+ 11.3806ms,0.0V 11.3999ms,0.0
+ 11.4000ms,3.3V 11.4005ms,3.3
+ 11.4006ms,0.0V 11.4199ms,0.0
+ 11.4200ms,3.3V 11.4205ms,3.3
+ 11.4206ms,0.0V 11.4399ms,0.0
+ 11.4400ms,3.3V 11.4405ms,3.3
+ 11.4406ms,0.0V 11.4599ms,0.0
+ 11.4600ms,3.3V 11.4605ms,3.3
+ 11.4606ms,0.0V 11.4799ms,0.0
+ 11.4800ms,3.3V 11.4805ms,3.3
+ 11.4806ms,0.0V 11.4999ms,0.0
+ 11.5000ms,3.3V 11.5005ms,3.3
+ 11.5006ms,0.0V 11.5199ms,0.0
+ 11.5200ms,3.3V 11.5205ms,3.3
+ 11.5206ms,0.0V 11.5399ms,0.0
+ 11.5400ms,3.3V 11.5405ms,3.3
+ 11.5406ms,0.0V 11.5599ms,0.0
+ 11.5600ms,3.3V 11.5605ms,3.3
+ 11.5606ms,0.0V 11.5799ms,0.0
+ 11.5800ms,3.3V 11.5805ms,3.3
+ 11.5806ms,0.0V 11.5999ms,0.0
+ 11.6000ms,3.3V 11.6005ms,3.3
+ 11.6006ms,0.0V 11.6199ms,0.0
+ 11.6200ms,3.3V 11.6205ms,3.3
+ 11.6206ms,0.0V 11.6399ms,0.0
+ 11.6400ms,3.3V 11.6405ms,3.3
+ 11.6406ms,0.0V 11.6599ms,0.0
+ 11.6600ms,3.3V 11.6605ms,3.3
+ 11.6606ms,0.0V 11.6799ms,0.0
+ 11.6800ms,3.3V 11.6805ms,3.3
+ 11.6806ms,0.0V 11.6999ms,0.0
+ 11.7000ms,3.3V 11.7005ms,3.3
+ 11.7006ms,0.0V 11.7199ms,0.0
+ 11.7200ms,3.3V 11.7205ms,3.3
+ 11.7206ms,0.0V 11.7399ms,0.0
+ 11.7400ms,3.3V 11.7405ms,3.3
+ 11.7406ms,0.0V 11.7599ms,0.0
+ 11.7600ms,3.3V 11.7605ms,3.3
+ 11.7606ms,0.0V 11.7799ms,0.0
+ 11.7800ms,3.3V 11.7805ms,3.3
+ 11.7806ms,0.0V 11.7999ms,0.0
+ 11.8000ms,3.3V 11.8005ms,3.3
+ 11.8006ms,0.0V 11.8199ms,0.0
+ 11.8200ms,3.3V 11.8205ms,3.3
+ 11.8206ms,0.0V 11.8399ms,0.0
+ 11.8400ms,3.3V 11.8405ms,3.3
+ 11.8406ms,0.0V 11.8599ms,0.0
+ 11.8600ms,3.3V 11.8605ms,3.3
+ 11.8606ms,0.0V 11.8799ms,0.0
+ 11.8800ms,3.3V 11.8805ms,3.3
+ 11.8806ms,0.0V 11.8999ms,0.0
+ 11.9000ms,3.3V 11.9005ms,3.3
+ 11.9006ms,0.0V 11.9199ms,0.0
+ 11.9200ms,3.3V 11.9205ms,3.3
+ 11.9206ms,0.0V 11.9399ms,0.0
+ 11.9400ms,3.3V 11.9405ms,3.3
+ 11.9406ms,0.0V 11.9599ms,0.0
+ 11.9600ms,3.3V 11.9605ms,3.3
+ 11.9606ms,0.0V 11.9799ms,0.0
+ 11.9800ms,3.3V 11.9805ms,3.3
+ 11.9806ms,0.0V 11.9999ms,0.0
+ 12.0000ms,3.3V 12.0005ms,3.3
+ 12.0006ms,0.0V 12.0199ms,0.0
+ 12.0200ms,3.3V 12.0205ms,3.3
+ 12.0206ms,0.0V 12.0399ms,0.0
+ 12.0400ms,3.3V 12.0405ms,3.3
+ 12.0406ms,0.0V 12.0599ms,0.0
+ 12.0600ms,3.3V 12.0605ms,3.3
+ 12.0606ms,0.0V 12.0799ms,0.0
+ 12.0800ms,3.3V 12.0805ms,3.3
+ 12.0806ms,0.0V 12.0999ms,0.0
+ 12.1000ms,3.3V 12.1005ms,3.3
+ 12.1006ms,0.0V 12.1199ms,0.0
+ 12.1200ms,3.3V 12.1205ms,3.3
+ 12.1206ms,0.0V 12.1399ms,0.0
+ 12.1400ms,3.3V 12.1405ms,3.3
+ 12.1406ms,0.0V 12.1599ms,0.0
+ 12.1600ms,3.3V 12.1605ms,3.3
+ 12.1606ms,0.0V 12.1799ms,0.0
+ 12.1800ms,3.3V 12.1805ms,3.3
+ 12.1806ms,0.0V 12.1999ms,0.0
+ 12.2000ms,3.3V 12.2005ms,3.3
+ 12.2006ms,0.0V 12.2199ms,0.0
+ 12.2200ms,3.3V 12.2205ms,3.3
+ 12.2206ms,0.0V 12.2399ms,0.0
+ 12.2400ms,3.3V 12.2405ms,3.3
+ 12.2406ms,0.0V 12.2599ms,0.0
+ 12.2600ms,3.3V 12.2605ms,3.3
+ 12.2606ms,0.0V 12.2799ms,0.0
+ 12.2800ms,3.3V 12.2805ms,3.3
+ 12.2806ms,0.0V 12.2999ms,0.0
+ 12.3000ms,3.3V 12.3005ms,3.3
+ 12.3006ms,0.0V 12.3199ms,0.0
+ 12.3200ms,3.3V 12.3205ms,3.3
+ 12.3206ms,0.0V 12.3399ms,0.0
+ 12.3400ms,3.3V 12.3405ms,3.3
+ 12.3406ms,0.0V 12.3599ms,0.0
+ 12.3600ms,3.3V 12.3605ms,3.3
+ 12.3606ms,0.0V 12.3799ms,0.0
+ 12.3800ms,3.3V 12.3805ms,3.3
+ 12.3806ms,0.0V 12.3999ms,0.0
+ 12.4000ms,3.3V 12.4005ms,3.3
+ 12.4006ms,0.0V 12.4199ms,0.0
+ 12.4200ms,3.3V 12.4205ms,3.3
+ 12.4206ms,0.0V 12.4399ms,0.0
+ 12.4400ms,3.3V 12.4405ms,3.3
+ 12.4406ms,0.0V 12.4599ms,0.0
+ 12.4600ms,3.3V 12.4605ms,3.3
+ 12.4606ms,0.0V 12.4799ms,0.0
+ 12.4800ms,3.3V 12.4805ms,3.3
+ 12.4806ms,0.0V 12.4999ms,0.0
+ 12.5000ms,3.3V 12.5005ms,3.3
+ 12.5006ms,0.0V 12.5199ms,0.0
+ 12.5200ms,3.3V 12.5205ms,3.3
+ 12.5206ms,0.0V 12.5399ms,0.0
+ 12.5400ms,3.3V 12.5405ms,3.3
+ 12.5406ms,0.0V 12.5599ms,0.0
+ 12.5600ms,3.3V 12.5605ms,3.3
+ 12.5606ms,0.0V 12.5799ms,0.0
+ 12.5800ms,3.3V 12.5805ms,3.3
+ 12.5806ms,0.0V 12.5999ms,0.0
+ 12.6000ms,3.3V 12.6005ms,3.3
+ 12.6006ms,0.0V 12.6199ms,0.0
+ 12.6200ms,3.3V 12.6205ms,3.3
+ 12.6206ms,0.0V 12.6399ms,0.0
+ 12.6400ms,3.3V 12.6405ms,3.3
+ 12.6406ms,0.0V 12.6599ms,0.0
+ 12.6600ms,3.3V 12.6605ms,3.3
+ 12.6606ms,0.0V 12.6799ms,0.0
+ 12.6800ms,3.3V 12.6805ms,3.3
+ 12.6806ms,0.0V 12.6999ms,0.0
+ 12.7000ms,3.3V 12.7005ms,3.3
+ 12.7006ms,0.0V 12.7199ms,0.0
+ 12.7200ms,3.3V 12.7205ms,3.3
+ 12.7206ms,0.0V 12.7399ms,0.0
+ 12.7400ms,3.3V 12.7405ms,3.3
+ 12.7406ms,0.0V 12.7599ms,0.0
+ 12.7600ms,3.3V 12.7605ms,3.3
+ 12.7606ms,0.0V 12.7799ms,0.0
+ 12.7800ms,3.3V 12.7805ms,3.3
+ 12.7806ms,0.0V 12.7999ms,0.0
+ 12.8000ms,3.3V 12.8005ms,3.3
+ 12.8006ms,0.0V 12.8199ms,0.0
+ 12.8200ms,3.3V 12.8205ms,3.3
+ 12.8206ms,0.0V 12.8399ms,0.0
+ 12.8400ms,3.3V 12.8405ms,3.3
+ 12.8406ms,0.0V 12.8599ms,0.0
+ 12.8600ms,3.3V 12.8605ms,3.3
+ 12.8606ms,0.0V 12.8799ms,0.0
+ 12.8800ms,3.3V 12.8805ms,3.3
+ 12.8806ms,0.0V 12.8999ms,0.0
+ 12.9000ms,3.3V 12.9005ms,3.3
+ 12.9006ms,0.0V 12.9199ms,0.0
+ 12.9200ms,3.3V 12.9205ms,3.3
+ 12.9206ms,0.0V 12.9399ms,0.0
+ 12.9400ms,3.3V 12.9405ms,3.3
+ 12.9406ms,0.0V 12.9599ms,0.0
+ 12.9600ms,3.3V 12.9605ms,3.3
+ 12.9606ms,0.0V 12.9799ms,0.0
+ 12.9800ms,3.3V 12.9805ms,3.3
+ 12.9806ms,0.0V 12.9999ms,0.0
+ 13.0000ms,3.3V 13.0005ms,3.3
+ 13.0006ms,0.0V 13.0199ms,0.0
+ 13.0200ms,3.3V 13.0205ms,3.3
+ 13.0206ms,0.0V 13.0399ms,0.0
+ 13.0400ms,3.3V 13.0405ms,3.3
+ 13.0406ms,0.0V 13.0599ms,0.0
+ 13.0600ms,3.3V 13.0605ms,3.3
+ 13.0606ms,0.0V 13.0799ms,0.0
+ 13.0800ms,3.3V 13.0805ms,3.3
+ 13.0806ms,0.0V 13.0999ms,0.0
+ 13.1000ms,3.3V 13.1005ms,3.3
+ 13.1006ms,0.0V 13.1199ms,0.0
+ 13.1200ms,3.3V 13.1205ms,3.3
+ 13.1206ms,0.0V 13.1399ms,0.0
+ 13.1400ms,3.3V 13.1405ms,3.3
+ 13.1406ms,0.0V 13.1599ms,0.0
+ 13.1600ms,3.3V 13.1605ms,3.3
+ 13.1606ms,0.0V 13.1799ms,0.0
+ 13.1800ms,3.3V 13.1805ms,3.3
+ 13.1806ms,0.0V 13.1999ms,0.0
+ 13.2000ms,3.3V 13.2005ms,3.3
+ 13.2006ms,0.0V 13.2199ms,0.0
+ 13.2200ms,3.3V 13.2205ms,3.3
+ 13.2206ms,0.0V 13.2399ms,0.0
+ 13.2400ms,3.3V 13.2405ms,3.3
+ 13.2406ms,0.0V 13.2599ms,0.0
+ 13.2600ms,3.3V 13.2605ms,3.3
+ 13.2606ms,0.0V 13.2799ms,0.0
+ 13.2800ms,3.3V 13.2805ms,3.3
+ 13.2806ms,0.0V 13.2999ms,0.0
+ 13.3000ms,3.3V 13.3005ms,3.3
+ 13.3006ms,0.0V 13.3199ms,0.0
+ 13.3200ms,3.3V 13.3205ms,3.3
+ 13.3206ms,0.0V 13.3399ms,0.0
+ 13.3400ms,3.3V 13.3405ms,3.3
+ 13.3406ms,0.0V 13.3599ms,0.0
+ 13.3600ms,3.3V 13.3605ms,3.3
+ 13.3606ms,0.0V 13.3799ms,0.0
+ 13.3800ms,3.3V 13.3805ms,3.3
+ 13.3806ms,0.0V 13.3999ms,0.0
+ 13.4000ms,3.3V 13.4005ms,3.3
+ 13.4006ms,0.0V 13.4199ms,0.0
+ 13.4200ms,3.3V 13.4205ms,3.3
+ 13.4206ms,0.0V 13.4399ms,0.0
+ 13.4400ms,3.3V 13.4405ms,3.3
+ 13.4406ms,0.0V 13.4599ms,0.0
+ 13.4600ms,3.3V 13.4605ms,3.3
+ 13.4606ms,0.0V 13.4799ms,0.0
+ 13.4800ms,3.3V 13.4805ms,3.3
+ 13.4806ms,0.0V 13.4999ms,0.0
+ 13.5000ms,3.3V 13.5005ms,3.3
+ 13.5006ms,0.0V 13.5199ms,0.0
+ 13.5200ms,3.3V 13.5205ms,3.3
+ 13.5206ms,0.0V 13.5399ms,0.0
+ 13.5400ms,3.3V 13.5405ms,3.3
+ 13.5406ms,0.0V 13.5599ms,0.0
+ 13.5600ms,3.3V 13.5605ms,3.3
+ 13.5606ms,0.0V 13.5799ms,0.0
+ 13.5800ms,3.3V 13.5805ms,3.3
+ 13.5806ms,0.0V 13.5999ms,0.0
+ 13.6000ms,3.3V 13.6005ms,3.3
+ 13.6006ms,0.0V 13.6199ms,0.0
+ 13.6200ms,3.3V 13.6205ms,3.3
+ 13.6206ms,0.0V 13.6399ms,0.0
+ 13.6400ms,3.3V 13.6405ms,3.3
+ 13.6406ms,0.0V 13.6599ms,0.0
+ 13.6600ms,3.3V 13.6605ms,3.3
+ 13.6606ms,0.0V 13.6799ms,0.0
+ 13.6800ms,3.3V 13.6805ms,3.3
+ 13.6806ms,0.0V 13.6999ms,0.0
+ 13.7000ms,3.3V 13.7005ms,3.3
+ 13.7006ms,0.0V 13.7199ms,0.0
+ 13.7200ms,3.3V 13.7205ms,3.3
+ 13.7206ms,0.0V 13.7399ms,0.0
+ 13.7400ms,3.3V 13.7405ms,3.3
+ 13.7406ms,0.0V 13.7599ms,0.0
+ 13.7600ms,3.3V 13.7605ms,3.3
+ 13.7606ms,0.0V 13.7799ms,0.0
+ 13.7800ms,3.3V 13.7805ms,3.3
+ 13.7806ms,0.0V 13.7999ms,0.0
+ 13.8000ms,3.3V 13.8005ms,3.3
+ 13.8006ms,0.0V 13.8199ms,0.0
+ 13.8200ms,3.3V 13.8205ms,3.3
+ 13.8206ms,0.0V 13.8399ms,0.0
+ 13.8400ms,3.3V 13.8405ms,3.3
+ 13.8406ms,0.0V 13.8599ms,0.0
+ 13.8600ms,3.3V 13.8605ms,3.3
+ 13.8606ms,0.0V 13.8799ms,0.0
+ 13.8800ms,3.3V 13.8805ms,3.3
+ 13.8806ms,0.0V 13.8999ms,0.0
+ 13.9000ms,3.3V 13.9005ms,3.3
+ 13.9006ms,0.0V 13.9199ms,0.0
+ 13.9200ms,3.3V 13.9205ms,3.3
+ 13.9206ms,0.0V 13.9399ms,0.0
+ 13.9400ms,3.3V 13.9405ms,3.3
+ 13.9406ms,0.0V 13.9599ms,0.0
+ 13.9600ms,3.3V 13.9605ms,3.3
+ 13.9606ms,0.0V 13.9799ms,0.0
+ 13.9800ms,3.3V 13.9805ms,3.3
+ 13.9806ms,0.0V 13.9999ms,0.0
+ 14.0000ms,3.3V 14.0005ms,3.3
+ 14.0006ms,0.0V 14.0199ms,0.0
+ 14.0200ms,3.3V 14.0205ms,3.3
+ 14.0206ms,0.0V 14.0399ms,0.0
+ 14.0400ms,3.3V 14.0405ms,3.3
+ 14.0406ms,0.0V 14.0599ms,0.0
+ 14.0600ms,3.3V 14.0605ms,3.3
+ 14.0606ms,0.0V 14.0799ms,0.0
+ 14.0800ms,3.3V 14.0805ms,3.3
+ 14.0806ms,0.0V 14.0999ms,0.0
+ 14.1000ms,3.3V 14.1005ms,3.3
+ 14.1006ms,0.0V 14.1199ms,0.0
+ 14.1200ms,3.3V 14.1205ms,3.3
+ 14.1206ms,0.0V 14.1399ms,0.0
+ 14.1400ms,3.3V 14.1405ms,3.3
+ 14.1406ms,0.0V 14.1599ms,0.0
+ 14.1600ms,3.3V 14.1605ms,3.3
+ 14.1606ms,0.0V 14.1799ms,0.0
+ 14.1800ms,3.3V 14.1805ms,3.3
+ 14.1806ms,0.0V 14.1999ms,0.0
+ 14.2000ms,3.3V 14.2005ms,3.3
+ 14.2006ms,0.0V 14.2199ms,0.0
+ 14.2200ms,3.3V 14.2205ms,3.3
+ 14.2206ms,0.0V 14.2399ms,0.0
+ 14.2400ms,3.3V 14.2405ms,3.3
+ 14.2406ms,0.0V 14.2599ms,0.0
+ 14.2600ms,3.3V 14.2605ms,3.3
+ 14.2606ms,0.0V 14.2799ms,0.0
+ 14.2800ms,3.3V 14.2805ms,3.3
+ 14.2806ms,0.0V 14.2999ms,0.0
+ 14.3000ms,3.3V 14.3005ms,3.3
+ 14.3006ms,0.0V 14.3199ms,0.0
+ 14.3200ms,3.3V 14.3205ms,3.3
+ 14.3206ms,0.0V 14.3399ms,0.0
+ 14.3400ms,3.3V 14.3405ms,3.3
+ 14.3406ms,0.0V 14.3599ms,0.0
+ 14.3600ms,3.3V 14.3605ms,3.3
+ 14.3606ms,0.0V 14.3799ms,0.0
+ 14.3800ms,3.3V 14.3805ms,3.3
+ 14.3806ms,0.0V 14.3999ms,0.0
+ 14.4000ms,3.3V 14.4005ms,3.3
+ 14.4006ms,0.0V 14.4199ms,0.0
+ 14.4200ms,3.3V 14.4205ms,3.3
+ 14.4206ms,0.0V 14.4399ms,0.0
+ 14.4400ms,3.3V 14.4405ms,3.3
+ 14.4406ms,0.0V 14.4599ms,0.0
+ 14.4600ms,3.3V 14.4605ms,3.3
+ 14.4606ms,0.0V 14.4799ms,0.0
+ 14.4800ms,3.3V 14.4805ms,3.3
+ 14.4806ms,0.0V 14.4999ms,0.0
+ 14.5000ms,3.3V 14.5005ms,3.3
+ 14.5006ms,0.0V 14.5199ms,0.0
+ 14.5200ms,3.3V 14.5205ms,3.3
+ 14.5206ms,0.0V 14.5399ms,0.0
+ 14.5400ms,3.3V 14.5405ms,3.3
+ 14.5406ms,0.0V 14.5599ms,0.0
+ 14.5600ms,3.3V 14.5605ms,3.3
+ 14.5606ms,0.0V 14.5799ms,0.0
+ 14.5800ms,3.3V 14.5805ms,3.3
+ 14.5806ms,0.0V 14.5999ms,0.0
+ 14.6000ms,3.3V 14.6005ms,3.3
+ 14.6006ms,0.0V 14.6199ms,0.0
+ 14.6200ms,3.3V 14.6205ms,3.3
+ 14.6206ms,0.0V 14.6399ms,0.0
+ 14.6400ms,3.3V 14.6405ms,3.3
+ 14.6406ms,0.0V 14.6599ms,0.0
+ 14.6600ms,3.3V 14.6605ms,3.3
+ 14.6606ms,0.0V 14.6799ms,0.0
+ 14.6800ms,3.3V 14.6805ms,3.3
+ 14.6806ms,0.0V 14.6999ms,0.0
+ 14.7000ms,3.3V 14.7005ms,3.3
+ 14.7006ms,0.0V 14.7199ms,0.0
+ 14.7200ms,3.3V 14.7205ms,3.3
+ 14.7206ms,0.0V 14.7399ms,0.0
+ 14.7400ms,3.3V 14.7405ms,3.3
+ 14.7406ms,0.0V 14.7599ms,0.0
+ 14.7600ms,3.3V 14.7605ms,3.3
+ 14.7606ms,0.0V 14.7799ms,0.0
+ 14.7800ms,3.3V 14.7805ms,3.3
+ 14.7806ms,0.0V 14.7999ms,0.0
+ 14.8000ms,3.3V 14.8005ms,3.3
+ 14.8006ms,0.0V 14.8199ms,0.0
+ 14.8200ms,3.3V 14.8205ms,3.3
+ 14.8206ms,0.0V 14.8399ms,0.0
+ 14.8400ms,3.3V 14.8405ms,3.3
+ 14.8406ms,0.0V 14.8599ms,0.0
+ 14.8600ms,3.3V 14.8605ms,3.3
+ 14.8606ms,0.0V 14.8799ms,0.0
+ 14.8800ms,3.3V 14.8805ms,3.3
+ 14.8806ms,0.0V 14.8999ms,0.0
+ 14.9000ms,3.3V 14.9005ms,3.3
+ 14.9006ms,0.0V 14.9199ms,0.0
+ 14.9200ms,3.3V 14.9205ms,3.3
+ 14.9206ms,0.0V 14.9399ms,0.0
+ 14.9400ms,3.3V 14.9405ms,3.3
+ 14.9406ms,0.0V 14.9599ms,0.0
+ 14.9600ms,3.3V 14.9605ms,3.3
+ 14.9606ms,0.0V 14.9799ms,0.0
+ 14.9800ms,3.3V 14.9805ms,3.3
+ 14.9806ms,0.0V 14.9999ms,0.0
+ 15.0000ms,3.3V 15.0005ms,3.3
+ 15.0006ms,0.0V 15.0199ms,0.0
+ 15.0200ms,3.3V 15.0205ms,3.3
+ 15.0206ms,0.0V 15.0399ms,0.0
+ 15.0400ms,3.3V 15.0405ms,3.3
+ 15.0406ms,0.0V 15.0599ms,0.0
+ 15.0600ms,3.3V 15.0607ms,3.3
+ 15.0608ms,0.0V 15.0799ms,0.0
+ 15.0800ms,3.3V 15.0807ms,3.3
+ 15.0808ms,0.0V 15.0999ms,0.0
+ 15.1000ms,3.3V 15.1007ms,3.3
+ 15.1008ms,0.0V 15.1199ms,0.0
+ 15.1200ms,3.3V 15.1207ms,3.3
+ 15.1208ms,0.0V 15.1399ms,0.0
+ 15.1400ms,3.3V 15.1407ms,3.3
+ 15.1408ms,0.0V 15.1599ms,0.0
+ 15.1600ms,3.3V 15.1607ms,3.3
+ 15.1608ms,0.0V 15.1799ms,0.0
+ 15.1800ms,3.3V 15.1807ms,3.3
+ 15.1808ms,0.0V 15.1999ms,0.0
+ 15.2000ms,3.3V 15.2007ms,3.3
+ 15.2008ms,0.0V 15.2199ms,0.0
+ 15.2200ms,3.3V 15.2207ms,3.3
+ 15.2208ms,0.0V 15.2399ms,0.0
+ 15.2400ms,3.3V 15.2407ms,3.3
+ 15.2408ms,0.0V 15.2599ms,0.0
+ 15.2600ms,3.3V 15.2607ms,3.3
+ 15.2608ms,0.0V 15.2799ms,0.0
+ 15.2800ms,3.3V 15.2807ms,3.3
+ 15.2808ms,0.0V 15.2999ms,0.0
+ 15.3000ms,3.3V 15.3007ms,3.3
+ 15.3008ms,0.0V 15.3199ms,0.0
+ 15.3200ms,3.3V 15.3207ms,3.3
+ 15.3208ms,0.0V 15.3399ms,0.0
+ 15.3400ms,3.3V 15.3407ms,3.3
+ 15.3408ms,0.0V 15.3599ms,0.0
+ 15.3600ms,3.3V 15.3607ms,3.3
+ 15.3608ms,0.0V 15.3799ms,0.0
+ 15.3800ms,3.3V 15.3807ms,3.3
+ 15.3808ms,0.0V 15.3999ms,0.0
+ 15.4000ms,3.3V 15.4007ms,3.3
+ 15.4008ms,0.0V 15.4199ms,0.0
+ 15.4200ms,3.3V 15.4207ms,3.3
+ 15.4208ms,0.0V 15.4399ms,0.0
+ 15.4400ms,3.3V 15.4407ms,3.3
+ 15.4408ms,0.0V 15.4599ms,0.0
+ 15.4600ms,3.3V 15.4607ms,3.3
+ 15.4608ms,0.0V 15.4799ms,0.0
+ 15.4800ms,3.3V 15.4807ms,3.3
+ 15.4808ms,0.0V 15.4999ms,0.0
+ 15.5000ms,3.3V 15.5007ms,3.3
+ 15.5008ms,0.0V 15.5199ms,0.0
+ 15.5200ms,3.3V 15.5207ms,3.3
+ 15.5208ms,0.0V 15.5399ms,0.0
+ 15.5400ms,3.3V 15.5407ms,3.3
+ 15.5408ms,0.0V 15.5599ms,0.0
+ 15.5600ms,3.3V 15.5607ms,3.3
+ 15.5608ms,0.0V 15.5799ms,0.0
+ 15.5800ms,3.3V 15.5807ms,3.3
+ 15.5808ms,0.0V 15.5999ms,0.0
+ 15.6000ms,3.3V 15.6007ms,3.3
+ 15.6008ms,0.0V 15.6199ms,0.0
+ 15.6200ms,3.3V 15.6207ms,3.3
+ 15.6208ms,0.0V 15.6399ms,0.0
+ 15.6400ms,3.3V 15.6407ms,3.3
+ 15.6408ms,0.0V 15.6599ms,0.0
+ 15.6600ms,3.3V 15.6607ms,3.3
+ 15.6608ms,0.0V 15.6799ms,0.0
+ 15.6800ms,3.3V 15.6807ms,3.3
+ 15.6808ms,0.0V 15.6999ms,0.0
+ 15.7000ms,3.3V 15.7007ms,3.3
+ 15.7008ms,0.0V 15.7199ms,0.0
+ 15.7200ms,3.3V 15.7207ms,3.3
+ 15.7208ms,0.0V 15.7399ms,0.0
+ 15.7400ms,3.3V 15.7407ms,3.3
+ 15.7408ms,0.0V 15.7599ms,0.0
+ 15.7600ms,3.3V 15.7607ms,3.3
+ 15.7608ms,0.0V 15.7799ms,0.0
+ 15.7800ms,3.3V 15.7807ms,3.3
+ 15.7808ms,0.0V 15.7999ms,0.0
+ 15.8000ms,3.3V 15.8007ms,3.3
+ 15.8008ms,0.0V 15.8199ms,0.0
+ 15.8200ms,3.3V 15.8207ms,3.3
+ 15.8208ms,0.0V 15.8399ms,0.0
+ 15.8400ms,3.3V 15.8407ms,3.3
+ 15.8408ms,0.0V 15.8599ms,0.0
+ 15.8600ms,3.3V 15.8607ms,3.3
+ 15.8608ms,0.0V 15.8799ms,0.0
+ 15.8800ms,3.3V 15.8807ms,3.3
+ 15.8808ms,0.0V 15.8999ms,0.0
+ 15.9000ms,3.3V 15.9007ms,3.3
+ 15.9008ms,0.0V 15.9199ms,0.0
+ 15.9200ms,3.3V 15.9207ms,3.3
+ 15.9208ms,0.0V 15.9399ms,0.0
+ 15.9400ms,3.3V 15.9407ms,3.3
+ 15.9408ms,0.0V 15.9599ms,0.0
+ 15.9600ms,3.3V 15.9607ms,3.3
+ 15.9608ms,0.0V 15.9799ms,0.0
+ 15.9800ms,3.3V 15.9807ms,3.3
+ 15.9808ms,0.0V 15.9999ms,0.0
+ 16.0000ms,3.3V 16.0007ms,3.3
+ 16.0008ms,0.0V 16.0199ms,0.0
+ 16.0200ms,3.3V 16.0207ms,3.3
+ 16.0208ms,0.0V 16.0399ms,0.0
+ 16.0400ms,3.3V 16.0407ms,3.3
+ 16.0408ms,0.0V 16.0599ms,0.0
+ 16.0600ms,3.3V 16.0607ms,3.3
+ 16.0608ms,0.0V 16.0799ms,0.0
+ 16.0800ms,3.3V 16.0807ms,3.3
+ 16.0808ms,0.0V 16.0999ms,0.0
+ 16.1000ms,3.3V 16.1007ms,3.3
+ 16.1008ms,0.0V 16.1199ms,0.0
+ 16.1200ms,3.3V 16.1207ms,3.3
+ 16.1208ms,0.0V 16.1399ms,0.0
+ 16.1400ms,3.3V 16.1407ms,3.3
+ 16.1408ms,0.0V 16.1599ms,0.0
+ 16.1600ms,3.3V 16.1607ms,3.3
+ 16.1608ms,0.0V 16.1799ms,0.0
+ 16.1800ms,3.3V 16.1807ms,3.3
+ 16.1808ms,0.0V 16.1999ms,0.0
+ 16.2000ms,3.3V 16.2007ms,3.3
+ 16.2008ms,0.0V 16.2199ms,0.0
+ 16.2200ms,3.3V 16.2207ms,3.3
+ 16.2208ms,0.0V 16.2399ms,0.0
+ 16.2400ms,3.3V 16.2407ms,3.3
+ 16.2408ms,0.0V 16.2599ms,0.0
+ 16.2600ms,3.3V 16.2607ms,3.3
+ 16.2608ms,0.0V 16.2799ms,0.0
+ 16.2800ms,3.3V 16.2807ms,3.3
+ 16.2808ms,0.0V 16.2999ms,0.0
+ 16.3000ms,3.3V 16.3007ms,3.3
+ 16.3008ms,0.0V 16.3199ms,0.0
+ 16.3200ms,3.3V 16.3207ms,3.3
+ 16.3208ms,0.0V 16.3399ms,0.0
+ 16.3400ms,3.3V 16.3407ms,3.3
+ 16.3408ms,0.0V 16.3599ms,0.0
+ 16.3600ms,3.3V 16.3607ms,3.3
+ 16.3608ms,0.0V 16.3799ms,0.0
+ 16.3800ms,3.3V 16.3807ms,3.3
+ 16.3808ms,0.0V 16.3999ms,0.0
+ 16.4000ms,3.3V 16.4007ms,3.3
+ 16.4008ms,0.0V 16.4199ms,0.0
+ 16.4200ms,3.3V 16.4207ms,3.3
+ 16.4208ms,0.0V 16.4399ms,0.0
+ 16.4400ms,3.3V 16.4407ms,3.3
+ 16.4408ms,0.0V 16.4599ms,0.0
+ 16.4600ms,3.3V 16.4607ms,3.3
+ 16.4608ms,0.0V 16.4799ms,0.0
+ 16.4800ms,3.3V 16.4807ms,3.3
+ 16.4808ms,0.0V 16.4999ms,0.0
+ 16.5000ms,3.3V 16.5007ms,3.3
+ 16.5008ms,0.0V 16.5199ms,0.0
+ 16.5200ms,3.3V 16.5207ms,3.3
+ 16.5208ms,0.0V 16.5399ms,0.0
+ 16.5400ms,3.3V 16.5407ms,3.3
+ 16.5408ms,0.0V 16.5599ms,0.0
+ 16.5600ms,3.3V 16.5607ms,3.3
+ 16.5608ms,0.0V 16.5799ms,0.0
+ 16.5800ms,3.3V 16.5807ms,3.3
+ 16.5808ms,0.0V 16.5999ms,0.0
+ 16.6000ms,3.3V 16.6007ms,3.3
+ 16.6008ms,0.0V 16.6199ms,0.0
+ 16.6200ms,3.3V 16.6207ms,3.3
+ 16.6208ms,0.0V 16.6399ms,0.0
+ 16.6400ms,3.3V 16.6407ms,3.3
+ 16.6408ms,0.0V 16.6599ms,0.0
+ 16.6600ms,3.3V 16.6607ms,3.3
+ 16.6608ms,0.0V 16.6799ms,0.0
+ 16.6800ms,3.3V 16.6807ms,3.3
+ 16.6808ms,0.0V 16.6999ms,0.0
+ 16.7000ms,3.3V 16.7007ms,3.3
+ 16.7008ms,0.0V 16.7199ms,0.0
+ 16.7200ms,3.3V 16.7207ms,3.3
+ 16.7208ms,0.0V 16.7399ms,0.0
+ 16.7400ms,3.3V 16.7407ms,3.3
+ 16.7408ms,0.0V 16.7599ms,0.0
+ 16.7600ms,3.3V 16.7607ms,3.3
+ 16.7608ms,0.0V 16.7799ms,0.0
+ 16.7800ms,3.3V 16.7807ms,3.3
+ 16.7808ms,0.0V 16.7999ms,0.0
+ 16.8000ms,3.3V 16.8007ms,3.3
+ 16.8008ms,0.0V 16.8199ms,0.0
+ 16.8200ms,3.3V 16.8207ms,3.3
+ 16.8208ms,0.0V 16.8399ms,0.0
+ 16.8400ms,3.3V 16.8407ms,3.3
+ 16.8408ms,0.0V 16.8599ms,0.0
+ 16.8600ms,3.3V 16.8607ms,3.3
+ 16.8608ms,0.0V 16.8799ms,0.0
+ 16.8800ms,3.3V 16.8807ms,3.3
+ 16.8808ms,0.0V 16.8999ms,0.0
+ 16.9000ms,3.3V 16.9007ms,3.3
+ 16.9008ms,0.0V 16.9199ms,0.0
+ 16.9200ms,3.3V 16.9207ms,3.3
+ 16.9208ms,0.0V 16.9399ms,0.0
+ 16.9400ms,3.3V 16.9407ms,3.3
+ 16.9408ms,0.0V 16.9599ms,0.0
+ 16.9600ms,3.3V 16.9607ms,3.3
+ 16.9608ms,0.0V 16.9799ms,0.0
+ 16.9800ms,3.3V 16.9807ms,3.3
+ 16.9808ms,0.0V 16.9999ms,0.0
+ 17.0000ms,3.3V 17.0007ms,3.3
+ 17.0008ms,0.0V 17.0199ms,0.0
+ 17.0200ms,3.3V 17.0207ms,3.3
+ 17.0208ms,0.0V 17.0399ms,0.0
+ 17.0400ms,3.3V 17.0407ms,3.3
+ 17.0408ms,0.0V 17.0599ms,0.0
+ 17.0600ms,3.3V 17.0607ms,3.3
+ 17.0608ms,0.0V 17.0799ms,0.0
+ 17.0800ms,3.3V 17.0807ms,3.3
+ 17.0808ms,0.0V 17.0999ms,0.0
+ 17.1000ms,3.3V 17.1007ms,3.3
+ 17.1008ms,0.0V 17.1199ms,0.0
+ 17.1200ms,3.3V 17.1207ms,3.3
+ 17.1208ms,0.0V 17.1399ms,0.0
+ 17.1400ms,3.3V 17.1407ms,3.3
+ 17.1408ms,0.0V 17.1599ms,0.0
+ 17.1600ms,3.3V 17.1607ms,3.3
+ 17.1608ms,0.0V 17.1799ms,0.0
+ 17.1800ms,3.3V 17.1807ms,3.3
+ 17.1808ms,0.0V 17.1999ms,0.0
+ 17.2000ms,3.3V 17.2007ms,3.3
+ 17.2008ms,0.0V 17.2199ms,0.0
+ 17.2200ms,3.3V 17.2207ms,3.3
+ 17.2208ms,0.0V 17.2399ms,0.0
+ 17.2400ms,3.3V 17.2407ms,3.3
+ 17.2408ms,0.0V 17.2599ms,0.0
+ 17.2600ms,3.3V 17.2607ms,3.3
+ 17.2608ms,0.0V 17.2799ms,0.0
+ 17.2800ms,3.3V 17.2807ms,3.3
+ 17.2808ms,0.0V 17.2999ms,0.0
+ 17.3000ms,3.3V 17.3007ms,3.3
+ 17.3008ms,0.0V 17.3199ms,0.0
+ 17.3200ms,3.3V 17.3207ms,3.3
+ 17.3208ms,0.0V 17.3399ms,0.0
+ 17.3400ms,3.3V 17.3407ms,3.3
+ 17.3408ms,0.0V 17.3599ms,0.0
+ 17.3600ms,3.3V 17.3607ms,3.3
+ 17.3608ms,0.0V 17.3799ms,0.0
+ 17.3800ms,3.3V 17.3807ms,3.3
+ 17.3808ms,0.0V 17.3999ms,0.0
+ 17.4000ms,3.3V 17.4007ms,3.3
+ 17.4008ms,0.0V 17.4199ms,0.0
+ 17.4200ms,3.3V 17.4207ms,3.3
+ 17.4208ms,0.0V 17.4399ms,0.0
+ 17.4400ms,3.3V 17.4407ms,3.3
+ 17.4408ms,0.0V 17.4599ms,0.0
+ 17.4600ms,3.3V 17.4607ms,3.3
+ 17.4608ms,0.0V 17.4799ms,0.0
+ 17.4800ms,3.3V 17.4807ms,3.3
+ 17.4808ms,0.0V 17.4999ms,0.0
+ 17.5000ms,3.3V 17.5007ms,3.3
+ 17.5008ms,0.0V 17.5199ms,0.0
+ 17.5200ms,3.3V 17.5207ms,3.3
+ 17.5208ms,0.0V 17.5399ms,0.0
+ 17.5400ms,3.3V 17.5407ms,3.3
+ 17.5408ms,0.0V 17.5599ms,0.0
+ 17.5600ms,3.3V 17.5607ms,3.3
+ 17.5608ms,0.0V 17.5799ms,0.0
+ 17.5800ms,3.3V 17.5807ms,3.3
+ 17.5808ms,0.0V 17.5999ms,0.0
+ 17.6000ms,3.3V 17.6007ms,3.3
+ 17.6008ms,0.0V 17.6199ms,0.0
+ 17.6200ms,3.3V 17.6207ms,3.3
+ 17.6208ms,0.0V 17.6399ms,0.0
+ 17.6400ms,3.3V 17.6407ms,3.3
+ 17.6408ms,0.0V 17.6599ms,0.0
+ 17.6600ms,3.3V 17.6607ms,3.3
+ 17.6608ms,0.0V 17.6799ms,0.0
+ 17.6800ms,3.3V 17.6807ms,3.3
+ 17.6808ms,0.0V 17.6999ms,0.0
+ 17.7000ms,3.3V 17.7007ms,3.3
+ 17.7008ms,0.0V 17.7199ms,0.0
+ 17.7200ms,3.3V 17.7207ms,3.3
+ 17.7208ms,0.0V 17.7399ms,0.0
+ 17.7400ms,3.3V 17.7407ms,3.3
+ 17.7408ms,0.0V 17.7599ms,0.0
+ 17.7600ms,3.3V 17.7607ms,3.3
+ 17.7608ms,0.0V 17.7799ms,0.0
+ 17.7800ms,3.3V 17.7807ms,3.3
+ 17.7808ms,0.0V 17.7999ms,0.0
+ 17.8000ms,3.3V 17.8007ms,3.3
+ 17.8008ms,0.0V 17.8199ms,0.0
+ 17.8200ms,3.3V 17.8207ms,3.3
+ 17.8208ms,0.0V 17.8399ms,0.0
+ 17.8400ms,3.3V 17.8407ms,3.3
+ 17.8408ms,0.0V 17.8599ms,0.0
+ 17.8600ms,3.3V 17.8607ms,3.3
+ 17.8608ms,0.0V 17.8799ms,0.0
+ 17.8800ms,3.3V 17.8807ms,3.3
+ 17.8808ms,0.0V 17.8999ms,0.0
+ 17.9000ms,3.3V 17.9007ms,3.3
+ 17.9008ms,0.0V 17.9199ms,0.0
+ 17.9200ms,3.3V 17.9207ms,3.3
+ 17.9208ms,0.0V 17.9399ms,0.0
+ 17.9400ms,3.3V 17.9407ms,3.3
+ 17.9408ms,0.0V 17.9599ms,0.0
+ 17.9600ms,3.3V 17.9607ms,3.3
+ 17.9608ms,0.0V 17.9799ms,0.0
+ 17.9800ms,3.3V 17.9807ms,3.3
+ 17.9808ms,0.0V 17.9999ms,0.0
+ 18.0000ms,3.3V 18.0007ms,3.3
+ 18.0008ms,0.0V 18.0199ms,0.0
+ 18.0200ms,3.3V 18.0207ms,3.3
+ 18.0208ms,0.0V 18.0399ms,0.0
+ 18.0400ms,3.3V 18.0407ms,3.3
+ 18.0408ms,0.0V 18.0599ms,0.0
+ 18.0600ms,3.3V 18.0607ms,3.3
+ 18.0608ms,0.0V 18.0799ms,0.0
+ 18.0800ms,3.3V 18.0807ms,3.3
+ 18.0808ms,0.0V 18.0999ms,0.0
+ 18.1000ms,3.3V 18.1007ms,3.3
+ 18.1008ms,0.0V 18.1199ms,0.0
+ 18.1200ms,3.3V 18.1207ms,3.3
+ 18.1208ms,0.0V 18.1399ms,0.0
+ 18.1400ms,3.3V 18.1407ms,3.3
+ 18.1408ms,0.0V 18.1599ms,0.0
+ 18.1600ms,3.3V 18.1607ms,3.3
+ 18.1608ms,0.0V 18.1799ms,0.0
+ 18.1800ms,3.3V 18.1807ms,3.3
+ 18.1808ms,0.0V 18.1999ms,0.0
+ 18.2000ms,3.3V 18.2007ms,3.3
+ 18.2008ms,0.0V 18.2199ms,0.0
+ 18.2200ms,3.3V 18.2207ms,3.3
+ 18.2208ms,0.0V 18.2399ms,0.0
+ 18.2400ms,3.3V 18.2407ms,3.3
+ 18.2408ms,0.0V 18.2599ms,0.0
+ 18.2600ms,3.3V 18.2607ms,3.3
+ 18.2608ms,0.0V 18.2799ms,0.0
+ 18.2800ms,3.3V 18.2807ms,3.3
+ 18.2808ms,0.0V 18.2999ms,0.0
+ 18.3000ms,3.3V 18.3007ms,3.3
+ 18.3008ms,0.0V 18.3199ms,0.0
+ 18.3200ms,3.3V 18.3207ms,3.3
+ 18.3208ms,0.0V 18.3399ms,0.0
+ 18.3400ms,3.3V 18.3407ms,3.3
+ 18.3408ms,0.0V 18.3599ms,0.0
+ 18.3600ms,3.3V 18.3607ms,3.3
+ 18.3608ms,0.0V 18.3799ms,0.0
+ 18.3800ms,3.3V 18.3807ms,3.3
+ 18.3808ms,0.0V 18.3999ms,0.0
+ 18.4000ms,3.3V 18.4007ms,3.3
+ 18.4008ms,0.0V 18.4199ms,0.0
+ 18.4200ms,3.3V 18.4207ms,3.3
+ 18.4208ms,0.0V 18.4399ms,0.0
+ 18.4400ms,3.3V 18.4407ms,3.3
+ 18.4408ms,0.0V 18.4599ms,0.0
+ 18.4600ms,3.3V 18.4607ms,3.3
+ 18.4608ms,0.0V 18.4799ms,0.0
+ 18.4800ms,3.3V 18.4807ms,3.3
+ 18.4808ms,0.0V 18.4999ms,0.0
+ 18.5000ms,3.3V 18.5007ms,3.3
+ 18.5008ms,0.0V 18.5199ms,0.0
+ 18.5200ms,3.3V 18.5207ms,3.3
+ 18.5208ms,0.0V 18.5399ms,0.0
+ 18.5400ms,3.3V 18.5407ms,3.3
+ 18.5408ms,0.0V 18.5599ms,0.0
+ 18.5600ms,3.3V 18.5607ms,3.3
+ 18.5608ms,0.0V 18.5799ms,0.0
+ 18.5800ms,3.3V 18.5807ms,3.3
+ 18.5808ms,0.0V 18.5999ms,0.0
+ 18.6000ms,3.3V 18.6007ms,3.3
+ 18.6008ms,0.0V 18.6199ms,0.0
+ 18.6200ms,3.3V 18.6207ms,3.3
+ 18.6208ms,0.0V 18.6399ms,0.0
+ 18.6400ms,3.3V 18.6407ms,3.3
+ 18.6408ms,0.0V 18.6599ms,0.0
+ 18.6600ms,3.3V 18.6607ms,3.3
+ 18.6608ms,0.0V 18.6799ms,0.0
+ 18.6800ms,3.3V 18.6807ms,3.3
+ 18.6808ms,0.0V 18.6999ms,0.0
+ 18.7000ms,3.3V 18.7007ms,3.3
+ 18.7008ms,0.0V 18.7199ms,0.0
+ 18.7200ms,3.3V 18.7207ms,3.3
+ 18.7208ms,0.0V 18.7399ms,0.0
+ 18.7400ms,3.3V 18.7407ms,3.3
+ 18.7408ms,0.0V 18.7599ms,0.0
+ 18.7600ms,3.3V 18.7607ms,3.3
+ 18.7608ms,0.0V 18.7799ms,0.0
+ 18.7800ms,3.3V 18.7807ms,3.3
+ 18.7808ms,0.0V 18.7999ms,0.0
+ 18.8000ms,3.3V 18.8007ms,3.3
+ 18.8008ms,0.0V 18.8199ms,0.0
+ 18.8200ms,3.3V 18.8207ms,3.3
+ 18.8208ms,0.0V 18.8399ms,0.0
+ 18.8400ms,3.3V 18.8407ms,3.3
+ 18.8408ms,0.0V 18.8599ms,0.0
+ 18.8600ms,3.3V 18.8607ms,3.3
+ 18.8608ms,0.0V 18.8799ms,0.0
+ 18.8800ms,3.3V 18.8807ms,3.3
+ 18.8808ms,0.0V 18.8999ms,0.0
+ 18.9000ms,3.3V 18.9007ms,3.3
+ 18.9008ms,0.0V 18.9199ms,0.0
+ 18.9200ms,3.3V 18.9207ms,3.3
+ 18.9208ms,0.0V 18.9399ms,0.0
+ 18.9400ms,3.3V 18.9407ms,3.3
+ 18.9408ms,0.0V 18.9599ms,0.0
+ 18.9600ms,3.3V 18.9607ms,3.3
+ 18.9608ms,0.0V 18.9799ms,0.0
+ 18.9800ms,3.3V 18.9807ms,3.3
+ 18.9808ms,0.0V 18.9999ms,0.0
+ 19.0000ms,3.3V 19.0007ms,3.3
+ 19.0008ms,0.0V 19.0199ms,0.0
+ 19.0200ms,3.3V 19.0207ms,3.3
+ 19.0208ms,0.0V 19.0399ms,0.0
+ 19.0400ms,3.3V 19.0407ms,3.3
+ 19.0408ms,0.0V 19.0599ms,0.0
+ 19.0600ms,3.3V 19.0607ms,3.3
+ 19.0608ms,0.0V 19.0799ms,0.0
+ 19.0800ms,3.3V 19.0807ms,3.3
+ 19.0808ms,0.0V 19.0999ms,0.0
+ 19.1000ms,3.3V 19.1007ms,3.3
+ 19.1008ms,0.0V 19.1199ms,0.0
+ 19.1200ms,3.3V 19.1207ms,3.3
+ 19.1208ms,0.0V 19.1399ms,0.0
+ 19.1400ms,3.3V 19.1407ms,3.3
+ 19.1408ms,0.0V 19.1599ms,0.0
+ 19.1600ms,3.3V 19.1607ms,3.3
+ 19.1608ms,0.0V 19.1799ms,0.0
+ 19.1800ms,3.3V 19.1807ms,3.3
+ 19.1808ms,0.0V 19.1999ms,0.0
+ 19.2000ms,3.3V 19.2007ms,3.3
+ 19.2008ms,0.0V 19.2199ms,0.0
+ 19.2200ms,3.3V 19.2207ms,3.3
+ 19.2208ms,0.0V 19.2399ms,0.0
+ 19.2400ms,3.3V 19.2407ms,3.3
+ 19.2408ms,0.0V 19.2599ms,0.0
+ 19.2600ms,3.3V 19.2607ms,3.3
+ 19.2608ms,0.0V 19.2799ms,0.0
+ 19.2800ms,3.3V 19.2807ms,3.3
+ 19.2808ms,0.0V 19.2999ms,0.0
+ 19.3000ms,3.3V 19.3007ms,3.3
+ 19.3008ms,0.0V 19.3199ms,0.0
+ 19.3200ms,3.3V 19.3207ms,3.3
+ 19.3208ms,0.0V 19.3399ms,0.0
+ 19.3400ms,3.3V 19.3407ms,3.3
+ 19.3408ms,0.0V 19.3599ms,0.0
+ 19.3600ms,3.3V 19.3607ms,3.3
+ 19.3608ms,0.0V 19.3799ms,0.0
+ 19.3800ms,3.3V 19.3807ms,3.3
+ 19.3808ms,0.0V 19.3999ms,0.0
+ 19.4000ms,3.3V 19.4007ms,3.3
+ 19.4008ms,0.0V 19.4199ms,0.0
+ 19.4200ms,3.3V 19.4207ms,3.3
+ 19.4208ms,0.0V 19.4399ms,0.0
+ 19.4400ms,3.3V 19.4407ms,3.3
+ 19.4408ms,0.0V 19.4599ms,0.0
+ 19.4600ms,3.3V 19.4607ms,3.3
+ 19.4608ms,0.0V 19.4799ms,0.0
+ 19.4800ms,3.3V 19.4807ms,3.3
+ 19.4808ms,0.0V 19.4999ms,0.0
+ 19.5000ms,3.3V 19.5007ms,3.3
+ 19.5008ms,0.0V 19.5199ms,0.0
+ 19.5200ms,3.3V 19.5207ms,3.3
+ 19.5208ms,0.0V 19.5399ms,0.0
+ 19.5400ms,3.3V 19.5407ms,3.3
+ 19.5408ms,0.0V 19.5599ms,0.0
+ 19.5600ms,3.3V 19.5607ms,3.3
+ 19.5608ms,0.0V 19.5799ms,0.0
+ 19.5800ms,3.3V 19.5807ms,3.3
+ 19.5808ms,0.0V 19.5999ms,0.0
+ 19.6000ms,3.3V 19.6007ms,3.3
+ 19.6008ms,0.0V 19.6199ms,0.0
+ 19.6200ms,3.3V 19.6207ms,3.3
+ 19.6208ms,0.0V 19.6399ms,0.0
+ 19.6400ms,3.3V 19.6407ms,3.3
+ 19.6408ms,0.0V 19.6599ms,0.0
+ 19.6600ms,3.3V 19.6607ms,3.3
+ 19.6608ms,0.0V 19.6799ms,0.0
+ 19.6800ms,3.3V 19.6807ms,3.3
+ 19.6808ms,0.0V 19.6999ms,0.0
+ 19.7000ms,3.3V 19.7007ms,3.3
+ 19.7008ms,0.0V 19.7199ms,0.0
+ 19.7200ms,3.3V 19.7207ms,3.3
+ 19.7208ms,0.0V 19.7399ms,0.0
+ 19.7400ms,3.3V 19.7407ms,3.3
+ 19.7408ms,0.0V 19.7599ms,0.0
+ 19.7600ms,3.3V 19.7607ms,3.3
+ 19.7608ms,0.0V 19.7799ms,0.0
+ 19.7800ms,3.3V 19.7807ms,3.3
+ 19.7808ms,0.0V 19.7999ms,0.0
+ 19.8000ms,3.3V 19.8007ms,3.3
+ 19.8008ms,0.0V 19.8199ms,0.0
+ 19.8200ms,3.3V 19.8207ms,3.3
+ 19.8208ms,0.0V 19.8399ms,0.0
+ 19.8400ms,3.3V 19.8407ms,3.3
+ 19.8408ms,0.0V 19.8599ms,0.0
+ 19.8600ms,3.3V 19.8607ms,3.3
+ 19.8608ms,0.0V 19.8799ms,0.0
+ 19.8800ms,3.3V 19.8807ms,3.3
+ 19.8808ms,0.0V 19.8999ms,0.0
+ 19.9000ms,3.3V 19.9007ms,3.3
+ 19.9008ms,0.0V 19.9199ms,0.0
+ 19.9200ms,3.3V 19.9207ms,3.3
+ 19.9208ms,0.0V 19.9399ms,0.0
+ 19.9400ms,3.3V 19.9407ms,3.3
+ 19.9408ms,0.0V 19.9599ms,0.0
+ 19.9600ms,3.3V 19.9607ms,3.3
+ 19.9608ms,0.0V 19.9799ms,0.0
+ 19.9800ms,3.3V 19.9807ms,3.3
+ 19.9808ms,0.0V 19.9999ms,0.0
+ 20.0000ms,3.3V 20.0007ms,3.3
+ 20.0008ms,0.0V 20.0199ms,0.0
+ 20.0200ms,3.3V 20.0207ms,3.3
+ 20.0208ms,0.0V 20.0399ms,0.0
+ 20.0400ms,3.3V 20.0407ms,3.3
+ 20.0408ms,0.0V 20.0599ms,0.0
+ 20.0600ms,3.3V 20.0607ms,3.3
+ 20.0608ms,0.0V 20.0799ms,0.0
+ 20.0800ms,3.3V 20.0809ms,3.3
+ 20.0810ms,0.0V 20.0999ms,0.0
+ 20.1000ms,3.3V 20.1009ms,3.3
+ 20.1010ms,0.0V 20.1199ms,0.0
+ 20.1200ms,3.3V 20.1209ms,3.3
+ 20.1210ms,0.0V 20.1399ms,0.0
+ 20.1400ms,3.3V 20.1409ms,3.3
+ 20.1410ms,0.0V 20.1599ms,0.0
+ 20.1600ms,3.3V 20.1609ms,3.3
+ 20.1610ms,0.0V 20.1799ms,0.0
+ 20.1800ms,3.3V 20.1809ms,3.3
+ 20.1810ms,0.0V 20.1999ms,0.0
+ 20.2000ms,3.3V 20.2009ms,3.3
+ 20.2010ms,0.0V 20.2199ms,0.0
+ 20.2200ms,3.3V 20.2209ms,3.3
+ 20.2210ms,0.0V 20.2399ms,0.0
+ 20.2400ms,3.3V 20.2409ms,3.3
+ 20.2410ms,0.0V 20.2599ms,0.0
+ 20.2600ms,3.3V 20.2609ms,3.3
+ 20.2610ms,0.0V 20.2799ms,0.0
+ 20.2800ms,3.3V 20.2809ms,3.3
+ 20.2810ms,0.0V 20.2999ms,0.0
+ 20.3000ms,3.3V 20.3009ms,3.3
+ 20.3010ms,0.0V 20.3199ms,0.0
+ 20.3200ms,3.3V 20.3209ms,3.3
+ 20.3210ms,0.0V 20.3399ms,0.0
+ 20.3400ms,3.3V 20.3409ms,3.3
+ 20.3410ms,0.0V 20.3599ms,0.0
+ 20.3600ms,3.3V 20.3609ms,3.3
+ 20.3610ms,0.0V 20.3799ms,0.0
+ 20.3800ms,3.3V 20.3809ms,3.3
+ 20.3810ms,0.0V 20.3999ms,0.0
+ 20.4000ms,3.3V 20.4009ms,3.3
+ 20.4010ms,0.0V 20.4199ms,0.0
+ 20.4200ms,3.3V 20.4209ms,3.3
+ 20.4210ms,0.0V 20.4399ms,0.0
+ 20.4400ms,3.3V 20.4409ms,3.3
+ 20.4410ms,0.0V 20.4599ms,0.0
+ 20.4600ms,3.3V 20.4609ms,3.3
+ 20.4610ms,0.0V 20.4799ms,0.0
+ 20.4800ms,3.3V 20.4809ms,3.3
+ 20.4810ms,0.0V 20.4999ms,0.0
+ 20.5000ms,3.3V 20.5009ms,3.3
+ 20.5010ms,0.0V 20.5199ms,0.0
+ 20.5200ms,3.3V 20.5209ms,3.3
+ 20.5210ms,0.0V 20.5399ms,0.0
+ 20.5400ms,3.3V 20.5409ms,3.3
+ 20.5410ms,0.0V 20.5599ms,0.0
+ 20.5600ms,3.3V 20.5609ms,3.3
+ 20.5610ms,0.0V 20.5799ms,0.0
+ 20.5800ms,3.3V 20.5809ms,3.3
+ 20.5810ms,0.0V 20.5999ms,0.0
+ 20.6000ms,3.3V 20.6009ms,3.3
+ 20.6010ms,0.0V 20.6199ms,0.0
+ 20.6200ms,3.3V 20.6209ms,3.3
+ 20.6210ms,0.0V 20.6399ms,0.0
+ 20.6400ms,3.3V 20.6409ms,3.3
+ 20.6410ms,0.0V 20.6599ms,0.0
+ 20.6600ms,3.3V 20.6609ms,3.3
+ 20.6610ms,0.0V 20.6799ms,0.0
+ 20.6800ms,3.3V 20.6809ms,3.3
+ 20.6810ms,0.0V 20.6999ms,0.0
+ 20.7000ms,3.3V 20.7009ms,3.3
+ 20.7010ms,0.0V 20.7199ms,0.0
+ 20.7200ms,3.3V 20.7209ms,3.3
+ 20.7210ms,0.0V 20.7399ms,0.0
+ 20.7400ms,3.3V 20.7409ms,3.3
+ 20.7410ms,0.0V 20.7599ms,0.0
+ 20.7600ms,3.3V 20.7609ms,3.3
+ 20.7610ms,0.0V 20.7799ms,0.0
+ 20.7800ms,3.3V 20.7809ms,3.3
+ 20.7810ms,0.0V 20.7999ms,0.0
+ 20.8000ms,3.3V 20.8009ms,3.3
+ 20.8010ms,0.0V 20.8199ms,0.0
+ 20.8200ms,3.3V 20.8209ms,3.3
+ 20.8210ms,0.0V 20.8399ms,0.0
+ 20.8400ms,3.3V 20.8409ms,3.3
+ 20.8410ms,0.0V 20.8599ms,0.0
+ 20.8600ms,3.3V 20.8609ms,3.3
+ 20.8610ms,0.0V 20.8799ms,0.0
+ 20.8800ms,3.3V 20.8809ms,3.3
+ 20.8810ms,0.0V 20.8999ms,0.0
+ 20.9000ms,3.3V 20.9009ms,3.3
+ 20.9010ms,0.0V 20.9199ms,0.0
+ 20.9200ms,3.3V 20.9209ms,3.3
+ 20.9210ms,0.0V 20.9399ms,0.0
+ 20.9400ms,3.3V 20.9409ms,3.3
+ 20.9410ms,0.0V 20.9599ms,0.0
+ 20.9600ms,3.3V 20.9609ms,3.3
+ 20.9610ms,0.0V 20.9799ms,0.0
+ 20.9800ms,3.3V 20.9809ms,3.3
+ 20.9810ms,0.0V 20.9999ms,0.0
+ 21.0000ms,3.3V 21.0009ms,3.3
+ 21.0010ms,0.0V 21.0199ms,0.0
+ 21.0200ms,3.3V 21.0209ms,3.3
+ 21.0210ms,0.0V 21.0399ms,0.0
+ 21.0400ms,3.3V 21.0409ms,3.3
+ 21.0410ms,0.0V 21.0599ms,0.0
+ 21.0600ms,3.3V 21.0609ms,3.3
+ 21.0610ms,0.0V 21.0799ms,0.0
+ 21.0800ms,3.3V 21.0809ms,3.3
+ 21.0810ms,0.0V 21.0999ms,0.0
+ 21.1000ms,3.3V 21.1009ms,3.3
+ 21.1010ms,0.0V 21.1199ms,0.0
+ 21.1200ms,3.3V 21.1209ms,3.3
+ 21.1210ms,0.0V 21.1399ms,0.0
+ 21.1400ms,3.3V 21.1409ms,3.3
+ 21.1410ms,0.0V 21.1599ms,0.0
+ 21.1600ms,3.3V 21.1609ms,3.3
+ 21.1610ms,0.0V 21.1799ms,0.0
+ 21.1800ms,3.3V 21.1809ms,3.3
+ 21.1810ms,0.0V 21.1999ms,0.0
+ 21.2000ms,3.3V 21.2009ms,3.3
+ 21.2010ms,0.0V 21.2199ms,0.0
+ 21.2200ms,3.3V 21.2209ms,3.3
+ 21.2210ms,0.0V 21.2399ms,0.0
+ 21.2400ms,3.3V 21.2409ms,3.3
+ 21.2410ms,0.0V 21.2599ms,0.0
+ 21.2600ms,3.3V 21.2609ms,3.3
+ 21.2610ms,0.0V 21.2799ms,0.0
+ 21.2800ms,3.3V 21.2809ms,3.3
+ 21.2810ms,0.0V 21.2999ms,0.0
+ 21.3000ms,3.3V 21.3009ms,3.3
+ 21.3010ms,0.0V 21.3199ms,0.0
+ 21.3200ms,3.3V 21.3209ms,3.3
+ 21.3210ms,0.0V 21.3399ms,0.0
+ 21.3400ms,3.3V 21.3409ms,3.3
+ 21.3410ms,0.0V 21.3599ms,0.0
+ 21.3600ms,3.3V 21.3609ms,3.3
+ 21.3610ms,0.0V 21.3799ms,0.0
+ 21.3800ms,3.3V 21.3809ms,3.3
+ 21.3810ms,0.0V 21.3999ms,0.0
+ 21.4000ms,3.3V 21.4009ms,3.3
+ 21.4010ms,0.0V 21.4199ms,0.0
+ 21.4200ms,3.3V 21.4209ms,3.3
+ 21.4210ms,0.0V 21.4399ms,0.0
+ 21.4400ms,3.3V 21.4409ms,3.3
+ 21.4410ms,0.0V 21.4599ms,0.0
+ 21.4600ms,3.3V 21.4609ms,3.3
+ 21.4610ms,0.0V 21.4799ms,0.0
+ 21.4800ms,3.3V 21.4809ms,3.3
+ 21.4810ms,0.0V 21.4999ms,0.0
+ 21.5000ms,3.3V 21.5009ms,3.3
+ 21.5010ms,0.0V 21.5199ms,0.0
+ 21.5200ms,3.3V 21.5209ms,3.3
+ 21.5210ms,0.0V 21.5399ms,0.0
+ 21.5400ms,3.3V 21.5409ms,3.3
+ 21.5410ms,0.0V 21.5599ms,0.0
+ 21.5600ms,3.3V 21.5609ms,3.3
+ 21.5610ms,0.0V 21.5799ms,0.0
+ 21.5800ms,3.3V 21.5809ms,3.3
+ 21.5810ms,0.0V 21.5999ms,0.0
+ 21.6000ms,3.3V 21.6009ms,3.3
+ 21.6010ms,0.0V 21.6199ms,0.0
+ 21.6200ms,3.3V 21.6209ms,3.3
+ 21.6210ms,0.0V 21.6399ms,0.0
+ 21.6400ms,3.3V 21.6409ms,3.3
+ 21.6410ms,0.0V 21.6599ms,0.0
+ 21.6600ms,3.3V 21.6609ms,3.3
+ 21.6610ms,0.0V 21.6799ms,0.0
+ 21.6800ms,3.3V 21.6809ms,3.3
+ 21.6810ms,0.0V 21.6999ms,0.0
+ 21.7000ms,3.3V 21.7009ms,3.3
+ 21.7010ms,0.0V 21.7199ms,0.0
+ 21.7200ms,3.3V 21.7209ms,3.3
+ 21.7210ms,0.0V 21.7399ms,0.0
+ 21.7400ms,3.3V 21.7409ms,3.3
+ 21.7410ms,0.0V 21.7599ms,0.0
+ 21.7600ms,3.3V 21.7609ms,3.3
+ 21.7610ms,0.0V 21.7799ms,0.0
+ 21.7800ms,3.3V 21.7809ms,3.3
+ 21.7810ms,0.0V 21.7999ms,0.0
+ 21.8000ms,3.3V 21.8009ms,3.3
+ 21.8010ms,0.0V 21.8199ms,0.0
+ 21.8200ms,3.3V 21.8209ms,3.3
+ 21.8210ms,0.0V 21.8399ms,0.0
+ 21.8400ms,3.3V 21.8409ms,3.3
+ 21.8410ms,0.0V 21.8599ms,0.0
+ 21.8600ms,3.3V 21.8609ms,3.3
+ 21.8610ms,0.0V 21.8799ms,0.0
+ 21.8800ms,3.3V 21.8809ms,3.3
+ 21.8810ms,0.0V 21.8999ms,0.0
+ 21.9000ms,3.3V 21.9009ms,3.3
+ 21.9010ms,0.0V 21.9199ms,0.0
+ 21.9200ms,3.3V 21.9209ms,3.3
+ 21.9210ms,0.0V 21.9399ms,0.0
+ 21.9400ms,3.3V 21.9409ms,3.3
+ 21.9410ms,0.0V 21.9599ms,0.0
+ 21.9600ms,3.3V 21.9609ms,3.3
+ 21.9610ms,0.0V 21.9799ms,0.0
+ 21.9800ms,3.3V 21.9809ms,3.3
+ 21.9810ms,0.0V 21.9999ms,0.0
+ 22.0000ms,3.3V 22.0009ms,3.3
+ 22.0010ms,0.0V 22.0199ms,0.0
+ 22.0200ms,3.3V 22.0209ms,3.3
+ 22.0210ms,0.0V 22.0399ms,0.0
+ 22.0400ms,3.3V 22.0409ms,3.3
+ 22.0410ms,0.0V 22.0599ms,0.0
+ 22.0600ms,3.3V 22.0609ms,3.3
+ 22.0610ms,0.0V 22.0799ms,0.0
+ 22.0800ms,3.3V 22.0809ms,3.3
+ 22.0810ms,0.0V 22.0999ms,0.0
+ 22.1000ms,3.3V 22.1009ms,3.3
+ 22.1010ms,0.0V 22.1199ms,0.0
+ 22.1200ms,3.3V 22.1209ms,3.3
+ 22.1210ms,0.0V 22.1399ms,0.0
+ 22.1400ms,3.3V 22.1409ms,3.3
+ 22.1410ms,0.0V 22.1599ms,0.0
+ 22.1600ms,3.3V 22.1609ms,3.3
+ 22.1610ms,0.0V 22.1799ms,0.0
+ 22.1800ms,3.3V 22.1809ms,3.3
+ 22.1810ms,0.0V 22.1999ms,0.0
+ 22.2000ms,3.3V 22.2009ms,3.3
+ 22.2010ms,0.0V 22.2199ms,0.0
+ 22.2200ms,3.3V 22.2209ms,3.3
+ 22.2210ms,0.0V 22.2399ms,0.0
+ 22.2400ms,3.3V 22.2409ms,3.3
+ 22.2410ms,0.0V 22.2599ms,0.0
+ 22.2600ms,3.3V 22.2609ms,3.3
+ 22.2610ms,0.0V 22.2799ms,0.0
+ 22.2800ms,3.3V 22.2809ms,3.3
+ 22.2810ms,0.0V 22.2999ms,0.0
+ 22.3000ms,3.3V 22.3009ms,3.3
+ 22.3010ms,0.0V 22.3199ms,0.0
+ 22.3200ms,3.3V 22.3209ms,3.3
+ 22.3210ms,0.0V 22.3399ms,0.0
+ 22.3400ms,3.3V 22.3409ms,3.3
+ 22.3410ms,0.0V 22.3599ms,0.0
+ 22.3600ms,3.3V 22.3609ms,3.3
+ 22.3610ms,0.0V 22.3799ms,0.0
+ 22.3800ms,3.3V 22.3809ms,3.3
+ 22.3810ms,0.0V 22.3999ms,0.0
+ 22.4000ms,3.3V 22.4009ms,3.3
+ 22.4010ms,0.0V 22.4199ms,0.0
+ 22.4200ms,3.3V 22.4209ms,3.3
+ 22.4210ms,0.0V 22.4399ms,0.0
+ 22.4400ms,3.3V 22.4409ms,3.3
+ 22.4410ms,0.0V 22.4599ms,0.0
+ 22.4600ms,3.3V 22.4609ms,3.3
+ 22.4610ms,0.0V 22.4799ms,0.0
+ 22.4800ms,3.3V 22.4809ms,3.3
+ 22.4810ms,0.0V 22.4999ms,0.0
+ 22.5000ms,3.3V 22.5009ms,3.3
+ 22.5010ms,0.0V 22.5199ms,0.0
+ 22.5200ms,3.3V 22.5209ms,3.3
+ 22.5210ms,0.0V 22.5399ms,0.0
+ 22.5400ms,3.3V 22.5409ms,3.3
+ 22.5410ms,0.0V 22.5599ms,0.0
+ 22.5600ms,3.3V 22.5609ms,3.3
+ 22.5610ms,0.0V 22.5799ms,0.0
+ 22.5800ms,3.3V 22.5809ms,3.3
+ 22.5810ms,0.0V 22.5999ms,0.0
+ 22.6000ms,3.3V 22.6009ms,3.3
+ 22.6010ms,0.0V 22.6199ms,0.0
+ 22.6200ms,3.3V 22.6209ms,3.3
+ 22.6210ms,0.0V 22.6399ms,0.0
+ 22.6400ms,3.3V 22.6409ms,3.3
+ 22.6410ms,0.0V 22.6599ms,0.0
+ 22.6600ms,3.3V 22.6609ms,3.3
+ 22.6610ms,0.0V 22.6799ms,0.0
+ 22.6800ms,3.3V 22.6809ms,3.3
+ 22.6810ms,0.0V 22.6999ms,0.0
+ 22.7000ms,3.3V 22.7009ms,3.3
+ 22.7010ms,0.0V 22.7199ms,0.0
+ 22.7200ms,3.3V 22.7209ms,3.3
+ 22.7210ms,0.0V 22.7399ms,0.0
+ 22.7400ms,3.3V 22.7409ms,3.3
+ 22.7410ms,0.0V 22.7599ms,0.0
+ 22.7600ms,3.3V 22.7609ms,3.3
+ 22.7610ms,0.0V 22.7799ms,0.0
+ 22.7800ms,3.3V 22.7809ms,3.3
+ 22.7810ms,0.0V 22.7999ms,0.0
+ 22.8000ms,3.3V 22.8009ms,3.3
+ 22.8010ms,0.0V 22.8199ms,0.0
+ 22.8200ms,3.3V 22.8209ms,3.3
+ 22.8210ms,0.0V 22.8399ms,0.0
+ 22.8400ms,3.3V 22.8409ms,3.3
+ 22.8410ms,0.0V 22.8599ms,0.0
+ 22.8600ms,3.3V 22.8609ms,3.3
+ 22.8610ms,0.0V 22.8799ms,0.0
+ 22.8800ms,3.3V 22.8809ms,3.3
+ 22.8810ms,0.0V 22.8999ms,0.0
+ 22.9000ms,3.3V 22.9009ms,3.3
+ 22.9010ms,0.0V 22.9199ms,0.0
+ 22.9200ms,3.3V 22.9209ms,3.3
+ 22.9210ms,0.0V 22.9399ms,0.0
+ 22.9400ms,3.3V 22.9409ms,3.3
+ 22.9410ms,0.0V 22.9599ms,0.0
+ 22.9600ms,3.3V 22.9609ms,3.3
+ 22.9610ms,0.0V 22.9799ms,0.0
+ 22.9800ms,3.3V 22.9809ms,3.3
+ 22.9810ms,0.0V 22.9999ms,0.0
+ 23.0000ms,3.3V 23.0009ms,3.3
+ 23.0010ms,0.0V 23.0199ms,0.0
+ 23.0200ms,3.3V 23.0209ms,3.3
+ 23.0210ms,0.0V 23.0399ms,0.0
+ 23.0400ms,3.3V 23.0409ms,3.3
+ 23.0410ms,0.0V 23.0599ms,0.0
+ 23.0600ms,3.3V 23.0609ms,3.3
+ 23.0610ms,0.0V 23.0799ms,0.0
+ 23.0800ms,3.3V 23.0809ms,3.3
+ 23.0810ms,0.0V 23.0999ms,0.0
+ 23.1000ms,3.3V 23.1009ms,3.3
+ 23.1010ms,0.0V 23.1199ms,0.0
+ 23.1200ms,3.3V 23.1209ms,3.3
+ 23.1210ms,0.0V 23.1399ms,0.0
+ 23.1400ms,3.3V 23.1409ms,3.3
+ 23.1410ms,0.0V 23.1599ms,0.0
+ 23.1600ms,3.3V 23.1609ms,3.3
+ 23.1610ms,0.0V 23.1799ms,0.0
+ 23.1800ms,3.3V 23.1809ms,3.3
+ 23.1810ms,0.0V 23.1999ms,0.0
+ 23.2000ms,3.3V 23.2009ms,3.3
+ 23.2010ms,0.0V 23.2199ms,0.0
+ 23.2200ms,3.3V 23.2209ms,3.3
+ 23.2210ms,0.0V 23.2399ms,0.0
+ 23.2400ms,3.3V 23.2409ms,3.3
+ 23.2410ms,0.0V 23.2599ms,0.0
+ 23.2600ms,3.3V 23.2609ms,3.3
+ 23.2610ms,0.0V 23.2799ms,0.0
+ 23.2800ms,3.3V 23.2809ms,3.3
+ 23.2810ms,0.0V 23.2999ms,0.0
+ 23.3000ms,3.3V 23.3009ms,3.3
+ 23.3010ms,0.0V 23.3199ms,0.0
+ 23.3200ms,3.3V 23.3209ms,3.3
+ 23.3210ms,0.0V 23.3399ms,0.0
+ 23.3400ms,3.3V 23.3409ms,3.3
+ 23.3410ms,0.0V 23.3599ms,0.0
+ 23.3600ms,3.3V 23.3609ms,3.3
+ 23.3610ms,0.0V 23.3799ms,0.0
+ 23.3800ms,3.3V 23.3809ms,3.3
+ 23.3810ms,0.0V 23.3999ms,0.0
+ 23.4000ms,3.3V 23.4009ms,3.3
+ 23.4010ms,0.0V 23.4199ms,0.0
+ 23.4200ms,3.3V 23.4209ms,3.3
+ 23.4210ms,0.0V 23.4399ms,0.0
+ 23.4400ms,3.3V 23.4409ms,3.3
+ 23.4410ms,0.0V 23.4599ms,0.0
+ 23.4600ms,3.3V 23.4609ms,3.3
+ 23.4610ms,0.0V 23.4799ms,0.0
+ 23.4800ms,3.3V 23.4809ms,3.3
+ 23.4810ms,0.0V 23.4999ms,0.0
+ 23.5000ms,3.3V 23.5009ms,3.3
+ 23.5010ms,0.0V 23.5199ms,0.0
+ 23.5200ms,3.3V 23.5209ms,3.3
+ 23.5210ms,0.0V 23.5399ms,0.0
+ 23.5400ms,3.3V 23.5409ms,3.3
+ 23.5410ms,0.0V 23.5599ms,0.0
+ 23.5600ms,3.3V 23.5609ms,3.3
+ 23.5610ms,0.0V 23.5799ms,0.0
+ 23.5800ms,3.3V 23.5809ms,3.3
+ 23.5810ms,0.0V 23.5999ms,0.0
+ 23.6000ms,3.3V 23.6009ms,3.3
+ 23.6010ms,0.0V 23.6199ms,0.0
+ 23.6200ms,3.3V 23.6209ms,3.3
+ 23.6210ms,0.0V 23.6399ms,0.0
+ 23.6400ms,3.3V 23.6409ms,3.3
+ 23.6410ms,0.0V 23.6599ms,0.0
+ 23.6600ms,3.3V 23.6609ms,3.3
+ 23.6610ms,0.0V 23.6799ms,0.0
+ 23.6800ms,3.3V 23.6809ms,3.3
+ 23.6810ms,0.0V 23.6999ms,0.0
+ 23.7000ms,3.3V 23.7009ms,3.3
+ 23.7010ms,0.0V 23.7199ms,0.0
+ 23.7200ms,3.3V 23.7209ms,3.3
+ 23.7210ms,0.0V 23.7399ms,0.0
+ 23.7400ms,3.3V 23.7409ms,3.3
+ 23.7410ms,0.0V 23.7599ms,0.0
+ 23.7600ms,3.3V 23.7609ms,3.3
+ 23.7610ms,0.0V 23.7799ms,0.0
+ 23.7800ms,3.3V 23.7809ms,3.3
+ 23.7810ms,0.0V 23.7999ms,0.0
+ 23.8000ms,3.3V 23.8009ms,3.3
+ 23.8010ms,0.0V 23.8199ms,0.0
+ 23.8200ms,3.3V 23.8209ms,3.3
+ 23.8210ms,0.0V 23.8399ms,0.0
+ 23.8400ms,3.3V 23.8409ms,3.3
+ 23.8410ms,0.0V 23.8599ms,0.0
+ 23.8600ms,3.3V 23.8609ms,3.3
+ 23.8610ms,0.0V 23.8799ms,0.0
+ 23.8800ms,3.3V 23.8809ms,3.3
+ 23.8810ms,0.0V 23.8999ms,0.0
+ 23.9000ms,3.3V 23.9009ms,3.3
+ 23.9010ms,0.0V 23.9199ms,0.0
+ 23.9200ms,3.3V 23.9209ms,3.3
+ 23.9210ms,0.0V 23.9399ms,0.0
+ 23.9400ms,3.3V 23.9409ms,3.3
+ 23.9410ms,0.0V 23.9599ms,0.0
+ 23.9600ms,3.3V 23.9609ms,3.3
+ 23.9610ms,0.0V 23.9799ms,0.0
+ 23.9800ms,3.3V 23.9809ms,3.3
+ 23.9810ms,0.0V 23.9999ms,0.0
+ 24.0000ms,3.3V 24.0009ms,3.3
+ 24.0010ms,0.0V 24.0199ms,0.0
+ 24.0200ms,3.3V 24.0209ms,3.3
+ 24.0210ms,0.0V 24.0399ms,0.0
+ 24.0400ms,3.3V 24.0409ms,3.3
+ 24.0410ms,0.0V 24.0599ms,0.0
+ 24.0600ms,3.3V 24.0609ms,3.3
+ 24.0610ms,0.0V 24.0799ms,0.0
+ 24.0800ms,3.3V 24.0809ms,3.3
+ 24.0810ms,0.0V 24.0999ms,0.0
+ 24.1000ms,3.3V 24.1009ms,3.3
+ 24.1010ms,0.0V 24.1199ms,0.0
+ 24.1200ms,3.3V 24.1209ms,3.3
+ 24.1210ms,0.0V 24.1399ms,0.0
+ 24.1400ms,3.3V 24.1409ms,3.3
+ 24.1410ms,0.0V 24.1599ms,0.0
+ 24.1600ms,3.3V 24.1609ms,3.3
+ 24.1610ms,0.0V 24.1799ms,0.0
+ 24.1800ms,3.3V 24.1809ms,3.3
+ 24.1810ms,0.0V 24.1999ms,0.0
+ 24.2000ms,3.3V 24.2009ms,3.3
+ 24.2010ms,0.0V 24.2199ms,0.0
+ 24.2200ms,3.3V 24.2209ms,3.3
+ 24.2210ms,0.0V 24.2399ms,0.0
+ 24.2400ms,3.3V 24.2409ms,3.3
+ 24.2410ms,0.0V 24.2599ms,0.0
+ 24.2600ms,3.3V 24.2609ms,3.3
+ 24.2610ms,0.0V 24.2799ms,0.0
+ 24.2800ms,3.3V 24.2809ms,3.3
+ 24.2810ms,0.0V 24.2999ms,0.0
+ 24.3000ms,3.3V 24.3009ms,3.3
+ 24.3010ms,0.0V 24.3199ms,0.0
+ 24.3200ms,3.3V 24.3209ms,3.3
+ 24.3210ms,0.0V 24.3399ms,0.0
+ 24.3400ms,3.3V 24.3409ms,3.3
+ 24.3410ms,0.0V 24.3599ms,0.0
+ 24.3600ms,3.3V 24.3609ms,3.3
+ 24.3610ms,0.0V 24.3799ms,0.0
+ 24.3800ms,3.3V 24.3809ms,3.3
+ 24.3810ms,0.0V 24.3999ms,0.0
+ 24.4000ms,3.3V 24.4009ms,3.3
+ 24.4010ms,0.0V 24.4199ms,0.0
+ 24.4200ms,3.3V 24.4209ms,3.3
+ 24.4210ms,0.0V 24.4399ms,0.0
+ 24.4400ms,3.3V 24.4409ms,3.3
+ 24.4410ms,0.0V 24.4599ms,0.0
+ 24.4600ms,3.3V 24.4609ms,3.3
+ 24.4610ms,0.0V 24.4799ms,0.0
+ 24.4800ms,3.3V 24.4809ms,3.3
+ 24.4810ms,0.0V 24.4999ms,0.0
+ 24.5000ms,3.3V 24.5009ms,3.3
+ 24.5010ms,0.0V 24.5199ms,0.0
+ 24.5200ms,3.3V 24.5209ms,3.3
+ 24.5210ms,0.0V 24.5399ms,0.0
+ 24.5400ms,3.3V 24.5409ms,3.3
+ 24.5410ms,0.0V 24.5599ms,0.0
+ 24.5600ms,3.3V 24.5609ms,3.3
+ 24.5610ms,0.0V 24.5799ms,0.0
+ 24.5800ms,3.3V 24.5809ms,3.3
+ 24.5810ms,0.0V 24.5999ms,0.0
+ 24.6000ms,3.3V 24.6009ms,3.3
+ 24.6010ms,0.0V 24.6199ms,0.0
+ 24.6200ms,3.3V 24.6209ms,3.3
+ 24.6210ms,0.0V 24.6399ms,0.0
+ 24.6400ms,3.3V 24.6409ms,3.3
+ 24.6410ms,0.0V 24.6599ms,0.0
+ 24.6600ms,3.3V 24.6609ms,3.3
+ 24.6610ms,0.0V 24.6799ms,0.0
+ 24.6800ms,3.3V 24.6809ms,3.3
+ 24.6810ms,0.0V 24.6999ms,0.0
+ 24.7000ms,3.3V 24.7009ms,3.3
+ 24.7010ms,0.0V 24.7199ms,0.0
+ 24.7200ms,3.3V 24.7209ms,3.3
+ 24.7210ms,0.0V 24.7399ms,0.0
+ 24.7400ms,3.3V 24.7409ms,3.3
+ 24.7410ms,0.0V 24.7599ms,0.0
+ 24.7600ms,3.3V 24.7609ms,3.3
+ 24.7610ms,0.0V 24.7799ms,0.0
+ 24.7800ms,3.3V 24.7809ms,3.3
+ 24.7810ms,0.0V 24.7999ms,0.0
+ 24.8000ms,3.3V 24.8009ms,3.3
+ 24.8010ms,0.0V 24.8199ms,0.0
+ 24.8200ms,3.3V 24.8209ms,3.3
+ 24.8210ms,0.0V 24.8399ms,0.0
+ 24.8400ms,3.3V 24.8409ms,3.3
+ 24.8410ms,0.0V 24.8599ms,0.0
+ 24.8600ms,3.3V 24.8609ms,3.3
+ 24.8610ms,0.0V 24.8799ms,0.0
+ 24.8800ms,3.3V 24.8809ms,3.3
+ 24.8810ms,0.0V 24.8999ms,0.0
+ 24.9000ms,3.3V 24.9009ms,3.3
+ 24.9010ms,0.0V 24.9199ms,0.0
+ 24.9200ms,3.3V 24.9209ms,3.3
+ 24.9210ms,0.0V 24.9399ms,0.0
+ 24.9400ms,3.3V 24.9409ms,3.3
+ 24.9410ms,0.0V 24.9599ms,0.0
+ 24.9600ms,3.3V 24.9609ms,3.3
+ 24.9610ms,0.0V 24.9799ms,0.0
+ 24.9800ms,3.3V 24.9809ms,3.3
+ 24.9810ms,0.0V 24.9999ms,0.0
+ 25.0000ms,3.3V 25.0009ms,3.3
+ 25.0010ms,0.0V 25.0199ms,0.0
+ 25.0200ms,3.3V 25.0209ms,3.3
+ 25.0210ms,0.0V 25.0399ms,0.0
+ 25.0400ms,3.3V 25.0409ms,3.3
+ 25.0410ms,0.0V 25.0599ms,0.0
+ 25.0600ms,3.3V 25.0609ms,3.3
+ 25.0610ms,0.0V 25.0799ms,0.0
+ 25.0800ms,3.3V 25.0809ms,3.3
+ 25.0810ms,0.0V 25.0999ms,0.0
+ 25.1000ms,3.3V 25.1011ms,3.3
+ 25.1012ms,0.0V 25.1199ms,0.0
+ 25.1200ms,3.3V 25.1211ms,3.3
+ 25.1212ms,0.0V 25.1399ms,0.0
+ 25.1400ms,3.3V 25.1411ms,3.3
+ 25.1412ms,0.0V 25.1599ms,0.0
+ 25.1600ms,3.3V 25.1611ms,3.3
+ 25.1612ms,0.0V 25.1799ms,0.0
+ 25.1800ms,3.3V 25.1811ms,3.3
+ 25.1812ms,0.0V 25.1999ms,0.0
+ 25.2000ms,3.3V 25.2011ms,3.3
+ 25.2012ms,0.0V 25.2199ms,0.0
+ 25.2200ms,3.3V 25.2211ms,3.3
+ 25.2212ms,0.0V 25.2399ms,0.0
+ 25.2400ms,3.3V 25.2411ms,3.3
+ 25.2412ms,0.0V 25.2599ms,0.0
+ 25.2600ms,3.3V 25.2611ms,3.3
+ 25.2612ms,0.0V 25.2799ms,0.0
+ 25.2800ms,3.3V 25.2811ms,3.3
+ 25.2812ms,0.0V 25.2999ms,0.0
+ 25.3000ms,3.3V 25.3011ms,3.3
+ 25.3012ms,0.0V 25.3199ms,0.0
+ 25.3200ms,3.3V 25.3211ms,3.3
+ 25.3212ms,0.0V 25.3399ms,0.0
+ 25.3400ms,3.3V 25.3411ms,3.3
+ 25.3412ms,0.0V 25.3599ms,0.0
+ 25.3600ms,3.3V 25.3611ms,3.3
+ 25.3612ms,0.0V 25.3799ms,0.0
+ 25.3800ms,3.3V 25.3811ms,3.3
+ 25.3812ms,0.0V 25.3999ms,0.0
+ 25.4000ms,3.3V 25.4011ms,3.3
+ 25.4012ms,0.0V 25.4199ms,0.0
+ 25.4200ms,3.3V 25.4211ms,3.3
+ 25.4212ms,0.0V 25.4399ms,0.0
+ 25.4400ms,3.3V 25.4411ms,3.3
+ 25.4412ms,0.0V 25.4599ms,0.0
+ 25.4600ms,3.3V 25.4611ms,3.3
+ 25.4612ms,0.0V 25.4799ms,0.0
+ 25.4800ms,3.3V 25.4811ms,3.3
+ 25.4812ms,0.0V 25.4999ms,0.0
+ 25.5000ms,3.3V 25.5011ms,3.3
+ 25.5012ms,0.0V 25.5199ms,0.0
+ 25.5200ms,3.3V 25.5211ms,3.3
+ 25.5212ms,0.0V 25.5399ms,0.0
+ 25.5400ms,3.3V 25.5411ms,3.3
+ 25.5412ms,0.0V 25.5599ms,0.0
+ 25.5600ms,3.3V 25.5611ms,3.3
+ 25.5612ms,0.0V 25.5799ms,0.0
+ 25.5800ms,3.3V 25.5811ms,3.3
+ 25.5812ms,0.0V 25.5999ms,0.0
+ 25.6000ms,3.3V 25.6011ms,3.3
+ 25.6012ms,0.0V 25.6199ms,0.0
+ 25.6200ms,3.3V 25.6211ms,3.3
+ 25.6212ms,0.0V 25.6399ms,0.0
+ 25.6400ms,3.3V 25.6411ms,3.3
+ 25.6412ms,0.0V 25.6599ms,0.0
+ 25.6600ms,3.3V 25.6611ms,3.3
+ 25.6612ms,0.0V 25.6799ms,0.0
+ 25.6800ms,3.3V 25.6811ms,3.3
+ 25.6812ms,0.0V 25.6999ms,0.0
+ 25.7000ms,3.3V 25.7011ms,3.3
+ 25.7012ms,0.0V 25.7199ms,0.0
+ 25.7200ms,3.3V 25.7211ms,3.3
+ 25.7212ms,0.0V 25.7399ms,0.0
+ 25.7400ms,3.3V 25.7411ms,3.3
+ 25.7412ms,0.0V 25.7599ms,0.0
+ 25.7600ms,3.3V 25.7611ms,3.3
+ 25.7612ms,0.0V 25.7799ms,0.0
+ 25.7800ms,3.3V 25.7811ms,3.3
+ 25.7812ms,0.0V 25.7999ms,0.0
+ 25.8000ms,3.3V 25.8011ms,3.3
+ 25.8012ms,0.0V 25.8199ms,0.0
+ 25.8200ms,3.3V 25.8211ms,3.3
+ 25.8212ms,0.0V 25.8399ms,0.0
+ 25.8400ms,3.3V 25.8411ms,3.3
+ 25.8412ms,0.0V 25.8599ms,0.0
+ 25.8600ms,3.3V 25.8611ms,3.3
+ 25.8612ms,0.0V 25.8799ms,0.0
+ 25.8800ms,3.3V 25.8811ms,3.3
+ 25.8812ms,0.0V 25.8999ms,0.0
+ 25.9000ms,3.3V 25.9011ms,3.3
+ 25.9012ms,0.0V 25.9199ms,0.0
+ 25.9200ms,3.3V 25.9211ms,3.3
+ 25.9212ms,0.0V 25.9399ms,0.0
+ 25.9400ms,3.3V 25.9411ms,3.3
+ 25.9412ms,0.0V 25.9599ms,0.0
+ 25.9600ms,3.3V 25.9611ms,3.3
+ 25.9612ms,0.0V 25.9799ms,0.0
+ 25.9800ms,3.3V 25.9811ms,3.3
+ 25.9812ms,0.0V 25.9999ms,0.0
+ 26.0000ms,3.3V 26.0011ms,3.3
+ 26.0012ms,0.0V 26.0199ms,0.0
+ 26.0200ms,3.3V 26.0211ms,3.3
+ 26.0212ms,0.0V 26.0399ms,0.0
+ 26.0400ms,3.3V 26.0411ms,3.3
+ 26.0412ms,0.0V 26.0599ms,0.0
+ 26.0600ms,3.3V 26.0611ms,3.3
+ 26.0612ms,0.0V 26.0799ms,0.0
+ 26.0800ms,3.3V 26.0811ms,3.3
+ 26.0812ms,0.0V 26.0999ms,0.0
+ 26.1000ms,3.3V 26.1011ms,3.3
+ 26.1012ms,0.0V 26.1199ms,0.0
+ 26.1200ms,3.3V 26.1211ms,3.3
+ 26.1212ms,0.0V 26.1399ms,0.0
+ 26.1400ms,3.3V 26.1411ms,3.3
+ 26.1412ms,0.0V 26.1599ms,0.0
+ 26.1600ms,3.3V 26.1611ms,3.3
+ 26.1612ms,0.0V 26.1799ms,0.0
+ 26.1800ms,3.3V 26.1811ms,3.3
+ 26.1812ms,0.0V 26.1999ms,0.0
+ 26.2000ms,3.3V 26.2011ms,3.3
+ 26.2012ms,0.0V 26.2199ms,0.0
+ 26.2200ms,3.3V 26.2211ms,3.3
+ 26.2212ms,0.0V 26.2399ms,0.0
+ 26.2400ms,3.3V 26.2411ms,3.3
+ 26.2412ms,0.0V 26.2599ms,0.0
+ 26.2600ms,3.3V 26.2611ms,3.3
+ 26.2612ms,0.0V 26.2799ms,0.0
+ 26.2800ms,3.3V 26.2811ms,3.3
+ 26.2812ms,0.0V 26.2999ms,0.0
+ 26.3000ms,3.3V 26.3011ms,3.3
+ 26.3012ms,0.0V 26.3199ms,0.0
+ 26.3200ms,3.3V 26.3211ms,3.3
+ 26.3212ms,0.0V 26.3399ms,0.0
+ 26.3400ms,3.3V 26.3411ms,3.3
+ 26.3412ms,0.0V 26.3599ms,0.0
+ 26.3600ms,3.3V 26.3611ms,3.3
+ 26.3612ms,0.0V 26.3799ms,0.0
+ 26.3800ms,3.3V 26.3811ms,3.3
+ 26.3812ms,0.0V 26.3999ms,0.0
+ 26.4000ms,3.3V 26.4011ms,3.3
+ 26.4012ms,0.0V 26.4199ms,0.0
+ 26.4200ms,3.3V 26.4211ms,3.3
+ 26.4212ms,0.0V 26.4399ms,0.0
+ 26.4400ms,3.3V 26.4411ms,3.3
+ 26.4412ms,0.0V 26.4599ms,0.0
+ 26.4600ms,3.3V 26.4611ms,3.3
+ 26.4612ms,0.0V 26.4799ms,0.0
+ 26.4800ms,3.3V 26.4811ms,3.3
+ 26.4812ms,0.0V 26.4999ms,0.0
+ 26.5000ms,3.3V 26.5011ms,3.3
+ 26.5012ms,0.0V 26.5199ms,0.0
+ 26.5200ms,3.3V 26.5211ms,3.3
+ 26.5212ms,0.0V 26.5399ms,0.0
+ 26.5400ms,3.3V 26.5411ms,3.3
+ 26.5412ms,0.0V 26.5599ms,0.0
+ 26.5600ms,3.3V 26.5611ms,3.3
+ 26.5612ms,0.0V 26.5799ms,0.0
+ 26.5800ms,3.3V 26.5811ms,3.3
+ 26.5812ms,0.0V 26.5999ms,0.0
+ 26.6000ms,3.3V 26.6011ms,3.3
+ 26.6012ms,0.0V 26.6199ms,0.0
+ 26.6200ms,3.3V 26.6211ms,3.3
+ 26.6212ms,0.0V 26.6399ms,0.0
+ 26.6400ms,3.3V 26.6411ms,3.3
+ 26.6412ms,0.0V 26.6599ms,0.0
+ 26.6600ms,3.3V 26.6611ms,3.3
+ 26.6612ms,0.0V 26.6799ms,0.0
+ 26.6800ms,3.3V 26.6811ms,3.3
+ 26.6812ms,0.0V 26.6999ms,0.0
+ 26.7000ms,3.3V 26.7011ms,3.3
+ 26.7012ms,0.0V 26.7199ms,0.0
+ 26.7200ms,3.3V 26.7211ms,3.3
+ 26.7212ms,0.0V 26.7399ms,0.0
+ 26.7400ms,3.3V 26.7411ms,3.3
+ 26.7412ms,0.0V 26.7599ms,0.0
+ 26.7600ms,3.3V 26.7611ms,3.3
+ 26.7612ms,0.0V 26.7799ms,0.0
+ 26.7800ms,3.3V 26.7811ms,3.3
+ 26.7812ms,0.0V 26.7999ms,0.0
+ 26.8000ms,3.3V 26.8011ms,3.3
+ 26.8012ms,0.0V 26.8199ms,0.0
+ 26.8200ms,3.3V 26.8211ms,3.3
+ 26.8212ms,0.0V 26.8399ms,0.0
+ 26.8400ms,3.3V 26.8411ms,3.3
+ 26.8412ms,0.0V 26.8599ms,0.0
+ 26.8600ms,3.3V 26.8611ms,3.3
+ 26.8612ms,0.0V 26.8799ms,0.0
+ 26.8800ms,3.3V 26.8811ms,3.3
+ 26.8812ms,0.0V 26.8999ms,0.0
+ 26.9000ms,3.3V 26.9011ms,3.3
+ 26.9012ms,0.0V 26.9199ms,0.0
+ 26.9200ms,3.3V 26.9211ms,3.3
+ 26.9212ms,0.0V 26.9399ms,0.0
+ 26.9400ms,3.3V 26.9411ms,3.3
+ 26.9412ms,0.0V 26.9599ms,0.0
+ 26.9600ms,3.3V 26.9611ms,3.3
+ 26.9612ms,0.0V 26.9799ms,0.0
+ 26.9800ms,3.3V 26.9811ms,3.3
+ 26.9812ms,0.0V 26.9999ms,0.0
+ 27.0000ms,3.3V 27.0011ms,3.3
+ 27.0012ms,0.0V 27.0199ms,0.0
+ 27.0200ms,3.3V 27.0211ms,3.3
+ 27.0212ms,0.0V 27.0399ms,0.0
+ 27.0400ms,3.3V 27.0411ms,3.3
+ 27.0412ms,0.0V 27.0599ms,0.0
+ 27.0600ms,3.3V 27.0611ms,3.3
+ 27.0612ms,0.0V 27.0799ms,0.0
+ 27.0800ms,3.3V 27.0811ms,3.3
+ 27.0812ms,0.0V 27.0999ms,0.0
+ 27.1000ms,3.3V 27.1011ms,3.3
+ 27.1012ms,0.0V 27.1199ms,0.0
+ 27.1200ms,3.3V 27.1211ms,3.3
+ 27.1212ms,0.0V 27.1399ms,0.0
+ 27.1400ms,3.3V 27.1411ms,3.3
+ 27.1412ms,0.0V 27.1599ms,0.0
+ 27.1600ms,3.3V 27.1611ms,3.3
+ 27.1612ms,0.0V 27.1799ms,0.0
+ 27.1800ms,3.3V 27.1811ms,3.3
+ 27.1812ms,0.0V 27.1999ms,0.0
+ 27.2000ms,3.3V 27.2011ms,3.3
+ 27.2012ms,0.0V 27.2199ms,0.0
+ 27.2200ms,3.3V 27.2211ms,3.3
+ 27.2212ms,0.0V 27.2399ms,0.0
+ 27.2400ms,3.3V 27.2411ms,3.3
+ 27.2412ms,0.0V 27.2599ms,0.0
+ 27.2600ms,3.3V 27.2611ms,3.3
+ 27.2612ms,0.0V 27.2799ms,0.0
+ 27.2800ms,3.3V 27.2811ms,3.3
+ 27.2812ms,0.0V 27.2999ms,0.0
+ 27.3000ms,3.3V 27.3011ms,3.3
+ 27.3012ms,0.0V 27.3199ms,0.0
+ 27.3200ms,3.3V 27.3211ms,3.3
+ 27.3212ms,0.0V 27.3399ms,0.0
+ 27.3400ms,3.3V 27.3411ms,3.3
+ 27.3412ms,0.0V 27.3599ms,0.0
+ 27.3600ms,3.3V 27.3611ms,3.3
+ 27.3612ms,0.0V 27.3799ms,0.0
+ 27.3800ms,3.3V 27.3811ms,3.3
+ 27.3812ms,0.0V 27.3999ms,0.0
+ 27.4000ms,3.3V 27.4011ms,3.3
+ 27.4012ms,0.0V 27.4199ms,0.0
+ 27.4200ms,3.3V 27.4211ms,3.3
+ 27.4212ms,0.0V 27.4399ms,0.0
+ 27.4400ms,3.3V 27.4411ms,3.3
+ 27.4412ms,0.0V 27.4599ms,0.0
+ 27.4600ms,3.3V 27.4611ms,3.3
+ 27.4612ms,0.0V 27.4799ms,0.0
+ 27.4800ms,3.3V 27.4811ms,3.3
+ 27.4812ms,0.0V 27.4999ms,0.0
+ 27.5000ms,3.3V 27.5011ms,3.3
+ 27.5012ms,0.0V 27.5199ms,0.0
+ 27.5200ms,3.3V 27.5211ms,3.3
+ 27.5212ms,0.0V 27.5399ms,0.0
+ 27.5400ms,3.3V 27.5411ms,3.3
+ 27.5412ms,0.0V 27.5599ms,0.0
+ 27.5600ms,3.3V 27.5611ms,3.3
+ 27.5612ms,0.0V 27.5799ms,0.0
+ 27.5800ms,3.3V 27.5811ms,3.3
+ 27.5812ms,0.0V 27.5999ms,0.0
+ 27.6000ms,3.3V 27.6011ms,3.3
+ 27.6012ms,0.0V 27.6199ms,0.0
+ 27.6200ms,3.3V 27.6211ms,3.3
+ 27.6212ms,0.0V 27.6399ms,0.0
+ 27.6400ms,3.3V 27.6411ms,3.3
+ 27.6412ms,0.0V 27.6599ms,0.0
+ 27.6600ms,3.3V 27.6611ms,3.3
+ 27.6612ms,0.0V 27.6799ms,0.0
+ 27.6800ms,3.3V 27.6811ms,3.3
+ 27.6812ms,0.0V 27.6999ms,0.0
+ 27.7000ms,3.3V 27.7011ms,3.3
+ 27.7012ms,0.0V 27.7199ms,0.0
+ 27.7200ms,3.3V 27.7211ms,3.3
+ 27.7212ms,0.0V 27.7399ms,0.0
+ 27.7400ms,3.3V 27.7411ms,3.3
+ 27.7412ms,0.0V 27.7599ms,0.0
+ 27.7600ms,3.3V 27.7611ms,3.3
+ 27.7612ms,0.0V 27.7799ms,0.0
+ 27.7800ms,3.3V 27.7811ms,3.3
+ 27.7812ms,0.0V 27.7999ms,0.0
+ 27.8000ms,3.3V 27.8011ms,3.3
+ 27.8012ms,0.0V 27.8199ms,0.0
+ 27.8200ms,3.3V 27.8211ms,3.3
+ 27.8212ms,0.0V 27.8399ms,0.0
+ 27.8400ms,3.3V 27.8411ms,3.3
+ 27.8412ms,0.0V 27.8599ms,0.0
+ 27.8600ms,3.3V 27.8611ms,3.3
+ 27.8612ms,0.0V 27.8799ms,0.0
+ 27.8800ms,3.3V 27.8811ms,3.3
+ 27.8812ms,0.0V 27.8999ms,0.0
+ 27.9000ms,3.3V 27.9011ms,3.3
+ 27.9012ms,0.0V 27.9199ms,0.0
+ 27.9200ms,3.3V 27.9211ms,3.3
+ 27.9212ms,0.0V 27.9399ms,0.0
+ 27.9400ms,3.3V 27.9411ms,3.3
+ 27.9412ms,0.0V 27.9599ms,0.0
+ 27.9600ms,3.3V 27.9611ms,3.3
+ 27.9612ms,0.0V 27.9799ms,0.0
+ 27.9800ms,3.3V 27.9811ms,3.3
+ 27.9812ms,0.0V 27.9999ms,0.0
+ 28.0000ms,3.3V 28.0011ms,3.3
+ 28.0012ms,0.0V 28.0199ms,0.0
+ 28.0200ms,3.3V 28.0211ms,3.3
+ 28.0212ms,0.0V 28.0399ms,0.0
+ 28.0400ms,3.3V 28.0411ms,3.3
+ 28.0412ms,0.0V 28.0599ms,0.0
+ 28.0600ms,3.3V 28.0611ms,3.3
+ 28.0612ms,0.0V 28.0799ms,0.0
+ 28.0800ms,3.3V 28.0811ms,3.3
+ 28.0812ms,0.0V 28.0999ms,0.0
+ 28.1000ms,3.3V 28.1011ms,3.3
+ 28.1012ms,0.0V 28.1199ms,0.0
+ 28.1200ms,3.3V 28.1211ms,3.3
+ 28.1212ms,0.0V 28.1399ms,0.0
+ 28.1400ms,3.3V 28.1411ms,3.3
+ 28.1412ms,0.0V 28.1599ms,0.0
+ 28.1600ms,3.3V 28.1611ms,3.3
+ 28.1612ms,0.0V 28.1799ms,0.0
+ 28.1800ms,3.3V 28.1811ms,3.3
+ 28.1812ms,0.0V 28.1999ms,0.0
+ 28.2000ms,3.3V 28.2011ms,3.3
+ 28.2012ms,0.0V 28.2199ms,0.0
+ 28.2200ms,3.3V 28.2211ms,3.3
+ 28.2212ms,0.0V 28.2399ms,0.0
+ 28.2400ms,3.3V 28.2411ms,3.3
+ 28.2412ms,0.0V 28.2599ms,0.0
+ 28.2600ms,3.3V 28.2611ms,3.3
+ 28.2612ms,0.0V 28.2799ms,0.0
+ 28.2800ms,3.3V 28.2811ms,3.3
+ 28.2812ms,0.0V 28.2999ms,0.0
+ 28.3000ms,3.3V 28.3011ms,3.3
+ 28.3012ms,0.0V 28.3199ms,0.0
+ 28.3200ms,3.3V 28.3211ms,3.3
+ 28.3212ms,0.0V 28.3399ms,0.0
+ 28.3400ms,3.3V 28.3411ms,3.3
+ 28.3412ms,0.0V 28.3599ms,0.0
+ 28.3600ms,3.3V 28.3611ms,3.3
+ 28.3612ms,0.0V 28.3799ms,0.0
+ 28.3800ms,3.3V 28.3811ms,3.3
+ 28.3812ms,0.0V 28.3999ms,0.0
+ 28.4000ms,3.3V 28.4011ms,3.3
+ 28.4012ms,0.0V 28.4199ms,0.0
+ 28.4200ms,3.3V 28.4211ms,3.3
+ 28.4212ms,0.0V 28.4399ms,0.0
+ 28.4400ms,3.3V 28.4411ms,3.3
+ 28.4412ms,0.0V 28.4599ms,0.0
+ 28.4600ms,3.3V 28.4611ms,3.3
+ 28.4612ms,0.0V 28.4799ms,0.0
+ 28.4800ms,3.3V 28.4811ms,3.3
+ 28.4812ms,0.0V 28.4999ms,0.0
+ 28.5000ms,3.3V 28.5011ms,3.3
+ 28.5012ms,0.0V 28.5199ms,0.0
+ 28.5200ms,3.3V 28.5211ms,3.3
+ 28.5212ms,0.0V 28.5399ms,0.0
+ 28.5400ms,3.3V 28.5411ms,3.3
+ 28.5412ms,0.0V 28.5599ms,0.0
+ 28.5600ms,3.3V 28.5611ms,3.3
+ 28.5612ms,0.0V 28.5799ms,0.0
+ 28.5800ms,3.3V 28.5811ms,3.3
+ 28.5812ms,0.0V 28.5999ms,0.0
+ 28.6000ms,3.3V 28.6011ms,3.3
+ 28.6012ms,0.0V 28.6199ms,0.0
+ 28.6200ms,3.3V 28.6211ms,3.3
+ 28.6212ms,0.0V 28.6399ms,0.0
+ 28.6400ms,3.3V 28.6411ms,3.3
+ 28.6412ms,0.0V 28.6599ms,0.0
+ 28.6600ms,3.3V 28.6611ms,3.3
+ 28.6612ms,0.0V 28.6799ms,0.0
+ 28.6800ms,3.3V 28.6811ms,3.3
+ 28.6812ms,0.0V 28.6999ms,0.0
+ 28.7000ms,3.3V 28.7011ms,3.3
+ 28.7012ms,0.0V 28.7199ms,0.0
+ 28.7200ms,3.3V 28.7211ms,3.3
+ 28.7212ms,0.0V 28.7399ms,0.0
+ 28.7400ms,3.3V 28.7411ms,3.3
+ 28.7412ms,0.0V 28.7599ms,0.0
+ 28.7600ms,3.3V 28.7611ms,3.3
+ 28.7612ms,0.0V 28.7799ms,0.0
+ 28.7800ms,3.3V 28.7811ms,3.3
+ 28.7812ms,0.0V 28.7999ms,0.0
+ 28.8000ms,3.3V 28.8011ms,3.3
+ 28.8012ms,0.0V 28.8199ms,0.0
+ 28.8200ms,3.3V 28.8211ms,3.3
+ 28.8212ms,0.0V 28.8399ms,0.0
+ 28.8400ms,3.3V 28.8411ms,3.3
+ 28.8412ms,0.0V 28.8599ms,0.0
+ 28.8600ms,3.3V 28.8611ms,3.3
+ 28.8612ms,0.0V 28.8799ms,0.0
+ 28.8800ms,3.3V 28.8811ms,3.3
+ 28.8812ms,0.0V 28.8999ms,0.0
+ 28.9000ms,3.3V 28.9011ms,3.3
+ 28.9012ms,0.0V 28.9199ms,0.0
+ 28.9200ms,3.3V 28.9211ms,3.3
+ 28.9212ms,0.0V 28.9399ms,0.0
+ 28.9400ms,3.3V 28.9411ms,3.3
+ 28.9412ms,0.0V 28.9599ms,0.0
+ 28.9600ms,3.3V 28.9611ms,3.3
+ 28.9612ms,0.0V 28.9799ms,0.0
+ 28.9800ms,3.3V 28.9811ms,3.3
+ 28.9812ms,0.0V 28.9999ms,0.0
+ 29.0000ms,3.3V 29.0011ms,3.3
+ 29.0012ms,0.0V 29.0199ms,0.0
+ 29.0200ms,3.3V 29.0211ms,3.3
+ 29.0212ms,0.0V 29.0399ms,0.0
+ 29.0400ms,3.3V 29.0411ms,3.3
+ 29.0412ms,0.0V 29.0599ms,0.0
+ 29.0600ms,3.3V 29.0611ms,3.3
+ 29.0612ms,0.0V 29.0799ms,0.0
+ 29.0800ms,3.3V 29.0811ms,3.3
+ 29.0812ms,0.0V 29.0999ms,0.0
+ 29.1000ms,3.3V 29.1011ms,3.3
+ 29.1012ms,0.0V 29.1199ms,0.0
+ 29.1200ms,3.3V 29.1211ms,3.3
+ 29.1212ms,0.0V 29.1399ms,0.0
+ 29.1400ms,3.3V 29.1411ms,3.3
+ 29.1412ms,0.0V 29.1599ms,0.0
+ 29.1600ms,3.3V 29.1611ms,3.3
+ 29.1612ms,0.0V 29.1799ms,0.0
+ 29.1800ms,3.3V 29.1811ms,3.3
+ 29.1812ms,0.0V 29.1999ms,0.0
+ 29.2000ms,3.3V 29.2011ms,3.3
+ 29.2012ms,0.0V 29.2199ms,0.0
+ 29.2200ms,3.3V 29.2211ms,3.3
+ 29.2212ms,0.0V 29.2399ms,0.0
+ 29.2400ms,3.3V 29.2411ms,3.3
+ 29.2412ms,0.0V 29.2599ms,0.0
+ 29.2600ms,3.3V 29.2611ms,3.3
+ 29.2612ms,0.0V 29.2799ms,0.0
+ 29.2800ms,3.3V 29.2811ms,3.3
+ 29.2812ms,0.0V 29.2999ms,0.0
+ 29.3000ms,3.3V 29.3011ms,3.3
+ 29.3012ms,0.0V 29.3199ms,0.0
+ 29.3200ms,3.3V 29.3211ms,3.3
+ 29.3212ms,0.0V 29.3399ms,0.0
+ 29.3400ms,3.3V 29.3411ms,3.3
+ 29.3412ms,0.0V 29.3599ms,0.0
+ 29.3600ms,3.3V 29.3611ms,3.3
+ 29.3612ms,0.0V 29.3799ms,0.0
+ 29.3800ms,3.3V 29.3811ms,3.3
+ 29.3812ms,0.0V 29.3999ms,0.0
+ 29.4000ms,3.3V 29.4011ms,3.3
+ 29.4012ms,0.0V 29.4199ms,0.0
+ 29.4200ms,3.3V 29.4211ms,3.3
+ 29.4212ms,0.0V 29.4399ms,0.0
+ 29.4400ms,3.3V 29.4411ms,3.3
+ 29.4412ms,0.0V 29.4599ms,0.0
+ 29.4600ms,3.3V 29.4611ms,3.3
+ 29.4612ms,0.0V 29.4799ms,0.0
+ 29.4800ms,3.3V 29.4811ms,3.3
+ 29.4812ms,0.0V 29.4999ms,0.0
+ 29.5000ms,3.3V 29.5011ms,3.3
+ 29.5012ms,0.0V 29.5199ms,0.0
+ 29.5200ms,3.3V 29.5211ms,3.3
+ 29.5212ms,0.0V 29.5399ms,0.0
+ 29.5400ms,3.3V 29.5411ms,3.3
+ 29.5412ms,0.0V 29.5599ms,0.0
+ 29.5600ms,3.3V 29.5611ms,3.3
+ 29.5612ms,0.0V 29.5799ms,0.0
+ 29.5800ms,3.3V 29.5811ms,3.3
+ 29.5812ms,0.0V 29.5999ms,0.0
+ 29.6000ms,3.3V 29.6011ms,3.3
+ 29.6012ms,0.0V 29.6199ms,0.0
+ 29.6200ms,3.3V 29.6211ms,3.3
+ 29.6212ms,0.0V 29.6399ms,0.0
+ 29.6400ms,3.3V 29.6411ms,3.3
+ 29.6412ms,0.0V 29.6599ms,0.0
+ 29.6600ms,3.3V 29.6611ms,3.3
+ 29.6612ms,0.0V 29.6799ms,0.0
+ 29.6800ms,3.3V 29.6811ms,3.3
+ 29.6812ms,0.0V 29.6999ms,0.0
+ 29.7000ms,3.3V 29.7011ms,3.3
+ 29.7012ms,0.0V 29.7199ms,0.0
+ 29.7200ms,3.3V 29.7211ms,3.3
+ 29.7212ms,0.0V 29.7399ms,0.0
+ 29.7400ms,3.3V 29.7411ms,3.3
+ 29.7412ms,0.0V 29.7599ms,0.0
+ 29.7600ms,3.3V 29.7611ms,3.3
+ 29.7612ms,0.0V 29.7799ms,0.0
+ 29.7800ms,3.3V 29.7811ms,3.3
+ 29.7812ms,0.0V 29.7999ms,0.0
+ 29.8000ms,3.3V 29.8011ms,3.3
+ 29.8012ms,0.0V 29.8199ms,0.0
+ 29.8200ms,3.3V 29.8211ms,3.3
+ 29.8212ms,0.0V 29.8399ms,0.0
+ 29.8400ms,3.3V 29.8411ms,3.3
+ 29.8412ms,0.0V 29.8599ms,0.0
+ 29.8600ms,3.3V 29.8611ms,3.3
+ 29.8612ms,0.0V 29.8799ms,0.0
+ 29.8800ms,3.3V 29.8811ms,3.3
+ 29.8812ms,0.0V 29.8999ms,0.0
+ 29.9000ms,3.3V 29.9011ms,3.3
+ 29.9012ms,0.0V 29.9199ms,0.0
+ 29.9200ms,3.3V 29.9211ms,3.3
+ 29.9212ms,0.0V 29.9399ms,0.0
+ 29.9400ms,3.3V 29.9411ms,3.3
+ 29.9412ms,0.0V 29.9599ms,0.0
+ 29.9600ms,3.3V 29.9611ms,3.3
+ 29.9612ms,0.0V 29.9799ms,0.0
+ 29.9800ms,3.3V 29.9811ms,3.3
+ 29.9812ms,0.0V 29.9999ms,0.0
+ 30.0000ms,3.3V 30.0011ms,3.3
+ 30.0012ms,0.0V 30.0199ms,0.0
+ 30.0200ms,3.3V 30.0211ms,3.3
+ 30.0212ms,0.0V 30.0399ms,0.0
+ 30.0400ms,3.3V 30.0411ms,3.3
+ 30.0412ms,0.0V 30.0599ms,0.0
+ 30.0600ms,3.3V 30.0611ms,3.3
+ 30.0612ms,0.0V 30.0799ms,0.0
+ 30.0800ms,3.3V 30.0811ms,3.3
+ 30.0812ms,0.0V 30.0999ms,0.0
+ 30.1000ms,3.3V 30.1011ms,3.3
+ 30.1012ms,0.0V 30.1199ms,0.0
+ 30.1200ms,3.3V 30.1213ms,3.3
+ 30.1214ms,0.0V 30.1399ms,0.0
+ 30.1400ms,3.3V 30.1413ms,3.3
+ 30.1414ms,0.0V 30.1599ms,0.0
+ 30.1600ms,3.3V 30.1613ms,3.3
+ 30.1614ms,0.0V 30.1799ms,0.0
+ 30.1800ms,3.3V 30.1813ms,3.3
+ 30.1814ms,0.0V 30.1999ms,0.0
+ 30.2000ms,3.3V 30.2013ms,3.3
+ 30.2014ms,0.0V 30.2199ms,0.0
+ 30.2200ms,3.3V 30.2213ms,3.3
+ 30.2214ms,0.0V 30.2399ms,0.0
+ 30.2400ms,3.3V 30.2413ms,3.3
+ 30.2414ms,0.0V 30.2599ms,0.0
+ 30.2600ms,3.3V 30.2613ms,3.3
+ 30.2614ms,0.0V 30.2799ms,0.0
+ 30.2800ms,3.3V 30.2813ms,3.3
+ 30.2814ms,0.0V 30.2999ms,0.0
+ 30.3000ms,3.3V 30.3013ms,3.3
+ 30.3014ms,0.0V 30.3199ms,0.0
+ 30.3200ms,3.3V 30.3213ms,3.3
+ 30.3214ms,0.0V 30.3399ms,0.0
+ 30.3400ms,3.3V 30.3413ms,3.3
+ 30.3414ms,0.0V 30.3599ms,0.0
+ 30.3600ms,3.3V 30.3613ms,3.3
+ 30.3614ms,0.0V 30.3799ms,0.0
+ 30.3800ms,3.3V 30.3813ms,3.3
+ 30.3814ms,0.0V 30.3999ms,0.0
+ 30.4000ms,3.3V 30.4013ms,3.3
+ 30.4014ms,0.0V 30.4199ms,0.0
+ 30.4200ms,3.3V 30.4213ms,3.3
+ 30.4214ms,0.0V 30.4399ms,0.0
+ 30.4400ms,3.3V 30.4413ms,3.3
+ 30.4414ms,0.0V 30.4599ms,0.0
+ 30.4600ms,3.3V 30.4613ms,3.3
+ 30.4614ms,0.0V 30.4799ms,0.0
+ 30.4800ms,3.3V 30.4813ms,3.3
+ 30.4814ms,0.0V 30.4999ms,0.0
+ 30.5000ms,3.3V 30.5013ms,3.3
+ 30.5014ms,0.0V 30.5199ms,0.0
+ 30.5200ms,3.3V 30.5213ms,3.3
+ 30.5214ms,0.0V 30.5399ms,0.0
+ 30.5400ms,3.3V 30.5413ms,3.3
+ 30.5414ms,0.0V 30.5599ms,0.0
+ 30.5600ms,3.3V 30.5613ms,3.3
+ 30.5614ms,0.0V 30.5799ms,0.0
+ 30.5800ms,3.3V 30.5813ms,3.3
+ 30.5814ms,0.0V 30.5999ms,0.0
+ 30.6000ms,3.3V 30.6013ms,3.3
+ 30.6014ms,0.0V 30.6199ms,0.0
+ 30.6200ms,3.3V 30.6213ms,3.3
+ 30.6214ms,0.0V 30.6399ms,0.0
+ 30.6400ms,3.3V 30.6413ms,3.3
+ 30.6414ms,0.0V 30.6599ms,0.0
+ 30.6600ms,3.3V 30.6613ms,3.3
+ 30.6614ms,0.0V 30.6799ms,0.0
+ 30.6800ms,3.3V 30.6813ms,3.3
+ 30.6814ms,0.0V 30.6999ms,0.0
+ 30.7000ms,3.3V 30.7013ms,3.3
+ 30.7014ms,0.0V 30.7199ms,0.0
+ 30.7200ms,3.3V 30.7213ms,3.3
+ 30.7214ms,0.0V 30.7399ms,0.0
+ 30.7400ms,3.3V 30.7413ms,3.3
+ 30.7414ms,0.0V 30.7599ms,0.0
+ 30.7600ms,3.3V 30.7613ms,3.3
+ 30.7614ms,0.0V 30.7799ms,0.0
+ 30.7800ms,3.3V 30.7813ms,3.3
+ 30.7814ms,0.0V 30.7999ms,0.0
+ 30.8000ms,3.3V 30.8013ms,3.3
+ 30.8014ms,0.0V 30.8199ms,0.0
+ 30.8200ms,3.3V 30.8213ms,3.3
+ 30.8214ms,0.0V 30.8399ms,0.0
+ 30.8400ms,3.3V 30.8413ms,3.3
+ 30.8414ms,0.0V 30.8599ms,0.0
+ 30.8600ms,3.3V 30.8613ms,3.3
+ 30.8614ms,0.0V 30.8799ms,0.0
+ 30.8800ms,3.3V 30.8813ms,3.3
+ 30.8814ms,0.0V 30.8999ms,0.0
+ 30.9000ms,3.3V 30.9013ms,3.3
+ 30.9014ms,0.0V 30.9199ms,0.0
+ 30.9200ms,3.3V 30.9213ms,3.3
+ 30.9214ms,0.0V 30.9399ms,0.0
+ 30.9400ms,3.3V 30.9413ms,3.3
+ 30.9414ms,0.0V 30.9599ms,0.0
+ 30.9600ms,3.3V 30.9613ms,3.3
+ 30.9614ms,0.0V 30.9799ms,0.0
+ 30.9800ms,3.3V 30.9813ms,3.3
+ 30.9814ms,0.0V 30.9999ms,0.0
+ 31.0000ms,3.3V 31.0013ms,3.3
+ 31.0014ms,0.0V 31.0199ms,0.0
+ 31.0200ms,3.3V 31.0213ms,3.3
+ 31.0214ms,0.0V 31.0399ms,0.0
+ 31.0400ms,3.3V 31.0413ms,3.3
+ 31.0414ms,0.0V 31.0599ms,0.0
+ 31.0600ms,3.3V 31.0613ms,3.3
+ 31.0614ms,0.0V 31.0799ms,0.0
+ 31.0800ms,3.3V 31.0813ms,3.3
+ 31.0814ms,0.0V 31.0999ms,0.0
+ 31.1000ms,3.3V 31.1013ms,3.3
+ 31.1014ms,0.0V 31.1199ms,0.0
+ 31.1200ms,3.3V 31.1213ms,3.3
+ 31.1214ms,0.0V 31.1399ms,0.0
+ 31.1400ms,3.3V 31.1413ms,3.3
+ 31.1414ms,0.0V 31.1599ms,0.0
+ 31.1600ms,3.3V 31.1613ms,3.3
+ 31.1614ms,0.0V 31.1799ms,0.0
+ 31.1800ms,3.3V 31.1813ms,3.3
+ 31.1814ms,0.0V 31.1999ms,0.0
+ 31.2000ms,3.3V 31.2013ms,3.3
+ 31.2014ms,0.0V 31.2199ms,0.0
+ 31.2200ms,3.3V 31.2213ms,3.3
+ 31.2214ms,0.0V 31.2399ms,0.0
+ 31.2400ms,3.3V 31.2413ms,3.3
+ 31.2414ms,0.0V 31.2599ms,0.0
+ 31.2600ms,3.3V 31.2613ms,3.3
+ 31.2614ms,0.0V 31.2799ms,0.0
+ 31.2800ms,3.3V 31.2813ms,3.3
+ 31.2814ms,0.0V 31.2999ms,0.0
+ 31.3000ms,3.3V 31.3013ms,3.3
+ 31.3014ms,0.0V 31.3199ms,0.0
+ 31.3200ms,3.3V 31.3213ms,3.3
+ 31.3214ms,0.0V 31.3399ms,0.0
+ 31.3400ms,3.3V 31.3413ms,3.3
+ 31.3414ms,0.0V 31.3599ms,0.0
+ 31.3600ms,3.3V 31.3613ms,3.3
+ 31.3614ms,0.0V 31.3799ms,0.0
+ 31.3800ms,3.3V 31.3813ms,3.3
+ 31.3814ms,0.0V 31.3999ms,0.0
+ 31.4000ms,3.3V 31.4013ms,3.3
+ 31.4014ms,0.0V 31.4199ms,0.0
+ 31.4200ms,3.3V 31.4213ms,3.3
+ 31.4214ms,0.0V 31.4399ms,0.0
+ 31.4400ms,3.3V 31.4413ms,3.3
+ 31.4414ms,0.0V 31.4599ms,0.0
+ 31.4600ms,3.3V 31.4613ms,3.3
+ 31.4614ms,0.0V 31.4799ms,0.0
+ 31.4800ms,3.3V 31.4813ms,3.3
+ 31.4814ms,0.0V 31.4999ms,0.0
+ 31.5000ms,3.3V 31.5013ms,3.3
+ 31.5014ms,0.0V 31.5199ms,0.0
+ 31.5200ms,3.3V 31.5213ms,3.3
+ 31.5214ms,0.0V 31.5399ms,0.0
+ 31.5400ms,3.3V 31.5413ms,3.3
+ 31.5414ms,0.0V 31.5599ms,0.0
+ 31.5600ms,3.3V 31.5613ms,3.3
+ 31.5614ms,0.0V 31.5799ms,0.0
+ 31.5800ms,3.3V 31.5813ms,3.3
+ 31.5814ms,0.0V 31.5999ms,0.0
+ 31.6000ms,3.3V 31.6013ms,3.3
+ 31.6014ms,0.0V 31.6199ms,0.0
+ 31.6200ms,3.3V 31.6213ms,3.3
+ 31.6214ms,0.0V 31.6399ms,0.0
+ 31.6400ms,3.3V 31.6413ms,3.3
+ 31.6414ms,0.0V 31.6599ms,0.0
+ 31.6600ms,3.3V 31.6613ms,3.3
+ 31.6614ms,0.0V 31.6799ms,0.0
+ 31.6800ms,3.3V 31.6813ms,3.3
+ 31.6814ms,0.0V 31.6999ms,0.0
+ 31.7000ms,3.3V 31.7013ms,3.3
+ 31.7014ms,0.0V 31.7199ms,0.0
+ 31.7200ms,3.3V 31.7213ms,3.3
+ 31.7214ms,0.0V 31.7399ms,0.0
+ 31.7400ms,3.3V 31.7413ms,3.3
+ 31.7414ms,0.0V 31.7599ms,0.0
+ 31.7600ms,3.3V 31.7613ms,3.3
+ 31.7614ms,0.0V 31.7799ms,0.0
+ 31.7800ms,3.3V 31.7813ms,3.3
+ 31.7814ms,0.0V 31.7999ms,0.0
+ 31.8000ms,3.3V 31.8013ms,3.3
+ 31.8014ms,0.0V 31.8199ms,0.0
+ 31.8200ms,3.3V 31.8213ms,3.3
+ 31.8214ms,0.0V 31.8399ms,0.0
+ 31.8400ms,3.3V 31.8413ms,3.3
+ 31.8414ms,0.0V 31.8599ms,0.0
+ 31.8600ms,3.3V 31.8613ms,3.3
+ 31.8614ms,0.0V 31.8799ms,0.0
+ 31.8800ms,3.3V 31.8813ms,3.3
+ 31.8814ms,0.0V 31.8999ms,0.0
+ 31.9000ms,3.3V 31.9013ms,3.3
+ 31.9014ms,0.0V 31.9199ms,0.0
+ 31.9200ms,3.3V 31.9213ms,3.3
+ 31.9214ms,0.0V 31.9399ms,0.0
+ 31.9400ms,3.3V 31.9413ms,3.3
+ 31.9414ms,0.0V 31.9599ms,0.0
+ 31.9600ms,3.3V 31.9613ms,3.3
+ 31.9614ms,0.0V 31.9799ms,0.0
+ 31.9800ms,3.3V 31.9813ms,3.3
+ 31.9814ms,0.0V 31.9999ms,0.0
+ 32.0000ms,3.3V 32.0013ms,3.3
+ 32.0014ms,0.0V 32.0199ms,0.0
+ 32.0200ms,3.3V 32.0213ms,3.3
+ 32.0214ms,0.0V 32.0399ms,0.0
+ 32.0400ms,3.3V 32.0413ms,3.3
+ 32.0414ms,0.0V 32.0599ms,0.0
+ 32.0600ms,3.3V 32.0613ms,3.3
+ 32.0614ms,0.0V 32.0799ms,0.0
+ 32.0800ms,3.3V 32.0813ms,3.3
+ 32.0814ms,0.0V 32.0999ms,0.0
+ 32.1000ms,3.3V 32.1013ms,3.3
+ 32.1014ms,0.0V 32.1199ms,0.0
+ 32.1200ms,3.3V 32.1213ms,3.3
+ 32.1214ms,0.0V 32.1399ms,0.0
+ 32.1400ms,3.3V 32.1413ms,3.3
+ 32.1414ms,0.0V 32.1599ms,0.0
+ 32.1600ms,3.3V 32.1613ms,3.3
+ 32.1614ms,0.0V 32.1799ms,0.0
+ 32.1800ms,3.3V 32.1813ms,3.3
+ 32.1814ms,0.0V 32.1999ms,0.0
+ 32.2000ms,3.3V 32.2013ms,3.3
+ 32.2014ms,0.0V 32.2199ms,0.0
+ 32.2200ms,3.3V 32.2213ms,3.3
+ 32.2214ms,0.0V 32.2399ms,0.0
+ 32.2400ms,3.3V 32.2413ms,3.3
+ 32.2414ms,0.0V 32.2599ms,0.0
+ 32.2600ms,3.3V 32.2613ms,3.3
+ 32.2614ms,0.0V 32.2799ms,0.0
+ 32.2800ms,3.3V 32.2813ms,3.3
+ 32.2814ms,0.0V 32.2999ms,0.0
+ 32.3000ms,3.3V 32.3013ms,3.3
+ 32.3014ms,0.0V 32.3199ms,0.0
+ 32.3200ms,3.3V 32.3213ms,3.3
+ 32.3214ms,0.0V 32.3399ms,0.0
+ 32.3400ms,3.3V 32.3413ms,3.3
+ 32.3414ms,0.0V 32.3599ms,0.0
+ 32.3600ms,3.3V 32.3613ms,3.3
+ 32.3614ms,0.0V 32.3799ms,0.0
+ 32.3800ms,3.3V 32.3813ms,3.3
+ 32.3814ms,0.0V 32.3999ms,0.0
+ 32.4000ms,3.3V 32.4013ms,3.3
+ 32.4014ms,0.0V 32.4199ms,0.0
+ 32.4200ms,3.3V 32.4213ms,3.3
+ 32.4214ms,0.0V 32.4399ms,0.0
+ 32.4400ms,3.3V 32.4413ms,3.3
+ 32.4414ms,0.0V 32.4599ms,0.0
+ 32.4600ms,3.3V 32.4613ms,3.3
+ 32.4614ms,0.0V 32.4799ms,0.0
+ 32.4800ms,3.3V 32.4813ms,3.3
+ 32.4814ms,0.0V 32.4999ms,0.0
+ 32.5000ms,3.3V 32.5013ms,3.3
+ 32.5014ms,0.0V 32.5199ms,0.0
+ 32.5200ms,3.3V 32.5213ms,3.3
+ 32.5214ms,0.0V 32.5399ms,0.0
+ 32.5400ms,3.3V 32.5413ms,3.3
+ 32.5414ms,0.0V 32.5599ms,0.0
+ 32.5600ms,3.3V 32.5613ms,3.3
+ 32.5614ms,0.0V 32.5799ms,0.0
+ 32.5800ms,3.3V 32.5813ms,3.3
+ 32.5814ms,0.0V 32.5999ms,0.0
+ 32.6000ms,3.3V 32.6013ms,3.3
+ 32.6014ms,0.0V 32.6199ms,0.0
+ 32.6200ms,3.3V 32.6213ms,3.3
+ 32.6214ms,0.0V 32.6399ms,0.0
+ 32.6400ms,3.3V 32.6413ms,3.3
+ 32.6414ms,0.0V 32.6599ms,0.0
+ 32.6600ms,3.3V 32.6613ms,3.3
+ 32.6614ms,0.0V 32.6799ms,0.0
+ 32.6800ms,3.3V 32.6813ms,3.3
+ 32.6814ms,0.0V 32.6999ms,0.0
+ 32.7000ms,3.3V 32.7013ms,3.3
+ 32.7014ms,0.0V 32.7199ms,0.0
+ 32.7200ms,3.3V 32.7213ms,3.3
+ 32.7214ms,0.0V 32.7399ms,0.0
+ 32.7400ms,3.3V 32.7413ms,3.3
+ 32.7414ms,0.0V 32.7599ms,0.0
+ 32.7600ms,3.3V 32.7613ms,3.3
+ 32.7614ms,0.0V 32.7799ms,0.0
+ 32.7800ms,3.3V 32.7813ms,3.3
+ 32.7814ms,0.0V 32.7999ms,0.0
+ 32.8000ms,3.3V 32.8013ms,3.3
+ 32.8014ms,0.0V 32.8199ms,0.0
+ 32.8200ms,3.3V 32.8213ms,3.3
+ 32.8214ms,0.0V 32.8399ms,0.0
+ 32.8400ms,3.3V 32.8413ms,3.3
+ 32.8414ms,0.0V 32.8599ms,0.0
+ 32.8600ms,3.3V 32.8613ms,3.3
+ 32.8614ms,0.0V 32.8799ms,0.0
+ 32.8800ms,3.3V 32.8813ms,3.3
+ 32.8814ms,0.0V 32.8999ms,0.0
+ 32.9000ms,3.3V 32.9013ms,3.3
+ 32.9014ms,0.0V 32.9199ms,0.0
+ 32.9200ms,3.3V 32.9213ms,3.3
+ 32.9214ms,0.0V 32.9399ms,0.0
+ 32.9400ms,3.3V 32.9413ms,3.3
+ 32.9414ms,0.0V 32.9599ms,0.0
+ 32.9600ms,3.3V 32.9613ms,3.3
+ 32.9614ms,0.0V 32.9799ms,0.0
+ 32.9800ms,3.3V 32.9813ms,3.3
+ 32.9814ms,0.0V 32.9999ms,0.0
+ 33.0000ms,3.3V 33.0013ms,3.3
+ 33.0014ms,0.0V 33.0199ms,0.0
+ 33.0200ms,3.3V 33.0213ms,3.3
+ 33.0214ms,0.0V 33.0399ms,0.0
+ 33.0400ms,3.3V 33.0413ms,3.3
+ 33.0414ms,0.0V 33.0599ms,0.0
+ 33.0600ms,3.3V 33.0613ms,3.3
+ 33.0614ms,0.0V 33.0799ms,0.0
+ 33.0800ms,3.3V 33.0813ms,3.3
+ 33.0814ms,0.0V 33.0999ms,0.0
+ 33.1000ms,3.3V 33.1013ms,3.3
+ 33.1014ms,0.0V 33.1199ms,0.0
+ 33.1200ms,3.3V 33.1213ms,3.3
+ 33.1214ms,0.0V 33.1399ms,0.0
+ 33.1400ms,3.3V 33.1413ms,3.3
+ 33.1414ms,0.0V 33.1599ms,0.0
+ 33.1600ms,3.3V 33.1613ms,3.3
+ 33.1614ms,0.0V 33.1799ms,0.0
+ 33.1800ms,3.3V 33.1813ms,3.3
+ 33.1814ms,0.0V 33.1999ms,0.0
+ 33.2000ms,3.3V 33.2013ms,3.3
+ 33.2014ms,0.0V 33.2199ms,0.0
+ 33.2200ms,3.3V 33.2213ms,3.3
+ 33.2214ms,0.0V 33.2399ms,0.0
+ 33.2400ms,3.3V 33.2413ms,3.3
+ 33.2414ms,0.0V 33.2599ms,0.0
+ 33.2600ms,3.3V 33.2613ms,3.3
+ 33.2614ms,0.0V 33.2799ms,0.0
+ 33.2800ms,3.3V 33.2813ms,3.3
+ 33.2814ms,0.0V 33.2999ms,0.0
+ 33.3000ms,3.3V 33.3013ms,3.3
+ 33.3014ms,0.0V 33.3199ms,0.0
+ 33.3200ms,3.3V 33.3213ms,3.3
+ 33.3214ms,0.0V 33.3399ms,0.0
+ 33.3400ms,3.3V 33.3413ms,3.3
+ 33.3414ms,0.0V 33.3599ms,0.0
+ 33.3600ms,3.3V 33.3613ms,3.3
+ 33.3614ms,0.0V 33.3799ms,0.0
+ 33.3800ms,3.3V 33.3813ms,3.3
+ 33.3814ms,0.0V 33.3999ms,0.0
+ 33.4000ms,3.3V 33.4013ms,3.3
+ 33.4014ms,0.0V 33.4199ms,0.0
+ 33.4200ms,3.3V 33.4213ms,3.3
+ 33.4214ms,0.0V 33.4399ms,0.0
+ 33.4400ms,3.3V 33.4413ms,3.3
+ 33.4414ms,0.0V 33.4599ms,0.0
+ 33.4600ms,3.3V 33.4613ms,3.3
+ 33.4614ms,0.0V 33.4799ms,0.0
+ 33.4800ms,3.3V 33.4813ms,3.3
+ 33.4814ms,0.0V 33.4999ms,0.0
+ 33.5000ms,3.3V 33.5013ms,3.3
+ 33.5014ms,0.0V 33.5199ms,0.0
+ 33.5200ms,3.3V 33.5213ms,3.3
+ 33.5214ms,0.0V 33.5399ms,0.0
+ 33.5400ms,3.3V 33.5413ms,3.3
+ 33.5414ms,0.0V 33.5599ms,0.0
+ 33.5600ms,3.3V 33.5613ms,3.3
+ 33.5614ms,0.0V 33.5799ms,0.0
+ 33.5800ms,3.3V 33.5813ms,3.3
+ 33.5814ms,0.0V 33.5999ms,0.0
+ 33.6000ms,3.3V 33.6013ms,3.3
+ 33.6014ms,0.0V 33.6199ms,0.0
+ 33.6200ms,3.3V 33.6213ms,3.3
+ 33.6214ms,0.0V 33.6399ms,0.0
+ 33.6400ms,3.3V 33.6413ms,3.3
+ 33.6414ms,0.0V 33.6599ms,0.0
+ 33.6600ms,3.3V 33.6613ms,3.3
+ 33.6614ms,0.0V 33.6799ms,0.0
+ 33.6800ms,3.3V 33.6813ms,3.3
+ 33.6814ms,0.0V 33.6999ms,0.0
+ 33.7000ms,3.3V 33.7013ms,3.3
+ 33.7014ms,0.0V 33.7199ms,0.0
+ 33.7200ms,3.3V 33.7213ms,3.3
+ 33.7214ms,0.0V 33.7399ms,0.0
+ 33.7400ms,3.3V 33.7413ms,3.3
+ 33.7414ms,0.0V 33.7599ms,0.0
+ 33.7600ms,3.3V 33.7613ms,3.3
+ 33.7614ms,0.0V 33.7799ms,0.0
+ 33.7800ms,3.3V 33.7813ms,3.3
+ 33.7814ms,0.0V 33.7999ms,0.0
+ 33.8000ms,3.3V 33.8013ms,3.3
+ 33.8014ms,0.0V 33.8199ms,0.0
+ 33.8200ms,3.3V 33.8213ms,3.3
+ 33.8214ms,0.0V 33.8399ms,0.0
+ 33.8400ms,3.3V 33.8413ms,3.3
+ 33.8414ms,0.0V 33.8599ms,0.0
+ 33.8600ms,3.3V 33.8613ms,3.3
+ 33.8614ms,0.0V 33.8799ms,0.0
+ 33.8800ms,3.3V 33.8813ms,3.3
+ 33.8814ms,0.0V 33.8999ms,0.0
+ 33.9000ms,3.3V 33.9013ms,3.3
+ 33.9014ms,0.0V 33.9199ms,0.0
+ 33.9200ms,3.3V 33.9213ms,3.3
+ 33.9214ms,0.0V 33.9399ms,0.0
+ 33.9400ms,3.3V 33.9413ms,3.3
+ 33.9414ms,0.0V 33.9599ms,0.0
+ 33.9600ms,3.3V 33.9613ms,3.3
+ 33.9614ms,0.0V 33.9799ms,0.0
+ 33.9800ms,3.3V 33.9813ms,3.3
+ 33.9814ms,0.0V 33.9999ms,0.0
+ 34.0000ms,3.3V 34.0013ms,3.3
+ 34.0014ms,0.0V 34.0199ms,0.0
+ 34.0200ms,3.3V 34.0213ms,3.3
+ 34.0214ms,0.0V 34.0399ms,0.0
+ 34.0400ms,3.3V 34.0413ms,3.3
+ 34.0414ms,0.0V 34.0599ms,0.0
+ 34.0600ms,3.3V 34.0613ms,3.3
+ 34.0614ms,0.0V 34.0799ms,0.0
+ 34.0800ms,3.3V 34.0813ms,3.3
+ 34.0814ms,0.0V 34.0999ms,0.0
+ 34.1000ms,3.3V 34.1013ms,3.3
+ 34.1014ms,0.0V 34.1199ms,0.0
+ 34.1200ms,3.3V 34.1213ms,3.3
+ 34.1214ms,0.0V 34.1399ms,0.0
+ 34.1400ms,3.3V 34.1413ms,3.3
+ 34.1414ms,0.0V 34.1599ms,0.0
+ 34.1600ms,3.3V 34.1613ms,3.3
+ 34.1614ms,0.0V 34.1799ms,0.0
+ 34.1800ms,3.3V 34.1813ms,3.3
+ 34.1814ms,0.0V 34.1999ms,0.0
+ 34.2000ms,3.3V 34.2013ms,3.3
+ 34.2014ms,0.0V 34.2199ms,0.0
+ 34.2200ms,3.3V 34.2213ms,3.3
+ 34.2214ms,0.0V 34.2399ms,0.0
+ 34.2400ms,3.3V 34.2413ms,3.3
+ 34.2414ms,0.0V 34.2599ms,0.0
+ 34.2600ms,3.3V 34.2613ms,3.3
+ 34.2614ms,0.0V 34.2799ms,0.0
+ 34.2800ms,3.3V 34.2813ms,3.3
+ 34.2814ms,0.0V 34.2999ms,0.0
+ 34.3000ms,3.3V 34.3013ms,3.3
+ 34.3014ms,0.0V 34.3199ms,0.0
+ 34.3200ms,3.3V 34.3213ms,3.3
+ 34.3214ms,0.0V 34.3399ms,0.0
+ 34.3400ms,3.3V 34.3413ms,3.3
+ 34.3414ms,0.0V 34.3599ms,0.0
+ 34.3600ms,3.3V 34.3613ms,3.3
+ 34.3614ms,0.0V 34.3799ms,0.0
+ 34.3800ms,3.3V 34.3813ms,3.3
+ 34.3814ms,0.0V 34.3999ms,0.0
+ 34.4000ms,3.3V 34.4013ms,3.3
+ 34.4014ms,0.0V 34.4199ms,0.0
+ 34.4200ms,3.3V 34.4213ms,3.3
+ 34.4214ms,0.0V 34.4399ms,0.0
+ 34.4400ms,3.3V 34.4413ms,3.3
+ 34.4414ms,0.0V 34.4599ms,0.0
+ 34.4600ms,3.3V 34.4613ms,3.3
+ 34.4614ms,0.0V 34.4799ms,0.0
+ 34.4800ms,3.3V 34.4813ms,3.3
+ 34.4814ms,0.0V 34.4999ms,0.0
+ 34.5000ms,3.3V 34.5013ms,3.3
+ 34.5014ms,0.0V 34.5199ms,0.0
+ 34.5200ms,3.3V 34.5213ms,3.3
+ 34.5214ms,0.0V 34.5399ms,0.0
+ 34.5400ms,3.3V 34.5413ms,3.3
+ 34.5414ms,0.0V 34.5599ms,0.0
+ 34.5600ms,3.3V 34.5613ms,3.3
+ 34.5614ms,0.0V 34.5799ms,0.0
+ 34.5800ms,3.3V 34.5813ms,3.3
+ 34.5814ms,0.0V 34.5999ms,0.0
+ 34.6000ms,3.3V 34.6013ms,3.3
+ 34.6014ms,0.0V 34.6199ms,0.0
+ 34.6200ms,3.3V 34.6213ms,3.3
+ 34.6214ms,0.0V 34.6399ms,0.0
+ 34.6400ms,3.3V 34.6413ms,3.3
+ 34.6414ms,0.0V 34.6599ms,0.0
+ 34.6600ms,3.3V 34.6613ms,3.3
+ 34.6614ms,0.0V 34.6799ms,0.0
+ 34.6800ms,3.3V 34.6813ms,3.3
+ 34.6814ms,0.0V 34.6999ms,0.0
+ 34.7000ms,3.3V 34.7013ms,3.3
+ 34.7014ms,0.0V 34.7199ms,0.0
+ 34.7200ms,3.3V 34.7213ms,3.3
+ 34.7214ms,0.0V 34.7399ms,0.0
+ 34.7400ms,3.3V 34.7413ms,3.3
+ 34.7414ms,0.0V 34.7599ms,0.0
+ 34.7600ms,3.3V 34.7613ms,3.3
+ 34.7614ms,0.0V 34.7799ms,0.0
+ 34.7800ms,3.3V 34.7813ms,3.3
+ 34.7814ms,0.0V 34.7999ms,0.0
+ 34.8000ms,3.3V 34.8013ms,3.3
+ 34.8014ms,0.0V 34.8199ms,0.0
+ 34.8200ms,3.3V 34.8213ms,3.3
+ 34.8214ms,0.0V 34.8399ms,0.0
+ 34.8400ms,3.3V 34.8413ms,3.3
+ 34.8414ms,0.0V 34.8599ms,0.0
+ 34.8600ms,3.3V 34.8613ms,3.3
+ 34.8614ms,0.0V 34.8799ms,0.0
+ 34.8800ms,3.3V 34.8813ms,3.3
+ 34.8814ms,0.0V 34.8999ms,0.0
+ 34.9000ms,3.3V 34.9013ms,3.3
+ 34.9014ms,0.0V 34.9199ms,0.0
+ 34.9200ms,3.3V 34.9213ms,3.3
+ 34.9214ms,0.0V 34.9399ms,0.0
+ 34.9400ms,3.3V 34.9413ms,3.3
+ 34.9414ms,0.0V 34.9599ms,0.0
+ 34.9600ms,3.3V 34.9613ms,3.3
+ 34.9614ms,0.0V 34.9799ms,0.0
+ 34.9800ms,3.3V 34.9813ms,3.3
+ 34.9814ms,0.0V 34.9999ms,0.0
+ 35.0000ms,3.3V 35.0013ms,3.3
+ 35.0014ms,0.0V 35.0199ms,0.0
+ 35.0200ms,3.3V 35.0213ms,3.3
+ 35.0214ms,0.0V 35.0399ms,0.0
+ 35.0400ms,3.3V 35.0413ms,3.3
+ 35.0414ms,0.0V 35.0599ms,0.0
+ 35.0600ms,3.3V 35.0613ms,3.3
+ 35.0614ms,0.0V 35.0799ms,0.0
+ 35.0800ms,3.3V 35.0813ms,3.3
+ 35.0814ms,0.0V 35.0999ms,0.0
+ 35.1000ms,3.3V 35.1013ms,3.3
+ 35.1014ms,0.0V 35.1199ms,0.0
+ 35.1200ms,3.3V 35.1215ms,3.3
+ 35.1216ms,0.0V 35.1399ms,0.0
+ 35.1400ms,3.3V 35.1415ms,3.3
+ 35.1416ms,0.0V 35.1599ms,0.0
+ 35.1600ms,3.3V 35.1615ms,3.3
+ 35.1616ms,0.0V 35.1799ms,0.0
+ 35.1800ms,3.3V 35.1815ms,3.3
+ 35.1816ms,0.0V 35.1999ms,0.0
+ 35.2000ms,3.3V 35.2015ms,3.3
+ 35.2016ms,0.0V 35.2199ms,0.0
+ 35.2200ms,3.3V 35.2215ms,3.3
+ 35.2216ms,0.0V 35.2399ms,0.0
+ 35.2400ms,3.3V 35.2415ms,3.3
+ 35.2416ms,0.0V 35.2599ms,0.0
+ 35.2600ms,3.3V 35.2615ms,3.3
+ 35.2616ms,0.0V 35.2799ms,0.0
+ 35.2800ms,3.3V 35.2815ms,3.3
+ 35.2816ms,0.0V 35.2999ms,0.0
+ 35.3000ms,3.3V 35.3015ms,3.3
+ 35.3016ms,0.0V 35.3199ms,0.0
+ 35.3200ms,3.3V 35.3215ms,3.3
+ 35.3216ms,0.0V 35.3399ms,0.0
+ 35.3400ms,3.3V 35.3415ms,3.3
+ 35.3416ms,0.0V 35.3599ms,0.0
+ 35.3600ms,3.3V 35.3615ms,3.3
+ 35.3616ms,0.0V 35.3799ms,0.0
+ 35.3800ms,3.3V 35.3815ms,3.3
+ 35.3816ms,0.0V 35.3999ms,0.0
+ 35.4000ms,3.3V 35.4015ms,3.3
+ 35.4016ms,0.0V 35.4199ms,0.0
+ 35.4200ms,3.3V 35.4215ms,3.3
+ 35.4216ms,0.0V 35.4399ms,0.0
+ 35.4400ms,3.3V 35.4415ms,3.3
+ 35.4416ms,0.0V 35.4599ms,0.0
+ 35.4600ms,3.3V 35.4615ms,3.3
+ 35.4616ms,0.0V 35.4799ms,0.0
+ 35.4800ms,3.3V 35.4815ms,3.3
+ 35.4816ms,0.0V 35.4999ms,0.0
+ 35.5000ms,3.3V 35.5015ms,3.3
+ 35.5016ms,0.0V 35.5199ms,0.0
+ 35.5200ms,3.3V 35.5215ms,3.3
+ 35.5216ms,0.0V 35.5399ms,0.0
+ 35.5400ms,3.3V 35.5415ms,3.3
+ 35.5416ms,0.0V 35.5599ms,0.0
+ 35.5600ms,3.3V 35.5615ms,3.3
+ 35.5616ms,0.0V 35.5799ms,0.0
+ 35.5800ms,3.3V 35.5815ms,3.3
+ 35.5816ms,0.0V 35.5999ms,0.0
+ 35.6000ms,3.3V 35.6015ms,3.3
+ 35.6016ms,0.0V 35.6199ms,0.0
+ 35.6200ms,3.3V 35.6215ms,3.3
+ 35.6216ms,0.0V 35.6399ms,0.0
+ 35.6400ms,3.3V 35.6415ms,3.3
+ 35.6416ms,0.0V 35.6599ms,0.0
+ 35.6600ms,3.3V 35.6615ms,3.3
+ 35.6616ms,0.0V 35.6799ms,0.0
+ 35.6800ms,3.3V 35.6815ms,3.3
+ 35.6816ms,0.0V 35.6999ms,0.0
+ 35.7000ms,3.3V 35.7015ms,3.3
+ 35.7016ms,0.0V 35.7199ms,0.0
+ 35.7200ms,3.3V 35.7215ms,3.3
+ 35.7216ms,0.0V 35.7399ms,0.0
+ 35.7400ms,3.3V 35.7415ms,3.3
+ 35.7416ms,0.0V 35.7599ms,0.0
+ 35.7600ms,3.3V 35.7615ms,3.3
+ 35.7616ms,0.0V 35.7799ms,0.0
+ 35.7800ms,3.3V 35.7815ms,3.3
+ 35.7816ms,0.0V 35.7999ms,0.0
+ 35.8000ms,3.3V 35.8015ms,3.3
+ 35.8016ms,0.0V 35.8199ms,0.0
+ 35.8200ms,3.3V 35.8215ms,3.3
+ 35.8216ms,0.0V 35.8399ms,0.0
+ 35.8400ms,3.3V 35.8415ms,3.3
+ 35.8416ms,0.0V 35.8599ms,0.0
+ 35.8600ms,3.3V 35.8615ms,3.3
+ 35.8616ms,0.0V 35.8799ms,0.0
+ 35.8800ms,3.3V 35.8815ms,3.3
+ 35.8816ms,0.0V 35.8999ms,0.0
+ 35.9000ms,3.3V 35.9015ms,3.3
+ 35.9016ms,0.0V 35.9199ms,0.0
+ 35.9200ms,3.3V 35.9215ms,3.3
+ 35.9216ms,0.0V 35.9399ms,0.0
+ 35.9400ms,3.3V 35.9415ms,3.3
+ 35.9416ms,0.0V 35.9599ms,0.0
+ 35.9600ms,3.3V 35.9615ms,3.3
+ 35.9616ms,0.0V 35.9799ms,0.0
+ 35.9800ms,3.3V 35.9815ms,3.3
+ 35.9816ms,0.0V 35.9999ms,0.0
+ 36.0000ms,3.3V 36.0015ms,3.3
+ 36.0016ms,0.0V 36.0199ms,0.0
+ 36.0200ms,3.3V 36.0215ms,3.3
+ 36.0216ms,0.0V 36.0399ms,0.0
+ 36.0400ms,3.3V 36.0415ms,3.3
+ 36.0416ms,0.0V 36.0599ms,0.0
+ 36.0600ms,3.3V 36.0615ms,3.3
+ 36.0616ms,0.0V 36.0799ms,0.0
+ 36.0800ms,3.3V 36.0815ms,3.3
+ 36.0816ms,0.0V 36.0999ms,0.0
+ 36.1000ms,3.3V 36.1015ms,3.3
+ 36.1016ms,0.0V 36.1199ms,0.0
+ 36.1200ms,3.3V 36.1215ms,3.3
+ 36.1216ms,0.0V 36.1399ms,0.0
+ 36.1400ms,3.3V 36.1415ms,3.3
+ 36.1416ms,0.0V 36.1599ms,0.0
+ 36.1600ms,3.3V 36.1615ms,3.3
+ 36.1616ms,0.0V 36.1799ms,0.0
+ 36.1800ms,3.3V 36.1815ms,3.3
+ 36.1816ms,0.0V 36.1999ms,0.0
+ 36.2000ms,3.3V 36.2015ms,3.3
+ 36.2016ms,0.0V 36.2199ms,0.0
+ 36.2200ms,3.3V 36.2215ms,3.3
+ 36.2216ms,0.0V 36.2399ms,0.0
+ 36.2400ms,3.3V 36.2415ms,3.3
+ 36.2416ms,0.0V 36.2599ms,0.0
+ 36.2600ms,3.3V 36.2615ms,3.3
+ 36.2616ms,0.0V 36.2799ms,0.0
+ 36.2800ms,3.3V 36.2815ms,3.3
+ 36.2816ms,0.0V 36.2999ms,0.0
+ 36.3000ms,3.3V 36.3015ms,3.3
+ 36.3016ms,0.0V 36.3199ms,0.0
+ 36.3200ms,3.3V 36.3215ms,3.3
+ 36.3216ms,0.0V 36.3399ms,0.0
+ 36.3400ms,3.3V 36.3415ms,3.3
+ 36.3416ms,0.0V 36.3599ms,0.0
+ 36.3600ms,3.3V 36.3615ms,3.3
+ 36.3616ms,0.0V 36.3799ms,0.0
+ 36.3800ms,3.3V 36.3815ms,3.3
+ 36.3816ms,0.0V 36.3999ms,0.0
+ 36.4000ms,3.3V 36.4015ms,3.3
+ 36.4016ms,0.0V 36.4199ms,0.0
+ 36.4200ms,3.3V 36.4215ms,3.3
+ 36.4216ms,0.0V 36.4399ms,0.0
+ 36.4400ms,3.3V 36.4415ms,3.3
+ 36.4416ms,0.0V 36.4599ms,0.0
+ 36.4600ms,3.3V 36.4615ms,3.3
+ 36.4616ms,0.0V 36.4799ms,0.0
+ 36.4800ms,3.3V 36.4815ms,3.3
+ 36.4816ms,0.0V 36.4999ms,0.0
+ 36.5000ms,3.3V 36.5015ms,3.3
+ 36.5016ms,0.0V 36.5199ms,0.0
+ 36.5200ms,3.3V 36.5215ms,3.3
+ 36.5216ms,0.0V 36.5399ms,0.0
+ 36.5400ms,3.3V 36.5415ms,3.3
+ 36.5416ms,0.0V 36.5599ms,0.0
+ 36.5600ms,3.3V 36.5615ms,3.3
+ 36.5616ms,0.0V 36.5799ms,0.0
+ 36.5800ms,3.3V 36.5815ms,3.3
+ 36.5816ms,0.0V 36.5999ms,0.0
+ 36.6000ms,3.3V 36.6015ms,3.3
+ 36.6016ms,0.0V 36.6199ms,0.0
+ 36.6200ms,3.3V 36.6215ms,3.3
+ 36.6216ms,0.0V 36.6399ms,0.0
+ 36.6400ms,3.3V 36.6415ms,3.3
+ 36.6416ms,0.0V 36.6599ms,0.0
+ 36.6600ms,3.3V 36.6615ms,3.3
+ 36.6616ms,0.0V 36.6799ms,0.0
+ 36.6800ms,3.3V 36.6815ms,3.3
+ 36.6816ms,0.0V 36.6999ms,0.0
+ 36.7000ms,3.3V 36.7015ms,3.3
+ 36.7016ms,0.0V 36.7199ms,0.0
+ 36.7200ms,3.3V 36.7215ms,3.3
+ 36.7216ms,0.0V 36.7399ms,0.0
+ 36.7400ms,3.3V 36.7415ms,3.3
+ 36.7416ms,0.0V 36.7599ms,0.0
+ 36.7600ms,3.3V 36.7615ms,3.3
+ 36.7616ms,0.0V 36.7799ms,0.0
+ 36.7800ms,3.3V 36.7815ms,3.3
+ 36.7816ms,0.0V 36.7999ms,0.0
+ 36.8000ms,3.3V 36.8015ms,3.3
+ 36.8016ms,0.0V 36.8199ms,0.0
+ 36.8200ms,3.3V 36.8215ms,3.3
+ 36.8216ms,0.0V 36.8399ms,0.0
+ 36.8400ms,3.3V 36.8415ms,3.3
+ 36.8416ms,0.0V 36.8599ms,0.0
+ 36.8600ms,3.3V 36.8615ms,3.3
+ 36.8616ms,0.0V 36.8799ms,0.0
+ 36.8800ms,3.3V 36.8815ms,3.3
+ 36.8816ms,0.0V 36.8999ms,0.0
+ 36.9000ms,3.3V 36.9015ms,3.3
+ 36.9016ms,0.0V 36.9199ms,0.0
+ 36.9200ms,3.3V 36.9215ms,3.3
+ 36.9216ms,0.0V 36.9399ms,0.0
+ 36.9400ms,3.3V 36.9415ms,3.3
+ 36.9416ms,0.0V 36.9599ms,0.0
+ 36.9600ms,3.3V 36.9615ms,3.3
+ 36.9616ms,0.0V 36.9799ms,0.0
+ 36.9800ms,3.3V 36.9815ms,3.3
+ 36.9816ms,0.0V 36.9999ms,0.0
+ 37.0000ms,3.3V 37.0015ms,3.3
+ 37.0016ms,0.0V 37.0199ms,0.0
+ 37.0200ms,3.3V 37.0215ms,3.3
+ 37.0216ms,0.0V 37.0399ms,0.0
+ 37.0400ms,3.3V 37.0415ms,3.3
+ 37.0416ms,0.0V 37.0599ms,0.0
+ 37.0600ms,3.3V 37.0615ms,3.3
+ 37.0616ms,0.0V 37.0799ms,0.0
+ 37.0800ms,3.3V 37.0815ms,3.3
+ 37.0816ms,0.0V 37.0999ms,0.0
+ 37.1000ms,3.3V 37.1015ms,3.3
+ 37.1016ms,0.0V 37.1199ms,0.0
+ 37.1200ms,3.3V 37.1215ms,3.3
+ 37.1216ms,0.0V 37.1399ms,0.0
+ 37.1400ms,3.3V 37.1415ms,3.3
+ 37.1416ms,0.0V 37.1599ms,0.0
+ 37.1600ms,3.3V 37.1615ms,3.3
+ 37.1616ms,0.0V 37.1799ms,0.0
+ 37.1800ms,3.3V 37.1815ms,3.3
+ 37.1816ms,0.0V 37.1999ms,0.0
+ 37.2000ms,3.3V 37.2015ms,3.3
+ 37.2016ms,0.0V 37.2199ms,0.0
+ 37.2200ms,3.3V 37.2215ms,3.3
+ 37.2216ms,0.0V 37.2399ms,0.0
+ 37.2400ms,3.3V 37.2415ms,3.3
+ 37.2416ms,0.0V 37.2599ms,0.0
+ 37.2600ms,3.3V 37.2615ms,3.3
+ 37.2616ms,0.0V 37.2799ms,0.0
+ 37.2800ms,3.3V 37.2815ms,3.3
+ 37.2816ms,0.0V 37.2999ms,0.0
+ 37.3000ms,3.3V 37.3015ms,3.3
+ 37.3016ms,0.0V 37.3199ms,0.0
+ 37.3200ms,3.3V 37.3215ms,3.3
+ 37.3216ms,0.0V 37.3399ms,0.0
+ 37.3400ms,3.3V 37.3415ms,3.3
+ 37.3416ms,0.0V 37.3599ms,0.0
+ 37.3600ms,3.3V 37.3615ms,3.3
+ 37.3616ms,0.0V 37.3799ms,0.0
+ 37.3800ms,3.3V 37.3815ms,3.3
+ 37.3816ms,0.0V 37.3999ms,0.0
+ 37.4000ms,3.3V 37.4015ms,3.3
+ 37.4016ms,0.0V 37.4199ms,0.0
+ 37.4200ms,3.3V 37.4215ms,3.3
+ 37.4216ms,0.0V 37.4399ms,0.0
+ 37.4400ms,3.3V 37.4415ms,3.3
+ 37.4416ms,0.0V 37.4599ms,0.0
+ 37.4600ms,3.3V 37.4615ms,3.3
+ 37.4616ms,0.0V 37.4799ms,0.0
+ 37.4800ms,3.3V 37.4815ms,3.3
+ 37.4816ms,0.0V 37.4999ms,0.0
+ 37.5000ms,3.3V 37.5015ms,3.3
+ 37.5016ms,0.0V 37.5199ms,0.0
+ 37.5200ms,3.3V 37.5215ms,3.3
+ 37.5216ms,0.0V 37.5399ms,0.0
+ 37.5400ms,3.3V 37.5415ms,3.3
+ 37.5416ms,0.0V 37.5599ms,0.0
+ 37.5600ms,3.3V 37.5615ms,3.3
+ 37.5616ms,0.0V 37.5799ms,0.0
+ 37.5800ms,3.3V 37.5815ms,3.3
+ 37.5816ms,0.0V 37.5999ms,0.0
+ 37.6000ms,3.3V 37.6015ms,3.3
+ 37.6016ms,0.0V 37.6199ms,0.0
+ 37.6200ms,3.3V 37.6215ms,3.3
+ 37.6216ms,0.0V 37.6399ms,0.0
+ 37.6400ms,3.3V 37.6415ms,3.3
+ 37.6416ms,0.0V 37.6599ms,0.0
+ 37.6600ms,3.3V 37.6615ms,3.3
+ 37.6616ms,0.0V 37.6799ms,0.0
+ 37.6800ms,3.3V 37.6815ms,3.3
+ 37.6816ms,0.0V 37.6999ms,0.0
+ 37.7000ms,3.3V 37.7015ms,3.3
+ 37.7016ms,0.0V 37.7199ms,0.0
+ 37.7200ms,3.3V 37.7215ms,3.3
+ 37.7216ms,0.0V 37.7399ms,0.0
+ 37.7400ms,3.3V 37.7415ms,3.3
+ 37.7416ms,0.0V 37.7599ms,0.0
+ 37.7600ms,3.3V 37.7615ms,3.3
+ 37.7616ms,0.0V 37.7799ms,0.0
+ 37.7800ms,3.3V 37.7815ms,3.3
+ 37.7816ms,0.0V 37.7999ms,0.0
+ 37.8000ms,3.3V 37.8015ms,3.3
+ 37.8016ms,0.0V 37.8199ms,0.0
+ 37.8200ms,3.3V 37.8215ms,3.3
+ 37.8216ms,0.0V 37.8399ms,0.0
+ 37.8400ms,3.3V 37.8415ms,3.3
+ 37.8416ms,0.0V 37.8599ms,0.0
+ 37.8600ms,3.3V 37.8615ms,3.3
+ 37.8616ms,0.0V 37.8799ms,0.0
+ 37.8800ms,3.3V 37.8815ms,3.3
+ 37.8816ms,0.0V 37.8999ms,0.0
+ 37.9000ms,3.3V 37.9015ms,3.3
+ 37.9016ms,0.0V 37.9199ms,0.0
+ 37.9200ms,3.3V 37.9215ms,3.3
+ 37.9216ms,0.0V 37.9399ms,0.0
+ 37.9400ms,3.3V 37.9415ms,3.3
+ 37.9416ms,0.0V 37.9599ms,0.0
+ 37.9600ms,3.3V 37.9615ms,3.3
+ 37.9616ms,0.0V 37.9799ms,0.0
+ 37.9800ms,3.3V 37.9815ms,3.3
+ 37.9816ms,0.0V 37.9999ms,0.0
+ 38.0000ms,3.3V 38.0015ms,3.3
+ 38.0016ms,0.0V 38.0199ms,0.0
+ 38.0200ms,3.3V 38.0215ms,3.3
+ 38.0216ms,0.0V 38.0399ms,0.0
+ 38.0400ms,3.3V 38.0415ms,3.3
+ 38.0416ms,0.0V 38.0599ms,0.0
+ 38.0600ms,3.3V 38.0615ms,3.3
+ 38.0616ms,0.0V 38.0799ms,0.0
+ 38.0800ms,3.3V 38.0815ms,3.3
+ 38.0816ms,0.0V 38.0999ms,0.0
+ 38.1000ms,3.3V 38.1015ms,3.3
+ 38.1016ms,0.0V 38.1199ms,0.0
+ 38.1200ms,3.3V 38.1215ms,3.3
+ 38.1216ms,0.0V 38.1399ms,0.0
+ 38.1400ms,3.3V 38.1415ms,3.3
+ 38.1416ms,0.0V 38.1599ms,0.0
+ 38.1600ms,3.3V 38.1615ms,3.3
+ 38.1616ms,0.0V 38.1799ms,0.0
+ 38.1800ms,3.3V 38.1815ms,3.3
+ 38.1816ms,0.0V 38.1999ms,0.0
+ 38.2000ms,3.3V 38.2015ms,3.3
+ 38.2016ms,0.0V 38.2199ms,0.0
+ 38.2200ms,3.3V 38.2215ms,3.3
+ 38.2216ms,0.0V 38.2399ms,0.0
+ 38.2400ms,3.3V 38.2415ms,3.3
+ 38.2416ms,0.0V 38.2599ms,0.0
+ 38.2600ms,3.3V 38.2615ms,3.3
+ 38.2616ms,0.0V 38.2799ms,0.0
+ 38.2800ms,3.3V 38.2815ms,3.3
+ 38.2816ms,0.0V 38.2999ms,0.0
+ 38.3000ms,3.3V 38.3015ms,3.3
+ 38.3016ms,0.0V 38.3199ms,0.0
+ 38.3200ms,3.3V 38.3215ms,3.3
+ 38.3216ms,0.0V 38.3399ms,0.0
+ 38.3400ms,3.3V 38.3415ms,3.3
+ 38.3416ms,0.0V 38.3599ms,0.0
+ 38.3600ms,3.3V 38.3615ms,3.3
+ 38.3616ms,0.0V 38.3799ms,0.0
+ 38.3800ms,3.3V 38.3815ms,3.3
+ 38.3816ms,0.0V 38.3999ms,0.0
+ 38.4000ms,3.3V 38.4015ms,3.3
+ 38.4016ms,0.0V 38.4199ms,0.0
+ 38.4200ms,3.3V 38.4215ms,3.3
+ 38.4216ms,0.0V 38.4399ms,0.0
+ 38.4400ms,3.3V 38.4415ms,3.3
+ 38.4416ms,0.0V 38.4599ms,0.0
+ 38.4600ms,3.3V 38.4615ms,3.3
+ 38.4616ms,0.0V 38.4799ms,0.0
+ 38.4800ms,3.3V 38.4815ms,3.3
+ 38.4816ms,0.0V 38.4999ms,0.0
+ 38.5000ms,3.3V 38.5015ms,3.3
+ 38.5016ms,0.0V 38.5199ms,0.0
+ 38.5200ms,3.3V 38.5215ms,3.3
+ 38.5216ms,0.0V 38.5399ms,0.0
+ 38.5400ms,3.3V 38.5415ms,3.3
+ 38.5416ms,0.0V 38.5599ms,0.0
+ 38.5600ms,3.3V 38.5615ms,3.3
+ 38.5616ms,0.0V 38.5799ms,0.0
+ 38.5800ms,3.3V 38.5815ms,3.3
+ 38.5816ms,0.0V 38.5999ms,0.0
+ 38.6000ms,3.3V 38.6015ms,3.3
+ 38.6016ms,0.0V 38.6199ms,0.0
+ 38.6200ms,3.3V 38.6215ms,3.3
+ 38.6216ms,0.0V 38.6399ms,0.0
+ 38.6400ms,3.3V 38.6415ms,3.3
+ 38.6416ms,0.0V 38.6599ms,0.0
+ 38.6600ms,3.3V 38.6615ms,3.3
+ 38.6616ms,0.0V 38.6799ms,0.0
+ 38.6800ms,3.3V 38.6815ms,3.3
+ 38.6816ms,0.0V 38.6999ms,0.0
+ 38.7000ms,3.3V 38.7015ms,3.3
+ 38.7016ms,0.0V 38.7199ms,0.0
+ 38.7200ms,3.3V 38.7215ms,3.3
+ 38.7216ms,0.0V 38.7399ms,0.0
+ 38.7400ms,3.3V 38.7415ms,3.3
+ 38.7416ms,0.0V 38.7599ms,0.0
+ 38.7600ms,3.3V 38.7615ms,3.3
+ 38.7616ms,0.0V 38.7799ms,0.0
+ 38.7800ms,3.3V 38.7815ms,3.3
+ 38.7816ms,0.0V 38.7999ms,0.0
+ 38.8000ms,3.3V 38.8015ms,3.3
+ 38.8016ms,0.0V 38.8199ms,0.0
+ 38.8200ms,3.3V 38.8215ms,3.3
+ 38.8216ms,0.0V 38.8399ms,0.0
+ 38.8400ms,3.3V 38.8415ms,3.3
+ 38.8416ms,0.0V 38.8599ms,0.0
+ 38.8600ms,3.3V 38.8615ms,3.3
+ 38.8616ms,0.0V 38.8799ms,0.0
+ 38.8800ms,3.3V 38.8815ms,3.3
+ 38.8816ms,0.0V 38.8999ms,0.0
+ 38.9000ms,3.3V 38.9015ms,3.3
+ 38.9016ms,0.0V 38.9199ms,0.0
+ 38.9200ms,3.3V 38.9215ms,3.3
+ 38.9216ms,0.0V 38.9399ms,0.0
+ 38.9400ms,3.3V 38.9415ms,3.3
+ 38.9416ms,0.0V 38.9599ms,0.0
+ 38.9600ms,3.3V 38.9615ms,3.3
+ 38.9616ms,0.0V 38.9799ms,0.0
+ 38.9800ms,3.3V 38.9815ms,3.3
+ 38.9816ms,0.0V 38.9999ms,0.0
+ 39.0000ms,3.3V 39.0015ms,3.3
+ 39.0016ms,0.0V 39.0199ms,0.0
+ 39.0200ms,3.3V 39.0215ms,3.3
+ 39.0216ms,0.0V 39.0399ms,0.0
+ 39.0400ms,3.3V 39.0415ms,3.3
+ 39.0416ms,0.0V 39.0599ms,0.0
+ 39.0600ms,3.3V 39.0615ms,3.3
+ 39.0616ms,0.0V 39.0799ms,0.0
+ 39.0800ms,3.3V 39.0815ms,3.3
+ 39.0816ms,0.0V 39.0999ms,0.0
+ 39.1000ms,3.3V 39.1015ms,3.3
+ 39.1016ms,0.0V 39.1199ms,0.0
+ 39.1200ms,3.3V 39.1215ms,3.3
+ 39.1216ms,0.0V 39.1399ms,0.0
+ 39.1400ms,3.3V 39.1415ms,3.3
+ 39.1416ms,0.0V 39.1599ms,0.0
+ 39.1600ms,3.3V 39.1615ms,3.3
+ 39.1616ms,0.0V 39.1799ms,0.0
+ 39.1800ms,3.3V 39.1815ms,3.3
+ 39.1816ms,0.0V 39.1999ms,0.0
+ 39.2000ms,3.3V 39.2015ms,3.3
+ 39.2016ms,0.0V 39.2199ms,0.0
+ 39.2200ms,3.3V 39.2215ms,3.3
+ 39.2216ms,0.0V 39.2399ms,0.0
+ 39.2400ms,3.3V 39.2415ms,3.3
+ 39.2416ms,0.0V 39.2599ms,0.0
+ 39.2600ms,3.3V 39.2615ms,3.3
+ 39.2616ms,0.0V 39.2799ms,0.0
+ 39.2800ms,3.3V 39.2815ms,3.3
+ 39.2816ms,0.0V 39.2999ms,0.0
+ 39.3000ms,3.3V 39.3015ms,3.3
+ 39.3016ms,0.0V 39.3199ms,0.0
+ 39.3200ms,3.3V 39.3215ms,3.3
+ 39.3216ms,0.0V 39.3399ms,0.0
+ 39.3400ms,3.3V 39.3415ms,3.3
+ 39.3416ms,0.0V 39.3599ms,0.0
+ 39.3600ms,3.3V 39.3615ms,3.3
+ 39.3616ms,0.0V 39.3799ms,0.0
+ 39.3800ms,3.3V 39.3815ms,3.3
+ 39.3816ms,0.0V 39.3999ms,0.0
+ 39.4000ms,3.3V 39.4015ms,3.3
+ 39.4016ms,0.0V 39.4199ms,0.0
+ 39.4200ms,3.3V 39.4215ms,3.3
+ 39.4216ms,0.0V 39.4399ms,0.0
+ 39.4400ms,3.3V 39.4415ms,3.3
+ 39.4416ms,0.0V 39.4599ms,0.0
+ 39.4600ms,3.3V 39.4615ms,3.3
+ 39.4616ms,0.0V 39.4799ms,0.0
+ 39.4800ms,3.3V 39.4815ms,3.3
+ 39.4816ms,0.0V 39.4999ms,0.0
+ 39.5000ms,3.3V 39.5015ms,3.3
+ 39.5016ms,0.0V 39.5199ms,0.0
+ 39.5200ms,3.3V 39.5215ms,3.3
+ 39.5216ms,0.0V 39.5399ms,0.0
+ 39.5400ms,3.3V 39.5415ms,3.3
+ 39.5416ms,0.0V 39.5599ms,0.0
+ 39.5600ms,3.3V 39.5615ms,3.3
+ 39.5616ms,0.0V 39.5799ms,0.0
+ 39.5800ms,3.3V 39.5815ms,3.3
+ 39.5816ms,0.0V 39.5999ms,0.0
+ 39.6000ms,3.3V 39.6015ms,3.3
+ 39.6016ms,0.0V 39.6199ms,0.0
+ 39.6200ms,3.3V 39.6215ms,3.3
+ 39.6216ms,0.0V 39.6399ms,0.0
+ 39.6400ms,3.3V 39.6415ms,3.3
+ 39.6416ms,0.0V 39.6599ms,0.0
+ 39.6600ms,3.3V 39.6615ms,3.3
+ 39.6616ms,0.0V 39.6799ms,0.0
+ 39.6800ms,3.3V 39.6815ms,3.3
+ 39.6816ms,0.0V 39.6999ms,0.0
+ 39.7000ms,3.3V 39.7015ms,3.3
+ 39.7016ms,0.0V 39.7199ms,0.0
+ 39.7200ms,3.3V 39.7215ms,3.3
+ 39.7216ms,0.0V 39.7399ms,0.0
+ 39.7400ms,3.3V 39.7415ms,3.3
+ 39.7416ms,0.0V 39.7599ms,0.0
+ 39.7600ms,3.3V 39.7615ms,3.3
+ 39.7616ms,0.0V 39.7799ms,0.0
+ 39.7800ms,3.3V 39.7815ms,3.3
+ 39.7816ms,0.0V 39.7999ms,0.0
+ 39.8000ms,3.3V 39.8015ms,3.3
+ 39.8016ms,0.0V 39.8199ms,0.0
+ 39.8200ms,3.3V 39.8215ms,3.3
+ 39.8216ms,0.0V 39.8399ms,0.0
+ 39.8400ms,3.3V 39.8415ms,3.3
+ 39.8416ms,0.0V 39.8599ms,0.0
+ 39.8600ms,3.3V 39.8615ms,3.3
+ 39.8616ms,0.0V 39.8799ms,0.0
+ 39.8800ms,3.3V 39.8815ms,3.3
+ 39.8816ms,0.0V 39.8999ms,0.0
+ 39.9000ms,3.3V 39.9015ms,3.3
+ 39.9016ms,0.0V 39.9199ms,0.0
+ 39.9200ms,3.3V 39.9215ms,3.3
+ 39.9216ms,0.0V 39.9399ms,0.0
+ 39.9400ms,3.3V 39.9415ms,3.3
+ 39.9416ms,0.0V 39.9599ms,0.0
+ 39.9600ms,3.3V 39.9615ms,3.3
+ 39.9616ms,0.0V 39.9799ms,0.0
+ 39.9800ms,3.3V 39.9815ms,3.3
+ 39.9816ms,0.0V 39.9999ms,0.0
+ 40.0000ms,3.3V 40.0015ms,3.3
+ 40.0016ms,0.0V 40.0199ms,0.0
+ 40.0200ms,3.3V 40.0215ms,3.3
+ 40.0216ms,0.0V 40.0399ms,0.0
+ 40.0400ms,3.3V 40.0415ms,3.3
+ 40.0416ms,0.0V 40.0599ms,0.0
+ 40.0600ms,3.3V 40.0615ms,3.3
+ 40.0616ms,0.0V 40.0799ms,0.0
+ 40.0800ms,3.3V 40.0815ms,3.3
+ 40.0816ms,0.0V 40.0999ms,0.0
+ 40.1000ms,3.3V 40.1015ms,3.3
+ 40.1016ms,0.0V 40.1199ms,0.0
+ 40.1200ms,3.3V 40.1217ms,3.3
+ 40.1218ms,0.0V 40.1399ms,0.0
+ 40.1400ms,3.3V 40.1417ms,3.3
+ 40.1418ms,0.0V 40.1599ms,0.0
+ 40.1600ms,3.3V 40.1617ms,3.3
+ 40.1618ms,0.0V 40.1799ms,0.0
+ 40.1800ms,3.3V 40.1817ms,3.3
+ 40.1818ms,0.0V 40.1999ms,0.0
+ 40.2000ms,3.3V 40.2017ms,3.3
+ 40.2018ms,0.0V 40.2199ms,0.0
+ 40.2200ms,3.3V 40.2217ms,3.3
+ 40.2218ms,0.0V 40.2399ms,0.0
+ 40.2400ms,3.3V 40.2417ms,3.3
+ 40.2418ms,0.0V 40.2599ms,0.0
+ 40.2600ms,3.3V 40.2617ms,3.3
+ 40.2618ms,0.0V 40.2799ms,0.0
+ 40.2800ms,3.3V 40.2817ms,3.3
+ 40.2818ms,0.0V 40.2999ms,0.0
+ 40.3000ms,3.3V 40.3017ms,3.3
+ 40.3018ms,0.0V 40.3199ms,0.0
+ 40.3200ms,3.3V 40.3217ms,3.3
+ 40.3218ms,0.0V 40.3399ms,0.0
+ 40.3400ms,3.3V 40.3417ms,3.3
+ 40.3418ms,0.0V 40.3599ms,0.0
+ 40.3600ms,3.3V 40.3617ms,3.3
+ 40.3618ms,0.0V 40.3799ms,0.0
+ 40.3800ms,3.3V 40.3817ms,3.3
+ 40.3818ms,0.0V 40.3999ms,0.0
+ 40.4000ms,3.3V 40.4017ms,3.3
+ 40.4018ms,0.0V 40.4199ms,0.0
+ 40.4200ms,3.3V 40.4217ms,3.3
+ 40.4218ms,0.0V 40.4399ms,0.0
+ 40.4400ms,3.3V 40.4417ms,3.3
+ 40.4418ms,0.0V 40.4599ms,0.0
+ 40.4600ms,3.3V 40.4617ms,3.3
+ 40.4618ms,0.0V 40.4799ms,0.0
+ 40.4800ms,3.3V 40.4817ms,3.3
+ 40.4818ms,0.0V 40.4999ms,0.0
+ 40.5000ms,3.3V 40.5017ms,3.3
+ 40.5018ms,0.0V 40.5199ms,0.0
+ 40.5200ms,3.3V 40.5217ms,3.3
+ 40.5218ms,0.0V 40.5399ms,0.0
+ 40.5400ms,3.3V 40.5417ms,3.3
+ 40.5418ms,0.0V 40.5599ms,0.0
+ 40.5600ms,3.3V 40.5617ms,3.3
+ 40.5618ms,0.0V 40.5799ms,0.0
+ 40.5800ms,3.3V 40.5817ms,3.3
+ 40.5818ms,0.0V 40.5999ms,0.0
+ 40.6000ms,3.3V 40.6017ms,3.3
+ 40.6018ms,0.0V 40.6199ms,0.0
+ 40.6200ms,3.3V 40.6217ms,3.3
+ 40.6218ms,0.0V 40.6399ms,0.0
+ 40.6400ms,3.3V 40.6417ms,3.3
+ 40.6418ms,0.0V 40.6599ms,0.0
+ 40.6600ms,3.3V 40.6617ms,3.3
+ 40.6618ms,0.0V 40.6799ms,0.0
+ 40.6800ms,3.3V 40.6817ms,3.3
+ 40.6818ms,0.0V 40.6999ms,0.0
+ 40.7000ms,3.3V 40.7017ms,3.3
+ 40.7018ms,0.0V 40.7199ms,0.0
+ 40.7200ms,3.3V 40.7217ms,3.3
+ 40.7218ms,0.0V 40.7399ms,0.0
+ 40.7400ms,3.3V 40.7417ms,3.3
+ 40.7418ms,0.0V 40.7599ms,0.0
+ 40.7600ms,3.3V 40.7617ms,3.3
+ 40.7618ms,0.0V 40.7799ms,0.0
+ 40.7800ms,3.3V 40.7817ms,3.3
+ 40.7818ms,0.0V 40.7999ms,0.0
+ 40.8000ms,3.3V 40.8017ms,3.3
+ 40.8018ms,0.0V 40.8199ms,0.0
+ 40.8200ms,3.3V 40.8217ms,3.3
+ 40.8218ms,0.0V 40.8399ms,0.0
+ 40.8400ms,3.3V 40.8417ms,3.3
+ 40.8418ms,0.0V 40.8599ms,0.0
+ 40.8600ms,3.3V 40.8617ms,3.3
+ 40.8618ms,0.0V 40.8799ms,0.0
+ 40.8800ms,3.3V 40.8817ms,3.3
+ 40.8818ms,0.0V 40.8999ms,0.0
+ 40.9000ms,3.3V 40.9017ms,3.3
+ 40.9018ms,0.0V 40.9199ms,0.0
+ 40.9200ms,3.3V 40.9217ms,3.3
+ 40.9218ms,0.0V 40.9399ms,0.0
+ 40.9400ms,3.3V 40.9417ms,3.3
+ 40.9418ms,0.0V 40.9599ms,0.0
+ 40.9600ms,3.3V 40.9617ms,3.3
+ 40.9618ms,0.0V 40.9799ms,0.0
+ 40.9800ms,3.3V 40.9817ms,3.3
+ 40.9818ms,0.0V 40.9999ms,0.0
+ 41.0000ms,3.3V 41.0017ms,3.3
+ 41.0018ms,0.0V 41.0199ms,0.0
+ 41.0200ms,3.3V 41.0217ms,3.3
+ 41.0218ms,0.0V 41.0399ms,0.0
+ 41.0400ms,3.3V 41.0417ms,3.3
+ 41.0418ms,0.0V 41.0599ms,0.0
+ 41.0600ms,3.3V 41.0617ms,3.3
+ 41.0618ms,0.0V 41.0799ms,0.0
+ 41.0800ms,3.3V 41.0817ms,3.3
+ 41.0818ms,0.0V 41.0999ms,0.0
+ 41.1000ms,3.3V 41.1017ms,3.3
+ 41.1018ms,0.0V 41.1199ms,0.0
+ 41.1200ms,3.3V 41.1217ms,3.3
+ 41.1218ms,0.0V 41.1399ms,0.0
+ 41.1400ms,3.3V 41.1417ms,3.3
+ 41.1418ms,0.0V 41.1599ms,0.0
+ 41.1600ms,3.3V 41.1617ms,3.3
+ 41.1618ms,0.0V 41.1799ms,0.0
+ 41.1800ms,3.3V 41.1817ms,3.3
+ 41.1818ms,0.0V 41.1999ms,0.0
+ 41.2000ms,3.3V 41.2017ms,3.3
+ 41.2018ms,0.0V 41.2199ms,0.0
+ 41.2200ms,3.3V 41.2217ms,3.3
+ 41.2218ms,0.0V 41.2399ms,0.0
+ 41.2400ms,3.3V 41.2417ms,3.3
+ 41.2418ms,0.0V 41.2599ms,0.0
+ 41.2600ms,3.3V 41.2617ms,3.3
+ 41.2618ms,0.0V 41.2799ms,0.0
+ 41.2800ms,3.3V 41.2817ms,3.3
+ 41.2818ms,0.0V 41.2999ms,0.0
+ 41.3000ms,3.3V 41.3017ms,3.3
+ 41.3018ms,0.0V 41.3199ms,0.0
+ 41.3200ms,3.3V 41.3217ms,3.3
+ 41.3218ms,0.0V 41.3399ms,0.0
+ 41.3400ms,3.3V 41.3417ms,3.3
+ 41.3418ms,0.0V 41.3599ms,0.0
+ 41.3600ms,3.3V 41.3617ms,3.3
+ 41.3618ms,0.0V 41.3799ms,0.0
+ 41.3800ms,3.3V 41.3817ms,3.3
+ 41.3818ms,0.0V 41.3999ms,0.0
+ 41.4000ms,3.3V 41.4017ms,3.3
+ 41.4018ms,0.0V 41.4199ms,0.0
+ 41.4200ms,3.3V 41.4217ms,3.3
+ 41.4218ms,0.0V 41.4399ms,0.0
+ 41.4400ms,3.3V 41.4417ms,3.3
+ 41.4418ms,0.0V 41.4599ms,0.0
+ 41.4600ms,3.3V 41.4617ms,3.3
+ 41.4618ms,0.0V 41.4799ms,0.0
+ 41.4800ms,3.3V 41.4817ms,3.3
+ 41.4818ms,0.0V 41.4999ms,0.0
+ 41.5000ms,3.3V 41.5017ms,3.3
+ 41.5018ms,0.0V 41.5199ms,0.0
+ 41.5200ms,3.3V 41.5217ms,3.3
+ 41.5218ms,0.0V 41.5399ms,0.0
+ 41.5400ms,3.3V 41.5417ms,3.3
+ 41.5418ms,0.0V 41.5599ms,0.0
+ 41.5600ms,3.3V 41.5617ms,3.3
+ 41.5618ms,0.0V 41.5799ms,0.0
+ 41.5800ms,3.3V 41.5817ms,3.3
+ 41.5818ms,0.0V 41.5999ms,0.0
+ 41.6000ms,3.3V 41.6017ms,3.3
+ 41.6018ms,0.0V 41.6199ms,0.0
+ 41.6200ms,3.3V 41.6217ms,3.3
+ 41.6218ms,0.0V 41.6399ms,0.0
+ 41.6400ms,3.3V 41.6417ms,3.3
+ 41.6418ms,0.0V 41.6599ms,0.0
+ 41.6600ms,3.3V 41.6617ms,3.3
+ 41.6618ms,0.0V 41.6799ms,0.0
+ 41.6800ms,3.3V 41.6817ms,3.3
+ 41.6818ms,0.0V 41.6999ms,0.0
+ 41.7000ms,3.3V 41.7017ms,3.3
+ 41.7018ms,0.0V 41.7199ms,0.0
+ 41.7200ms,3.3V 41.7217ms,3.3
+ 41.7218ms,0.0V 41.7399ms,0.0
+ 41.7400ms,3.3V 41.7417ms,3.3
+ 41.7418ms,0.0V 41.7599ms,0.0
+ 41.7600ms,3.3V 41.7617ms,3.3
+ 41.7618ms,0.0V 41.7799ms,0.0
+ 41.7800ms,3.3V 41.7817ms,3.3
+ 41.7818ms,0.0V 41.7999ms,0.0
+ 41.8000ms,3.3V 41.8017ms,3.3
+ 41.8018ms,0.0V 41.8199ms,0.0
+ 41.8200ms,3.3V 41.8217ms,3.3
+ 41.8218ms,0.0V 41.8399ms,0.0
+ 41.8400ms,3.3V 41.8417ms,3.3
+ 41.8418ms,0.0V 41.8599ms,0.0
+ 41.8600ms,3.3V 41.8617ms,3.3
+ 41.8618ms,0.0V 41.8799ms,0.0
+ 41.8800ms,3.3V 41.8817ms,3.3
+ 41.8818ms,0.0V 41.8999ms,0.0
+ 41.9000ms,3.3V 41.9017ms,3.3
+ 41.9018ms,0.0V 41.9199ms,0.0
+ 41.9200ms,3.3V 41.9217ms,3.3
+ 41.9218ms,0.0V 41.9399ms,0.0
+ 41.9400ms,3.3V 41.9417ms,3.3
+ 41.9418ms,0.0V 41.9599ms,0.0
+ 41.9600ms,3.3V 41.9617ms,3.3
+ 41.9618ms,0.0V 41.9799ms,0.0
+ 41.9800ms,3.3V 41.9817ms,3.3
+ 41.9818ms,0.0V 41.9999ms,0.0
+ 42.0000ms,3.3V 42.0017ms,3.3
+ 42.0018ms,0.0V 42.0199ms,0.0
+ 42.0200ms,3.3V 42.0217ms,3.3
+ 42.0218ms,0.0V 42.0399ms,0.0
+ 42.0400ms,3.3V 42.0417ms,3.3
+ 42.0418ms,0.0V 42.0599ms,0.0
+ 42.0600ms,3.3V 42.0617ms,3.3
+ 42.0618ms,0.0V 42.0799ms,0.0
+ 42.0800ms,3.3V 42.0817ms,3.3
+ 42.0818ms,0.0V 42.0999ms,0.0
+ 42.1000ms,3.3V 42.1017ms,3.3
+ 42.1018ms,0.0V 42.1199ms,0.0
+ 42.1200ms,3.3V 42.1217ms,3.3
+ 42.1218ms,0.0V 42.1399ms,0.0
+ 42.1400ms,3.3V 42.1417ms,3.3
+ 42.1418ms,0.0V 42.1599ms,0.0
+ 42.1600ms,3.3V 42.1617ms,3.3
+ 42.1618ms,0.0V 42.1799ms,0.0
+ 42.1800ms,3.3V 42.1817ms,3.3
+ 42.1818ms,0.0V 42.1999ms,0.0
+ 42.2000ms,3.3V 42.2017ms,3.3
+ 42.2018ms,0.0V 42.2199ms,0.0
+ 42.2200ms,3.3V 42.2217ms,3.3
+ 42.2218ms,0.0V 42.2399ms,0.0
+ 42.2400ms,3.3V 42.2417ms,3.3
+ 42.2418ms,0.0V 42.2599ms,0.0
+ 42.2600ms,3.3V 42.2617ms,3.3
+ 42.2618ms,0.0V 42.2799ms,0.0
+ 42.2800ms,3.3V 42.2817ms,3.3
+ 42.2818ms,0.0V 42.2999ms,0.0
+ 42.3000ms,3.3V 42.3017ms,3.3
+ 42.3018ms,0.0V 42.3199ms,0.0
+ 42.3200ms,3.3V 42.3217ms,3.3
+ 42.3218ms,0.0V 42.3399ms,0.0
+ 42.3400ms,3.3V 42.3417ms,3.3
+ 42.3418ms,0.0V 42.3599ms,0.0
+ 42.3600ms,3.3V 42.3617ms,3.3
+ 42.3618ms,0.0V 42.3799ms,0.0
+ 42.3800ms,3.3V 42.3817ms,3.3
+ 42.3818ms,0.0V 42.3999ms,0.0
+ 42.4000ms,3.3V 42.4017ms,3.3
+ 42.4018ms,0.0V 42.4199ms,0.0
+ 42.4200ms,3.3V 42.4217ms,3.3
+ 42.4218ms,0.0V 42.4399ms,0.0
+ 42.4400ms,3.3V 42.4417ms,3.3
+ 42.4418ms,0.0V 42.4599ms,0.0
+ 42.4600ms,3.3V 42.4617ms,3.3
+ 42.4618ms,0.0V 42.4799ms,0.0
+ 42.4800ms,3.3V 42.4817ms,3.3
+ 42.4818ms,0.0V 42.4999ms,0.0
+ 42.5000ms,3.3V 42.5017ms,3.3
+ 42.5018ms,0.0V 42.5199ms,0.0
+ 42.5200ms,3.3V 42.5217ms,3.3
+ 42.5218ms,0.0V 42.5399ms,0.0
+ 42.5400ms,3.3V 42.5417ms,3.3
+ 42.5418ms,0.0V 42.5599ms,0.0
+ 42.5600ms,3.3V 42.5617ms,3.3
+ 42.5618ms,0.0V 42.5799ms,0.0
+ 42.5800ms,3.3V 42.5817ms,3.3
+ 42.5818ms,0.0V 42.5999ms,0.0
+ 42.6000ms,3.3V 42.6017ms,3.3
+ 42.6018ms,0.0V 42.6199ms,0.0
+ 42.6200ms,3.3V 42.6217ms,3.3
+ 42.6218ms,0.0V 42.6399ms,0.0
+ 42.6400ms,3.3V 42.6417ms,3.3
+ 42.6418ms,0.0V 42.6599ms,0.0
+ 42.6600ms,3.3V 42.6617ms,3.3
+ 42.6618ms,0.0V 42.6799ms,0.0
+ 42.6800ms,3.3V 42.6817ms,3.3
+ 42.6818ms,0.0V 42.6999ms,0.0
+ 42.7000ms,3.3V 42.7017ms,3.3
+ 42.7018ms,0.0V 42.7199ms,0.0
+ 42.7200ms,3.3V 42.7217ms,3.3
+ 42.7218ms,0.0V 42.7399ms,0.0
+ 42.7400ms,3.3V 42.7417ms,3.3
+ 42.7418ms,0.0V 42.7599ms,0.0
+ 42.7600ms,3.3V 42.7617ms,3.3
+ 42.7618ms,0.0V 42.7799ms,0.0
+ 42.7800ms,3.3V 42.7817ms,3.3
+ 42.7818ms,0.0V 42.7999ms,0.0
+ 42.8000ms,3.3V 42.8017ms,3.3
+ 42.8018ms,0.0V 42.8199ms,0.0
+ 42.8200ms,3.3V 42.8217ms,3.3
+ 42.8218ms,0.0V 42.8399ms,0.0
+ 42.8400ms,3.3V 42.8417ms,3.3
+ 42.8418ms,0.0V 42.8599ms,0.0
+ 42.8600ms,3.3V 42.8617ms,3.3
+ 42.8618ms,0.0V 42.8799ms,0.0
+ 42.8800ms,3.3V 42.8817ms,3.3
+ 42.8818ms,0.0V 42.8999ms,0.0
+ 42.9000ms,3.3V 42.9017ms,3.3
+ 42.9018ms,0.0V 42.9199ms,0.0
+ 42.9200ms,3.3V 42.9217ms,3.3
+ 42.9218ms,0.0V 42.9399ms,0.0
+ 42.9400ms,3.3V 42.9417ms,3.3
+ 42.9418ms,0.0V 42.9599ms,0.0
+ 42.9600ms,3.3V 42.9617ms,3.3
+ 42.9618ms,0.0V 42.9799ms,0.0
+ 42.9800ms,3.3V 42.9817ms,3.3
+ 42.9818ms,0.0V 42.9999ms,0.0
+ 43.0000ms,3.3V 43.0017ms,3.3
+ 43.0018ms,0.0V 43.0199ms,0.0
+ 43.0200ms,3.3V 43.0217ms,3.3
+ 43.0218ms,0.0V 43.0399ms,0.0
+ 43.0400ms,3.3V 43.0417ms,3.3
+ 43.0418ms,0.0V 43.0599ms,0.0
+ 43.0600ms,3.3V 43.0617ms,3.3
+ 43.0618ms,0.0V 43.0799ms,0.0
+ 43.0800ms,3.3V 43.0817ms,3.3
+ 43.0818ms,0.0V 43.0999ms,0.0
+ 43.1000ms,3.3V 43.1017ms,3.3
+ 43.1018ms,0.0V 43.1199ms,0.0
+ 43.1200ms,3.3V 43.1217ms,3.3
+ 43.1218ms,0.0V 43.1399ms,0.0
+ 43.1400ms,3.3V 43.1417ms,3.3
+ 43.1418ms,0.0V 43.1599ms,0.0
+ 43.1600ms,3.3V 43.1617ms,3.3
+ 43.1618ms,0.0V 43.1799ms,0.0
+ 43.1800ms,3.3V 43.1817ms,3.3
+ 43.1818ms,0.0V 43.1999ms,0.0
+ 43.2000ms,3.3V 43.2017ms,3.3
+ 43.2018ms,0.0V 43.2199ms,0.0
+ 43.2200ms,3.3V 43.2217ms,3.3
+ 43.2218ms,0.0V 43.2399ms,0.0
+ 43.2400ms,3.3V 43.2417ms,3.3
+ 43.2418ms,0.0V 43.2599ms,0.0
+ 43.2600ms,3.3V 43.2617ms,3.3
+ 43.2618ms,0.0V 43.2799ms,0.0
+ 43.2800ms,3.3V 43.2817ms,3.3
+ 43.2818ms,0.0V 43.2999ms,0.0
+ 43.3000ms,3.3V 43.3017ms,3.3
+ 43.3018ms,0.0V 43.3199ms,0.0
+ 43.3200ms,3.3V 43.3217ms,3.3
+ 43.3218ms,0.0V 43.3399ms,0.0
+ 43.3400ms,3.3V 43.3417ms,3.3
+ 43.3418ms,0.0V 43.3599ms,0.0
+ 43.3600ms,3.3V 43.3617ms,3.3
+ 43.3618ms,0.0V 43.3799ms,0.0
+ 43.3800ms,3.3V 43.3817ms,3.3
+ 43.3818ms,0.0V 43.3999ms,0.0
+ 43.4000ms,3.3V 43.4017ms,3.3
+ 43.4018ms,0.0V 43.4199ms,0.0
+ 43.4200ms,3.3V 43.4217ms,3.3
+ 43.4218ms,0.0V 43.4399ms,0.0
+ 43.4400ms,3.3V 43.4417ms,3.3
+ 43.4418ms,0.0V 43.4599ms,0.0
+ 43.4600ms,3.3V 43.4617ms,3.3
+ 43.4618ms,0.0V 43.4799ms,0.0
+ 43.4800ms,3.3V 43.4817ms,3.3
+ 43.4818ms,0.0V 43.4999ms,0.0
+ 43.5000ms,3.3V 43.5017ms,3.3
+ 43.5018ms,0.0V 43.5199ms,0.0
+ 43.5200ms,3.3V 43.5217ms,3.3
+ 43.5218ms,0.0V 43.5399ms,0.0
+ 43.5400ms,3.3V 43.5417ms,3.3
+ 43.5418ms,0.0V 43.5599ms,0.0
+ 43.5600ms,3.3V 43.5617ms,3.3
+ 43.5618ms,0.0V 43.5799ms,0.0
+ 43.5800ms,3.3V 43.5817ms,3.3
+ 43.5818ms,0.0V 43.5999ms,0.0
+ 43.6000ms,3.3V 43.6017ms,3.3
+ 43.6018ms,0.0V 43.6199ms,0.0
+ 43.6200ms,3.3V 43.6217ms,3.3
+ 43.6218ms,0.0V 43.6399ms,0.0
+ 43.6400ms,3.3V 43.6417ms,3.3
+ 43.6418ms,0.0V 43.6599ms,0.0
+ 43.6600ms,3.3V 43.6617ms,3.3
+ 43.6618ms,0.0V 43.6799ms,0.0
+ 43.6800ms,3.3V 43.6817ms,3.3
+ 43.6818ms,0.0V 43.6999ms,0.0
+ 43.7000ms,3.3V 43.7017ms,3.3
+ 43.7018ms,0.0V 43.7199ms,0.0
+ 43.7200ms,3.3V 43.7217ms,3.3
+ 43.7218ms,0.0V 43.7399ms,0.0
+ 43.7400ms,3.3V 43.7417ms,3.3
+ 43.7418ms,0.0V 43.7599ms,0.0
+ 43.7600ms,3.3V 43.7617ms,3.3
+ 43.7618ms,0.0V 43.7799ms,0.0
+ 43.7800ms,3.3V 43.7817ms,3.3
+ 43.7818ms,0.0V 43.7999ms,0.0
+ 43.8000ms,3.3V 43.8017ms,3.3
+ 43.8018ms,0.0V 43.8199ms,0.0
+ 43.8200ms,3.3V 43.8217ms,3.3
+ 43.8218ms,0.0V 43.8399ms,0.0
+ 43.8400ms,3.3V 43.8417ms,3.3
+ 43.8418ms,0.0V 43.8599ms,0.0
+ 43.8600ms,3.3V 43.8617ms,3.3
+ 43.8618ms,0.0V 43.8799ms,0.0
+ 43.8800ms,3.3V 43.8817ms,3.3
+ 43.8818ms,0.0V 43.8999ms,0.0
+ 43.9000ms,3.3V 43.9017ms,3.3
+ 43.9018ms,0.0V 43.9199ms,0.0
+ 43.9200ms,3.3V 43.9217ms,3.3
+ 43.9218ms,0.0V 43.9399ms,0.0
+ 43.9400ms,3.3V 43.9417ms,3.3
+ 43.9418ms,0.0V 43.9599ms,0.0
+ 43.9600ms,3.3V 43.9617ms,3.3
+ 43.9618ms,0.0V 43.9799ms,0.0
+ 43.9800ms,3.3V 43.9817ms,3.3
+ 43.9818ms,0.0V 43.9999ms,0.0
+ 44.0000ms,3.3V 44.0017ms,3.3
+ 44.0018ms,0.0V 44.0199ms,0.0
+ 44.0200ms,3.3V 44.0217ms,3.3
+ 44.0218ms,0.0V 44.0399ms,0.0
+ 44.0400ms,3.3V 44.0417ms,3.3
+ 44.0418ms,0.0V 44.0599ms,0.0
+ 44.0600ms,3.3V 44.0617ms,3.3
+ 44.0618ms,0.0V 44.0799ms,0.0
+ 44.0800ms,3.3V 44.0817ms,3.3
+ 44.0818ms,0.0V 44.0999ms,0.0
+ 44.1000ms,3.3V 44.1017ms,3.3
+ 44.1018ms,0.0V 44.1199ms,0.0
+ 44.1200ms,3.3V 44.1217ms,3.3
+ 44.1218ms,0.0V 44.1399ms,0.0
+ 44.1400ms,3.3V 44.1417ms,3.3
+ 44.1418ms,0.0V 44.1599ms,0.0
+ 44.1600ms,3.3V 44.1617ms,3.3
+ 44.1618ms,0.0V 44.1799ms,0.0
+ 44.1800ms,3.3V 44.1817ms,3.3
+ 44.1818ms,0.0V 44.1999ms,0.0
+ 44.2000ms,3.3V 44.2017ms,3.3
+ 44.2018ms,0.0V 44.2199ms,0.0
+ 44.2200ms,3.3V 44.2217ms,3.3
+ 44.2218ms,0.0V 44.2399ms,0.0
+ 44.2400ms,3.3V 44.2417ms,3.3
+ 44.2418ms,0.0V 44.2599ms,0.0
+ 44.2600ms,3.3V 44.2617ms,3.3
+ 44.2618ms,0.0V 44.2799ms,0.0
+ 44.2800ms,3.3V 44.2817ms,3.3
+ 44.2818ms,0.0V 44.2999ms,0.0
+ 44.3000ms,3.3V 44.3017ms,3.3
+ 44.3018ms,0.0V 44.3199ms,0.0
+ 44.3200ms,3.3V 44.3217ms,3.3
+ 44.3218ms,0.0V 44.3399ms,0.0
+ 44.3400ms,3.3V 44.3417ms,3.3
+ 44.3418ms,0.0V 44.3599ms,0.0
+ 44.3600ms,3.3V 44.3617ms,3.3
+ 44.3618ms,0.0V 44.3799ms,0.0
+ 44.3800ms,3.3V 44.3817ms,3.3
+ 44.3818ms,0.0V 44.3999ms,0.0
+ 44.4000ms,3.3V 44.4017ms,3.3
+ 44.4018ms,0.0V 44.4199ms,0.0
+ 44.4200ms,3.3V 44.4217ms,3.3
+ 44.4218ms,0.0V 44.4399ms,0.0
+ 44.4400ms,3.3V 44.4417ms,3.3
+ 44.4418ms,0.0V 44.4599ms,0.0
+ 44.4600ms,3.3V 44.4617ms,3.3
+ 44.4618ms,0.0V 44.4799ms,0.0
+ 44.4800ms,3.3V 44.4817ms,3.3
+ 44.4818ms,0.0V 44.4999ms,0.0
+ 44.5000ms,3.3V 44.5017ms,3.3
+ 44.5018ms,0.0V 44.5199ms,0.0
+ 44.5200ms,3.3V 44.5217ms,3.3
+ 44.5218ms,0.0V 44.5399ms,0.0
+ 44.5400ms,3.3V 44.5417ms,3.3
+ 44.5418ms,0.0V 44.5599ms,0.0
+ 44.5600ms,3.3V 44.5617ms,3.3
+ 44.5618ms,0.0V 44.5799ms,0.0
+ 44.5800ms,3.3V 44.5817ms,3.3
+ 44.5818ms,0.0V 44.5999ms,0.0
+ 44.6000ms,3.3V 44.6017ms,3.3
+ 44.6018ms,0.0V 44.6199ms,0.0
+ 44.6200ms,3.3V 44.6217ms,3.3
+ 44.6218ms,0.0V 44.6399ms,0.0
+ 44.6400ms,3.3V 44.6417ms,3.3
+ 44.6418ms,0.0V 44.6599ms,0.0
+ 44.6600ms,3.3V 44.6617ms,3.3
+ 44.6618ms,0.0V 44.6799ms,0.0
+ 44.6800ms,3.3V 44.6817ms,3.3
+ 44.6818ms,0.0V 44.6999ms,0.0
+ 44.7000ms,3.3V 44.7017ms,3.3
+ 44.7018ms,0.0V 44.7199ms,0.0
+ 44.7200ms,3.3V 44.7217ms,3.3
+ 44.7218ms,0.0V 44.7399ms,0.0
+ 44.7400ms,3.3V 44.7417ms,3.3
+ 44.7418ms,0.0V 44.7599ms,0.0
+ 44.7600ms,3.3V 44.7617ms,3.3
+ 44.7618ms,0.0V 44.7799ms,0.0
+ 44.7800ms,3.3V 44.7817ms,3.3
+ 44.7818ms,0.0V 44.7999ms,0.0
+ 44.8000ms,3.3V 44.8017ms,3.3
+ 44.8018ms,0.0V 44.8199ms,0.0
+ 44.8200ms,3.3V 44.8217ms,3.3
+ 44.8218ms,0.0V 44.8399ms,0.0
+ 44.8400ms,3.3V 44.8417ms,3.3
+ 44.8418ms,0.0V 44.8599ms,0.0
+ 44.8600ms,3.3V 44.8617ms,3.3
+ 44.8618ms,0.0V 44.8799ms,0.0
+ 44.8800ms,3.3V 44.8817ms,3.3
+ 44.8818ms,0.0V 44.8999ms,0.0
+ 44.9000ms,3.3V 44.9017ms,3.3
+ 44.9018ms,0.0V 44.9199ms,0.0
+ 44.9200ms,3.3V 44.9217ms,3.3
+ 44.9218ms,0.0V 44.9399ms,0.0
+ 44.9400ms,3.3V 44.9417ms,3.3
+ 44.9418ms,0.0V 44.9599ms,0.0
+ 44.9600ms,3.3V 44.9617ms,3.3
+ 44.9618ms,0.0V 44.9799ms,0.0
+ 44.9800ms,3.3V 44.9817ms,3.3
+ 44.9818ms,0.0V 44.9999ms,0.0
+ 45.0000ms,3.3V 45.0017ms,3.3
+ 45.0018ms,0.0V 45.0199ms,0.0
+ 45.0200ms,3.3V 45.0217ms,3.3
+ 45.0218ms,0.0V 45.0399ms,0.0
+ 45.0400ms,3.3V 45.0417ms,3.3
+ 45.0418ms,0.0V 45.0599ms,0.0
+ 45.0600ms,3.3V 45.0617ms,3.3
+ 45.0618ms,0.0V 45.0799ms,0.0
+ 45.0800ms,3.3V 45.0817ms,3.3
+ 45.0818ms,0.0V 45.0999ms,0.0
+ 45.1000ms,3.3V 45.1017ms,3.3
+ 45.1018ms,0.0V 45.1199ms,0.0
+ 45.1200ms,3.3V 45.1219ms,3.3
+ 45.1220ms,0.0V 45.1399ms,0.0
+ 45.1400ms,3.3V 45.1419ms,3.3
+ 45.1420ms,0.0V 45.1599ms,0.0
+ 45.1600ms,3.3V 45.1619ms,3.3
+ 45.1620ms,0.0V 45.1799ms,0.0
+ 45.1800ms,3.3V 45.1819ms,3.3
+ 45.1820ms,0.0V 45.1999ms,0.0
+ 45.2000ms,3.3V 45.2019ms,3.3
+ 45.2020ms,0.0V 45.2199ms,0.0
+ 45.2200ms,3.3V 45.2219ms,3.3
+ 45.2220ms,0.0V 45.2399ms,0.0
+ 45.2400ms,3.3V 45.2419ms,3.3
+ 45.2420ms,0.0V 45.2599ms,0.0
+ 45.2600ms,3.3V 45.2619ms,3.3
+ 45.2620ms,0.0V 45.2799ms,0.0
+ 45.2800ms,3.3V 45.2819ms,3.3
+ 45.2820ms,0.0V 45.2999ms,0.0
+ 45.3000ms,3.3V 45.3019ms,3.3
+ 45.3020ms,0.0V 45.3199ms,0.0
+ 45.3200ms,3.3V 45.3219ms,3.3
+ 45.3220ms,0.0V 45.3399ms,0.0
+ 45.3400ms,3.3V 45.3419ms,3.3
+ 45.3420ms,0.0V 45.3599ms,0.0
+ 45.3600ms,3.3V 45.3619ms,3.3
+ 45.3620ms,0.0V 45.3799ms,0.0
+ 45.3800ms,3.3V 45.3819ms,3.3
+ 45.3820ms,0.0V 45.3999ms,0.0
+ 45.4000ms,3.3V 45.4019ms,3.3
+ 45.4020ms,0.0V 45.4199ms,0.0
+ 45.4200ms,3.3V 45.4219ms,3.3
+ 45.4220ms,0.0V 45.4399ms,0.0
+ 45.4400ms,3.3V 45.4419ms,3.3
+ 45.4420ms,0.0V 45.4599ms,0.0
+ 45.4600ms,3.3V 45.4619ms,3.3
+ 45.4620ms,0.0V 45.4799ms,0.0
+ 45.4800ms,3.3V 45.4819ms,3.3
+ 45.4820ms,0.0V 45.4999ms,0.0
+ 45.5000ms,3.3V 45.5019ms,3.3
+ 45.5020ms,0.0V 45.5199ms,0.0
+ 45.5200ms,3.3V 45.5219ms,3.3
+ 45.5220ms,0.0V 45.5399ms,0.0
+ 45.5400ms,3.3V 45.5419ms,3.3
+ 45.5420ms,0.0V 45.5599ms,0.0
+ 45.5600ms,3.3V 45.5619ms,3.3
+ 45.5620ms,0.0V 45.5799ms,0.0
+ 45.5800ms,3.3V 45.5819ms,3.3
+ 45.5820ms,0.0V 45.5999ms,0.0
+ 45.6000ms,3.3V 45.6019ms,3.3
+ 45.6020ms,0.0V 45.6199ms,0.0
+ 45.6200ms,3.3V 45.6219ms,3.3
+ 45.6220ms,0.0V 45.6399ms,0.0
+ 45.6400ms,3.3V 45.6419ms,3.3
+ 45.6420ms,0.0V 45.6599ms,0.0
+ 45.6600ms,3.3V 45.6619ms,3.3
+ 45.6620ms,0.0V 45.6799ms,0.0
+ 45.6800ms,3.3V 45.6819ms,3.3
+ 45.6820ms,0.0V 45.6999ms,0.0
+ 45.7000ms,3.3V 45.7019ms,3.3
+ 45.7020ms,0.0V 45.7199ms,0.0
+ 45.7200ms,3.3V 45.7219ms,3.3
+ 45.7220ms,0.0V 45.7399ms,0.0
+ 45.7400ms,3.3V 45.7419ms,3.3
+ 45.7420ms,0.0V 45.7599ms,0.0
+ 45.7600ms,3.3V 45.7619ms,3.3
+ 45.7620ms,0.0V 45.7799ms,0.0
+ 45.7800ms,3.3V 45.7819ms,3.3
+ 45.7820ms,0.0V 45.7999ms,0.0
+ 45.8000ms,3.3V 45.8019ms,3.3
+ 45.8020ms,0.0V 45.8199ms,0.0
+ 45.8200ms,3.3V 45.8219ms,3.3
+ 45.8220ms,0.0V 45.8399ms,0.0
+ 45.8400ms,3.3V 45.8419ms,3.3
+ 45.8420ms,0.0V 45.8599ms,0.0
+ 45.8600ms,3.3V 45.8619ms,3.3
+ 45.8620ms,0.0V 45.8799ms,0.0
+ 45.8800ms,3.3V 45.8819ms,3.3
+ 45.8820ms,0.0V 45.8999ms,0.0
+ 45.9000ms,3.3V 45.9019ms,3.3
+ 45.9020ms,0.0V 45.9199ms,0.0
+ 45.9200ms,3.3V 45.9219ms,3.3
+ 45.9220ms,0.0V 45.9399ms,0.0
+ 45.9400ms,3.3V 45.9419ms,3.3
+ 45.9420ms,0.0V 45.9599ms,0.0
+ 45.9600ms,3.3V 45.9619ms,3.3
+ 45.9620ms,0.0V 45.9799ms,0.0
+ 45.9800ms,3.3V 45.9819ms,3.3
+ 45.9820ms,0.0V 45.9999ms,0.0
+ 46.0000ms,3.3V 46.0019ms,3.3
+ 46.0020ms,0.0V 46.0199ms,0.0
+ 46.0200ms,3.3V 46.0219ms,3.3
+ 46.0220ms,0.0V 46.0399ms,0.0
+ 46.0400ms,3.3V 46.0419ms,3.3
+ 46.0420ms,0.0V 46.0599ms,0.0
+ 46.0600ms,3.3V 46.0619ms,3.3
+ 46.0620ms,0.0V 46.0799ms,0.0
+ 46.0800ms,3.3V 46.0819ms,3.3
+ 46.0820ms,0.0V 46.0999ms,0.0
+ 46.1000ms,3.3V 46.1019ms,3.3
+ 46.1020ms,0.0V 46.1199ms,0.0
+ 46.1200ms,3.3V 46.1219ms,3.3
+ 46.1220ms,0.0V 46.1399ms,0.0
+ 46.1400ms,3.3V 46.1419ms,3.3
+ 46.1420ms,0.0V 46.1599ms,0.0
+ 46.1600ms,3.3V 46.1619ms,3.3
+ 46.1620ms,0.0V 46.1799ms,0.0
+ 46.1800ms,3.3V 46.1819ms,3.3
+ 46.1820ms,0.0V 46.1999ms,0.0
+ 46.2000ms,3.3V 46.2019ms,3.3
+ 46.2020ms,0.0V 46.2199ms,0.0
+ 46.2200ms,3.3V 46.2219ms,3.3
+ 46.2220ms,0.0V 46.2399ms,0.0
+ 46.2400ms,3.3V 46.2419ms,3.3
+ 46.2420ms,0.0V 46.2599ms,0.0
+ 46.2600ms,3.3V 46.2619ms,3.3
+ 46.2620ms,0.0V 46.2799ms,0.0
+ 46.2800ms,3.3V 46.2819ms,3.3
+ 46.2820ms,0.0V 46.2999ms,0.0
+ 46.3000ms,3.3V 46.3019ms,3.3
+ 46.3020ms,0.0V 46.3199ms,0.0
+ 46.3200ms,3.3V 46.3219ms,3.3
+ 46.3220ms,0.0V 46.3399ms,0.0
+ 46.3400ms,3.3V 46.3419ms,3.3
+ 46.3420ms,0.0V 46.3599ms,0.0
+ 46.3600ms,3.3V 46.3619ms,3.3
+ 46.3620ms,0.0V 46.3799ms,0.0
+ 46.3800ms,3.3V 46.3819ms,3.3
+ 46.3820ms,0.0V 46.3999ms,0.0
+ 46.4000ms,3.3V 46.4019ms,3.3
+ 46.4020ms,0.0V 46.4199ms,0.0
+ 46.4200ms,3.3V 46.4219ms,3.3
+ 46.4220ms,0.0V 46.4399ms,0.0
+ 46.4400ms,3.3V 46.4419ms,3.3
+ 46.4420ms,0.0V 46.4599ms,0.0
+ 46.4600ms,3.3V 46.4619ms,3.3
+ 46.4620ms,0.0V 46.4799ms,0.0
+ 46.4800ms,3.3V 46.4819ms,3.3
+ 46.4820ms,0.0V 46.4999ms,0.0
+ 46.5000ms,3.3V 46.5019ms,3.3
+ 46.5020ms,0.0V 46.5199ms,0.0
+ 46.5200ms,3.3V 46.5219ms,3.3
+ 46.5220ms,0.0V 46.5399ms,0.0
+ 46.5400ms,3.3V 46.5419ms,3.3
+ 46.5420ms,0.0V 46.5599ms,0.0
+ 46.5600ms,3.3V 46.5619ms,3.3
+ 46.5620ms,0.0V 46.5799ms,0.0
+ 46.5800ms,3.3V 46.5819ms,3.3
+ 46.5820ms,0.0V 46.5999ms,0.0
+ 46.6000ms,3.3V 46.6019ms,3.3
+ 46.6020ms,0.0V 46.6199ms,0.0
+ 46.6200ms,3.3V 46.6219ms,3.3
+ 46.6220ms,0.0V 46.6399ms,0.0
+ 46.6400ms,3.3V 46.6419ms,3.3
+ 46.6420ms,0.0V 46.6599ms,0.0
+ 46.6600ms,3.3V 46.6619ms,3.3
+ 46.6620ms,0.0V 46.6799ms,0.0
+ 46.6800ms,3.3V 46.6819ms,3.3
+ 46.6820ms,0.0V 46.6999ms,0.0
+ 46.7000ms,3.3V 46.7019ms,3.3
+ 46.7020ms,0.0V 46.7199ms,0.0
+ 46.7200ms,3.3V 46.7219ms,3.3
+ 46.7220ms,0.0V 46.7399ms,0.0
+ 46.7400ms,3.3V 46.7419ms,3.3
+ 46.7420ms,0.0V 46.7599ms,0.0
+ 46.7600ms,3.3V 46.7619ms,3.3
+ 46.7620ms,0.0V 46.7799ms,0.0
+ 46.7800ms,3.3V 46.7819ms,3.3
+ 46.7820ms,0.0V 46.7999ms,0.0
+ 46.8000ms,3.3V 46.8019ms,3.3
+ 46.8020ms,0.0V 46.8199ms,0.0
+ 46.8200ms,3.3V 46.8219ms,3.3
+ 46.8220ms,0.0V 46.8399ms,0.0
+ 46.8400ms,3.3V 46.8419ms,3.3
+ 46.8420ms,0.0V 46.8599ms,0.0
+ 46.8600ms,3.3V 46.8619ms,3.3
+ 46.8620ms,0.0V 46.8799ms,0.0
+ 46.8800ms,3.3V 46.8819ms,3.3
+ 46.8820ms,0.0V 46.8999ms,0.0
+ 46.9000ms,3.3V 46.9019ms,3.3
+ 46.9020ms,0.0V 46.9199ms,0.0
+ 46.9200ms,3.3V 46.9219ms,3.3
+ 46.9220ms,0.0V 46.9399ms,0.0
+ 46.9400ms,3.3V 46.9419ms,3.3
+ 46.9420ms,0.0V 46.9599ms,0.0
+ 46.9600ms,3.3V 46.9619ms,3.3
+ 46.9620ms,0.0V 46.9799ms,0.0
+ 46.9800ms,3.3V 46.9819ms,3.3
+ 46.9820ms,0.0V 46.9999ms,0.0
+ 47.0000ms,3.3V 47.0019ms,3.3
+ 47.0020ms,0.0V 47.0199ms,0.0
+ 47.0200ms,3.3V 47.0219ms,3.3
+ 47.0220ms,0.0V 47.0399ms,0.0
+ 47.0400ms,3.3V 47.0419ms,3.3
+ 47.0420ms,0.0V 47.0599ms,0.0
+ 47.0600ms,3.3V 47.0619ms,3.3
+ 47.0620ms,0.0V 47.0799ms,0.0
+ 47.0800ms,3.3V 47.0819ms,3.3
+ 47.0820ms,0.0V 47.0999ms,0.0
+ 47.1000ms,3.3V 47.1019ms,3.3
+ 47.1020ms,0.0V 47.1199ms,0.0
+ 47.1200ms,3.3V 47.1219ms,3.3
+ 47.1220ms,0.0V 47.1399ms,0.0
+ 47.1400ms,3.3V 47.1419ms,3.3
+ 47.1420ms,0.0V 47.1599ms,0.0
+ 47.1600ms,3.3V 47.1619ms,3.3
+ 47.1620ms,0.0V 47.1799ms,0.0
+ 47.1800ms,3.3V 47.1819ms,3.3
+ 47.1820ms,0.0V 47.1999ms,0.0
+ 47.2000ms,3.3V 47.2019ms,3.3
+ 47.2020ms,0.0V 47.2199ms,0.0
+ 47.2200ms,3.3V 47.2219ms,3.3
+ 47.2220ms,0.0V 47.2399ms,0.0
+ 47.2400ms,3.3V 47.2419ms,3.3
+ 47.2420ms,0.0V 47.2599ms,0.0
+ 47.2600ms,3.3V 47.2619ms,3.3
+ 47.2620ms,0.0V 47.2799ms,0.0
+ 47.2800ms,3.3V 47.2819ms,3.3
+ 47.2820ms,0.0V 47.2999ms,0.0
+ 47.3000ms,3.3V 47.3019ms,3.3
+ 47.3020ms,0.0V 47.3199ms,0.0
+ 47.3200ms,3.3V 47.3219ms,3.3
+ 47.3220ms,0.0V 47.3399ms,0.0
+ 47.3400ms,3.3V 47.3419ms,3.3
+ 47.3420ms,0.0V 47.3599ms,0.0
+ 47.3600ms,3.3V 47.3619ms,3.3
+ 47.3620ms,0.0V 47.3799ms,0.0
+ 47.3800ms,3.3V 47.3819ms,3.3
+ 47.3820ms,0.0V 47.3999ms,0.0
+ 47.4000ms,3.3V 47.4019ms,3.3
+ 47.4020ms,0.0V 47.4199ms,0.0
+ 47.4200ms,3.3V 47.4219ms,3.3
+ 47.4220ms,0.0V 47.4399ms,0.0
+ 47.4400ms,3.3V 47.4419ms,3.3
+ 47.4420ms,0.0V 47.4599ms,0.0
+ 47.4600ms,3.3V 47.4619ms,3.3
+ 47.4620ms,0.0V 47.4799ms,0.0
+ 47.4800ms,3.3V 47.4819ms,3.3
+ 47.4820ms,0.0V 47.4999ms,0.0
+ 47.5000ms,3.3V 47.5019ms,3.3
+ 47.5020ms,0.0V 47.5199ms,0.0
+ 47.5200ms,3.3V 47.5219ms,3.3
+ 47.5220ms,0.0V 47.5399ms,0.0
+ 47.5400ms,3.3V 47.5419ms,3.3
+ 47.5420ms,0.0V 47.5599ms,0.0
+ 47.5600ms,3.3V 47.5619ms,3.3
+ 47.5620ms,0.0V 47.5799ms,0.0
+ 47.5800ms,3.3V 47.5819ms,3.3
+ 47.5820ms,0.0V 47.5999ms,0.0
+ 47.6000ms,3.3V 47.6019ms,3.3
+ 47.6020ms,0.0V 47.6199ms,0.0
+ 47.6200ms,3.3V 47.6219ms,3.3
+ 47.6220ms,0.0V 47.6399ms,0.0
+ 47.6400ms,3.3V 47.6419ms,3.3
+ 47.6420ms,0.0V 47.6599ms,0.0
+ 47.6600ms,3.3V 47.6619ms,3.3
+ 47.6620ms,0.0V 47.6799ms,0.0
+ 47.6800ms,3.3V 47.6819ms,3.3
+ 47.6820ms,0.0V 47.6999ms,0.0
+ 47.7000ms,3.3V 47.7019ms,3.3
+ 47.7020ms,0.0V 47.7199ms,0.0
+ 47.7200ms,3.3V 47.7219ms,3.3
+ 47.7220ms,0.0V 47.7399ms,0.0
+ 47.7400ms,3.3V 47.7419ms,3.3
+ 47.7420ms,0.0V 47.7599ms,0.0
+ 47.7600ms,3.3V 47.7619ms,3.3
+ 47.7620ms,0.0V 47.7799ms,0.0
+ 47.7800ms,3.3V 47.7819ms,3.3
+ 47.7820ms,0.0V 47.7999ms,0.0
+ 47.8000ms,3.3V 47.8019ms,3.3
+ 47.8020ms,0.0V 47.8199ms,0.0
+ 47.8200ms,3.3V 47.8219ms,3.3
+ 47.8220ms,0.0V 47.8399ms,0.0
+ 47.8400ms,3.3V 47.8419ms,3.3
+ 47.8420ms,0.0V 47.8599ms,0.0
+ 47.8600ms,3.3V 47.8619ms,3.3
+ 47.8620ms,0.0V 47.8799ms,0.0
+ 47.8800ms,3.3V 47.8819ms,3.3
+ 47.8820ms,0.0V 47.8999ms,0.0
+ 47.9000ms,3.3V 47.9019ms,3.3
+ 47.9020ms,0.0V 47.9199ms,0.0
+ 47.9200ms,3.3V 47.9219ms,3.3
+ 47.9220ms,0.0V 47.9399ms,0.0
+ 47.9400ms,3.3V 47.9419ms,3.3
+ 47.9420ms,0.0V 47.9599ms,0.0
+ 47.9600ms,3.3V 47.9619ms,3.3
+ 47.9620ms,0.0V 47.9799ms,0.0
+ 47.9800ms,3.3V 47.9819ms,3.3
+ 47.9820ms,0.0V 47.9999ms,0.0
+ 48.0000ms,3.3V 48.0019ms,3.3
+ 48.0020ms,0.0V 48.0199ms,0.0
+ 48.0200ms,3.3V 48.0219ms,3.3
+ 48.0220ms,0.0V 48.0399ms,0.0
+ 48.0400ms,3.3V 48.0419ms,3.3
+ 48.0420ms,0.0V 48.0599ms,0.0
+ 48.0600ms,3.3V 48.0619ms,3.3
+ 48.0620ms,0.0V 48.0799ms,0.0
+ 48.0800ms,3.3V 48.0819ms,3.3
+ 48.0820ms,0.0V 48.0999ms,0.0
+ 48.1000ms,3.3V 48.1019ms,3.3
+ 48.1020ms,0.0V 48.1199ms,0.0
+ 48.1200ms,3.3V 48.1219ms,3.3
+ 48.1220ms,0.0V 48.1399ms,0.0
+ 48.1400ms,3.3V 48.1419ms,3.3
+ 48.1420ms,0.0V 48.1599ms,0.0
+ 48.1600ms,3.3V 48.1619ms,3.3
+ 48.1620ms,0.0V 48.1799ms,0.0
+ 48.1800ms,3.3V 48.1819ms,3.3
+ 48.1820ms,0.0V 48.1999ms,0.0
+ 48.2000ms,3.3V 48.2019ms,3.3
+ 48.2020ms,0.0V 48.2199ms,0.0
+ 48.2200ms,3.3V 48.2219ms,3.3
+ 48.2220ms,0.0V 48.2399ms,0.0
+ 48.2400ms,3.3V 48.2419ms,3.3
+ 48.2420ms,0.0V 48.2599ms,0.0
+ 48.2600ms,3.3V 48.2619ms,3.3
+ 48.2620ms,0.0V 48.2799ms,0.0
+ 48.2800ms,3.3V 48.2819ms,3.3
+ 48.2820ms,0.0V 48.2999ms,0.0
+ 48.3000ms,3.3V 48.3019ms,3.3
+ 48.3020ms,0.0V 48.3199ms,0.0
+ 48.3200ms,3.3V 48.3219ms,3.3
+ 48.3220ms,0.0V 48.3399ms,0.0
+ 48.3400ms,3.3V 48.3419ms,3.3
+ 48.3420ms,0.0V 48.3599ms,0.0
+ 48.3600ms,3.3V 48.3619ms,3.3
+ 48.3620ms,0.0V 48.3799ms,0.0
+ 48.3800ms,3.3V 48.3819ms,3.3
+ 48.3820ms,0.0V 48.3999ms,0.0
+ 48.4000ms,3.3V 48.4019ms,3.3
+ 48.4020ms,0.0V 48.4199ms,0.0
+ 48.4200ms,3.3V 48.4219ms,3.3
+ 48.4220ms,0.0V 48.4399ms,0.0
+ 48.4400ms,3.3V 48.4419ms,3.3
+ 48.4420ms,0.0V 48.4599ms,0.0
+ 48.4600ms,3.3V 48.4619ms,3.3
+ 48.4620ms,0.0V 48.4799ms,0.0
+ 48.4800ms,3.3V 48.4819ms,3.3
+ 48.4820ms,0.0V 48.4999ms,0.0
+ 48.5000ms,3.3V 48.5019ms,3.3
+ 48.5020ms,0.0V 48.5199ms,0.0
+ 48.5200ms,3.3V 48.5219ms,3.3
+ 48.5220ms,0.0V 48.5399ms,0.0
+ 48.5400ms,3.3V 48.5419ms,3.3
+ 48.5420ms,0.0V 48.5599ms,0.0
+ 48.5600ms,3.3V 48.5619ms,3.3
+ 48.5620ms,0.0V 48.5799ms,0.0
+ 48.5800ms,3.3V 48.5819ms,3.3
+ 48.5820ms,0.0V 48.5999ms,0.0
+ 48.6000ms,3.3V 48.6019ms,3.3
+ 48.6020ms,0.0V 48.6199ms,0.0
+ 48.6200ms,3.3V 48.6219ms,3.3
+ 48.6220ms,0.0V 48.6399ms,0.0
+ 48.6400ms,3.3V 48.6419ms,3.3
+ 48.6420ms,0.0V 48.6599ms,0.0
+ 48.6600ms,3.3V 48.6619ms,3.3
+ 48.6620ms,0.0V 48.6799ms,0.0
+ 48.6800ms,3.3V 48.6819ms,3.3
+ 48.6820ms,0.0V 48.6999ms,0.0
+ 48.7000ms,3.3V 48.7019ms,3.3
+ 48.7020ms,0.0V 48.7199ms,0.0
+ 48.7200ms,3.3V 48.7219ms,3.3
+ 48.7220ms,0.0V 48.7399ms,0.0
+ 48.7400ms,3.3V 48.7419ms,3.3
+ 48.7420ms,0.0V 48.7599ms,0.0
+ 48.7600ms,3.3V 48.7619ms,3.3
+ 48.7620ms,0.0V 48.7799ms,0.0
+ 48.7800ms,3.3V 48.7819ms,3.3
+ 48.7820ms,0.0V 48.7999ms,0.0
+ 48.8000ms,3.3V 48.8019ms,3.3
+ 48.8020ms,0.0V 48.8199ms,0.0
+ 48.8200ms,3.3V 48.8219ms,3.3
+ 48.8220ms,0.0V 48.8399ms,0.0
+ 48.8400ms,3.3V 48.8419ms,3.3
+ 48.8420ms,0.0V 48.8599ms,0.0
+ 48.8600ms,3.3V 48.8619ms,3.3
+ 48.8620ms,0.0V 48.8799ms,0.0
+ 48.8800ms,3.3V 48.8819ms,3.3
+ 48.8820ms,0.0V 48.8999ms,0.0
+ 48.9000ms,3.3V 48.9019ms,3.3
+ 48.9020ms,0.0V 48.9199ms,0.0
+ 48.9200ms,3.3V 48.9219ms,3.3
+ 48.9220ms,0.0V 48.9399ms,0.0
+ 48.9400ms,3.3V 48.9419ms,3.3
+ 48.9420ms,0.0V 48.9599ms,0.0
+ 48.9600ms,3.3V 48.9619ms,3.3
+ 48.9620ms,0.0V 48.9799ms,0.0
+ 48.9800ms,3.3V 48.9819ms,3.3
+ 48.9820ms,0.0V 48.9999ms,0.0
+ 49.0000ms,3.3V 49.0019ms,3.3
+ 49.0020ms,0.0V 49.0199ms,0.0
+ 49.0200ms,3.3V 49.0219ms,3.3
+ 49.0220ms,0.0V 49.0399ms,0.0
+ 49.0400ms,3.3V 49.0419ms,3.3
+ 49.0420ms,0.0V 49.0599ms,0.0
+ 49.0600ms,3.3V 49.0619ms,3.3
+ 49.0620ms,0.0V 49.0799ms,0.0
+ 49.0800ms,3.3V 49.0819ms,3.3
+ 49.0820ms,0.0V 49.0999ms,0.0
+ 49.1000ms,3.3V 49.1019ms,3.3
+ 49.1020ms,0.0V 49.1199ms,0.0
+ 49.1200ms,3.3V 49.1219ms,3.3
+ 49.1220ms,0.0V 49.1399ms,0.0
+ 49.1400ms,3.3V 49.1419ms,3.3
+ 49.1420ms,0.0V 49.1599ms,0.0
+ 49.1600ms,3.3V 49.1619ms,3.3
+ 49.1620ms,0.0V 49.1799ms,0.0
+ 49.1800ms,3.3V 49.1819ms,3.3
+ 49.1820ms,0.0V 49.1999ms,0.0
+ 49.2000ms,3.3V 49.2019ms,3.3
+ 49.2020ms,0.0V 49.2199ms,0.0
+ 49.2200ms,3.3V 49.2219ms,3.3
+ 49.2220ms,0.0V 49.2399ms,0.0
+ 49.2400ms,3.3V 49.2419ms,3.3
+ 49.2420ms,0.0V 49.2599ms,0.0
+ 49.2600ms,3.3V 49.2619ms,3.3
+ 49.2620ms,0.0V 49.2799ms,0.0
+ 49.2800ms,3.3V 49.2819ms,3.3
+ 49.2820ms,0.0V 49.2999ms,0.0
+ 49.3000ms,3.3V 49.3019ms,3.3
+ 49.3020ms,0.0V 49.3199ms,0.0
+ 49.3200ms,3.3V 49.3219ms,3.3
+ 49.3220ms,0.0V 49.3399ms,0.0
+ 49.3400ms,3.3V 49.3419ms,3.3
+ 49.3420ms,0.0V 49.3599ms,0.0
+ 49.3600ms,3.3V 49.3619ms,3.3
+ 49.3620ms,0.0V 49.3799ms,0.0
+ 49.3800ms,3.3V 49.3819ms,3.3
+ 49.3820ms,0.0V 49.3999ms,0.0
+ 49.4000ms,3.3V 49.4019ms,3.3
+ 49.4020ms,0.0V 49.4199ms,0.0
+ 49.4200ms,3.3V 49.4219ms,3.3
+ 49.4220ms,0.0V 49.4399ms,0.0
+ 49.4400ms,3.3V 49.4419ms,3.3
+ 49.4420ms,0.0V 49.4599ms,0.0
+ 49.4600ms,3.3V 49.4619ms,3.3
+ 49.4620ms,0.0V 49.4799ms,0.0
+ 49.4800ms,3.3V 49.4819ms,3.3
+ 49.4820ms,0.0V 49.4999ms,0.0
+ 49.5000ms,3.3V 49.5019ms,3.3
+ 49.5020ms,0.0V 49.5199ms,0.0
+ 49.5200ms,3.3V 49.5219ms,3.3
+ 49.5220ms,0.0V 49.5399ms,0.0
+ 49.5400ms,3.3V 49.5419ms,3.3
+ 49.5420ms,0.0V 49.5599ms,0.0
+ 49.5600ms,3.3V 49.5619ms,3.3
+ 49.5620ms,0.0V 49.5799ms,0.0
+ 49.5800ms,3.3V 49.5819ms,3.3
+ 49.5820ms,0.0V 49.5999ms,0.0
+ 49.6000ms,3.3V 49.6019ms,3.3
+ 49.6020ms,0.0V 49.6199ms,0.0
+ 49.6200ms,3.3V 49.6219ms,3.3
+ 49.6220ms,0.0V 49.6399ms,0.0
+ 49.6400ms,3.3V 49.6419ms,3.3
+ 49.6420ms,0.0V 49.6599ms,0.0
+ 49.6600ms,3.3V 49.6619ms,3.3
+ 49.6620ms,0.0V 49.6799ms,0.0
+ 49.6800ms,3.3V 49.6819ms,3.3
+ 49.6820ms,0.0V 49.6999ms,0.0
+ 49.7000ms,3.3V 49.7019ms,3.3
+ 49.7020ms,0.0V 49.7199ms,0.0
+ 49.7200ms,3.3V 49.7219ms,3.3
+ 49.7220ms,0.0V 49.7399ms,0.0
+ 49.7400ms,3.3V 49.7419ms,3.3
+ 49.7420ms,0.0V 49.7599ms,0.0
+ 49.7600ms,3.3V 49.7619ms,3.3
+ 49.7620ms,0.0V 49.7799ms,0.0
+ 49.7800ms,3.3V 49.7819ms,3.3
+ 49.7820ms,0.0V 49.7999ms,0.0
+ 49.8000ms,3.3V 49.8019ms,3.3
+ 49.8020ms,0.0V 49.8199ms,0.0
+ 49.8200ms,3.3V 49.8219ms,3.3
+ 49.8220ms,0.0V 49.8399ms,0.0
+ 49.8400ms,3.3V 49.8419ms,3.3
+ 49.8420ms,0.0V 49.8599ms,0.0
+ 49.8600ms,3.3V 49.8619ms,3.3
+ 49.8620ms,0.0V 49.8799ms,0.0
+ 49.8800ms,3.3V 49.8819ms,3.3
+ 49.8820ms,0.0V 49.8999ms,0.0
+ 49.9000ms,3.3V 49.9019ms,3.3
+ 49.9020ms,0.0V 49.9199ms,0.0
+ 49.9200ms,3.3V 49.9219ms,3.3
+ 49.9220ms,0.0V 49.9399ms,0.0
+ 49.9400ms,3.3V 49.9419ms,3.3
+ 49.9420ms,0.0V 49.9599ms,0.0
+ 49.9600ms,3.3V 49.9619ms,3.3
+ 49.9620ms,0.0V 49.9799ms,0.0
+ 49.9800ms,3.3V 49.9819ms,3.3
+ 49.9820ms,0.0V 49.9999ms,0.0
+ 50.0000ms,3.3V 50.0019ms,3.3
+ 50.0020ms,0.0V 50.0199ms,0.0
+ 50.0200ms,3.3V 50.0219ms,3.3
+ 50.0220ms,0.0V 50.0399ms,0.0
+ 50.0400ms,3.3V 50.0419ms,3.3
+ 50.0420ms,0.0V 50.0599ms,0.0
+ 50.0600ms,3.3V 50.0619ms,3.3
+ 50.0620ms,0.0V 50.0799ms,0.0
+ 50.0800ms,3.3V 50.0819ms,3.3
+ 50.0820ms,0.0V 50.0999ms,0.0
+ 50.1000ms,3.3V 50.1019ms,3.3
+ 50.1020ms,0.0V 50.1199ms,0.0
+ 50.1200ms,3.3V 50.1221ms,3.3
+ 50.1222ms,0.0V 50.1399ms,0.0
+ 50.1400ms,3.3V 50.1421ms,3.3
+ 50.1422ms,0.0V 50.1599ms,0.0
+ 50.1600ms,3.3V 50.1621ms,3.3
+ 50.1622ms,0.0V 50.1799ms,0.0
+ 50.1800ms,3.3V 50.1821ms,3.3
+ 50.1822ms,0.0V 50.1999ms,0.0
+ 50.2000ms,3.3V 50.2021ms,3.3
+ 50.2022ms,0.0V 50.2199ms,0.0
+ 50.2200ms,3.3V 50.2221ms,3.3
+ 50.2222ms,0.0V 50.2399ms,0.0
+ 50.2400ms,3.3V 50.2421ms,3.3
+ 50.2422ms,0.0V 50.2599ms,0.0
+ 50.2600ms,3.3V 50.2621ms,3.3
+ 50.2622ms,0.0V 50.2799ms,0.0
+ 50.2800ms,3.3V 50.2821ms,3.3
+ 50.2822ms,0.0V 50.2999ms,0.0
+ 50.3000ms,3.3V 50.3021ms,3.3
+ 50.3022ms,0.0V 50.3199ms,0.0
+ 50.3200ms,3.3V 50.3221ms,3.3
+ 50.3222ms,0.0V 50.3399ms,0.0
+ 50.3400ms,3.3V 50.3421ms,3.3
+ 50.3422ms,0.0V 50.3599ms,0.0
+ 50.3600ms,3.3V 50.3621ms,3.3
+ 50.3622ms,0.0V 50.3799ms,0.0
+ 50.3800ms,3.3V 50.3821ms,3.3
+ 50.3822ms,0.0V 50.3999ms,0.0
+ 50.4000ms,3.3V 50.4021ms,3.3
+ 50.4022ms,0.0V 50.4199ms,0.0
+ 50.4200ms,3.3V 50.4221ms,3.3
+ 50.4222ms,0.0V 50.4399ms,0.0
+ 50.4400ms,3.3V 50.4421ms,3.3
+ 50.4422ms,0.0V 50.4599ms,0.0
+ 50.4600ms,3.3V 50.4621ms,3.3
+ 50.4622ms,0.0V 50.4799ms,0.0
+ 50.4800ms,3.3V 50.4821ms,3.3
+ 50.4822ms,0.0V 50.4999ms,0.0
+ 50.5000ms,3.3V 50.5021ms,3.3
+ 50.5022ms,0.0V 50.5199ms,0.0
+ 50.5200ms,3.3V 50.5221ms,3.3
+ 50.5222ms,0.0V 50.5399ms,0.0
+ 50.5400ms,3.3V 50.5421ms,3.3
+ 50.5422ms,0.0V 50.5599ms,0.0
+ 50.5600ms,3.3V 50.5621ms,3.3
+ 50.5622ms,0.0V 50.5799ms,0.0
+ 50.5800ms,3.3V 50.5821ms,3.3
+ 50.5822ms,0.0V 50.5999ms,0.0
+ 50.6000ms,3.3V 50.6021ms,3.3
+ 50.6022ms,0.0V 50.6199ms,0.0
+ 50.6200ms,3.3V 50.6221ms,3.3
+ 50.6222ms,0.0V 50.6399ms,0.0
+ 50.6400ms,3.3V 50.6421ms,3.3
+ 50.6422ms,0.0V 50.6599ms,0.0
+ 50.6600ms,3.3V 50.6621ms,3.3
+ 50.6622ms,0.0V 50.6799ms,0.0
+ 50.6800ms,3.3V 50.6821ms,3.3
+ 50.6822ms,0.0V 50.6999ms,0.0
+ 50.7000ms,3.3V 50.7021ms,3.3
+ 50.7022ms,0.0V 50.7199ms,0.0
+ 50.7200ms,3.3V 50.7221ms,3.3
+ 50.7222ms,0.0V 50.7399ms,0.0
+ 50.7400ms,3.3V 50.7421ms,3.3
+ 50.7422ms,0.0V 50.7599ms,0.0
+ 50.7600ms,3.3V 50.7621ms,3.3
+ 50.7622ms,0.0V 50.7799ms,0.0
+ 50.7800ms,3.3V 50.7821ms,3.3
+ 50.7822ms,0.0V 50.7999ms,0.0
+ 50.8000ms,3.3V 50.8021ms,3.3
+ 50.8022ms,0.0V 50.8199ms,0.0
+ 50.8200ms,3.3V 50.8221ms,3.3
+ 50.8222ms,0.0V 50.8399ms,0.0
+ 50.8400ms,3.3V 50.8421ms,3.3
+ 50.8422ms,0.0V 50.8599ms,0.0
+ 50.8600ms,3.3V 50.8621ms,3.3
+ 50.8622ms,0.0V 50.8799ms,0.0
+ 50.8800ms,3.3V 50.8821ms,3.3
+ 50.8822ms,0.0V 50.8999ms,0.0
+ 50.9000ms,3.3V 50.9021ms,3.3
+ 50.9022ms,0.0V 50.9199ms,0.0
+ 50.9200ms,3.3V 50.9221ms,3.3
+ 50.9222ms,0.0V 50.9399ms,0.0
+ 50.9400ms,3.3V 50.9421ms,3.3
+ 50.9422ms,0.0V 50.9599ms,0.0
+ 50.9600ms,3.3V 50.9621ms,3.3
+ 50.9622ms,0.0V 50.9799ms,0.0
+ 50.9800ms,3.3V 50.9821ms,3.3
+ 50.9822ms,0.0V 50.9999ms,0.0
+ 51.0000ms,3.3V 51.0021ms,3.3
+ 51.0022ms,0.0V 51.0199ms,0.0
+ 51.0200ms,3.3V 51.0221ms,3.3
+ 51.0222ms,0.0V 51.0399ms,0.0
+ 51.0400ms,3.3V 51.0421ms,3.3
+ 51.0422ms,0.0V 51.0599ms,0.0
+ 51.0600ms,3.3V 51.0621ms,3.3
+ 51.0622ms,0.0V 51.0799ms,0.0
+ 51.0800ms,3.3V 51.0821ms,3.3
+ 51.0822ms,0.0V 51.0999ms,0.0
+ 51.1000ms,3.3V 51.1021ms,3.3
+ 51.1022ms,0.0V 51.1199ms,0.0
+ 51.1200ms,3.3V 51.1221ms,3.3
+ 51.1222ms,0.0V 51.1399ms,0.0
+ 51.1400ms,3.3V 51.1421ms,3.3
+ 51.1422ms,0.0V 51.1599ms,0.0
+ 51.1600ms,3.3V 51.1621ms,3.3
+ 51.1622ms,0.0V 51.1799ms,0.0
+ 51.1800ms,3.3V 51.1821ms,3.3
+ 51.1822ms,0.0V 51.1999ms,0.0
+ 51.2000ms,3.3V 51.2021ms,3.3
+ 51.2022ms,0.0V 51.2199ms,0.0
+ 51.2200ms,3.3V 51.2221ms,3.3
+ 51.2222ms,0.0V 51.2399ms,0.0
+ 51.2400ms,3.3V 51.2421ms,3.3
+ 51.2422ms,0.0V 51.2599ms,0.0
+ 51.2600ms,3.3V 51.2621ms,3.3
+ 51.2622ms,0.0V 51.2799ms,0.0
+ 51.2800ms,3.3V 51.2821ms,3.3
+ 51.2822ms,0.0V 51.2999ms,0.0
+ 51.3000ms,3.3V 51.3021ms,3.3
+ 51.3022ms,0.0V 51.3199ms,0.0
+ 51.3200ms,3.3V 51.3221ms,3.3
+ 51.3222ms,0.0V 51.3399ms,0.0
+ 51.3400ms,3.3V 51.3421ms,3.3
+ 51.3422ms,0.0V 51.3599ms,0.0
+ 51.3600ms,3.3V 51.3621ms,3.3
+ 51.3622ms,0.0V 51.3799ms,0.0
+ 51.3800ms,3.3V 51.3821ms,3.3
+ 51.3822ms,0.0V 51.3999ms,0.0
+ 51.4000ms,3.3V 51.4021ms,3.3
+ 51.4022ms,0.0V 51.4199ms,0.0
+ 51.4200ms,3.3V 51.4221ms,3.3
+ 51.4222ms,0.0V 51.4399ms,0.0
+ 51.4400ms,3.3V 51.4421ms,3.3
+ 51.4422ms,0.0V 51.4599ms,0.0
+ 51.4600ms,3.3V 51.4621ms,3.3
+ 51.4622ms,0.0V 51.4799ms,0.0
+ 51.4800ms,3.3V 51.4821ms,3.3
+ 51.4822ms,0.0V 51.4999ms,0.0
+ 51.5000ms,3.3V 51.5021ms,3.3
+ 51.5022ms,0.0V 51.5199ms,0.0
+ 51.5200ms,3.3V 51.5221ms,3.3
+ 51.5222ms,0.0V 51.5399ms,0.0
+ 51.5400ms,3.3V 51.5421ms,3.3
+ 51.5422ms,0.0V 51.5599ms,0.0
+ 51.5600ms,3.3V 51.5621ms,3.3
+ 51.5622ms,0.0V 51.5799ms,0.0
+ 51.5800ms,3.3V 51.5821ms,3.3
+ 51.5822ms,0.0V 51.5999ms,0.0
+ 51.6000ms,3.3V 51.6021ms,3.3
+ 51.6022ms,0.0V 51.6199ms,0.0
+ 51.6200ms,3.3V 51.6221ms,3.3
+ 51.6222ms,0.0V 51.6399ms,0.0
+ 51.6400ms,3.3V 51.6421ms,3.3
+ 51.6422ms,0.0V 51.6599ms,0.0
+ 51.6600ms,3.3V 51.6621ms,3.3
+ 51.6622ms,0.0V 51.6799ms,0.0
+ 51.6800ms,3.3V 51.6821ms,3.3
+ 51.6822ms,0.0V 51.6999ms,0.0
+ 51.7000ms,3.3V 51.7021ms,3.3
+ 51.7022ms,0.0V 51.7199ms,0.0
+ 51.7200ms,3.3V 51.7221ms,3.3
+ 51.7222ms,0.0V 51.7399ms,0.0
+ 51.7400ms,3.3V 51.7421ms,3.3
+ 51.7422ms,0.0V 51.7599ms,0.0
+ 51.7600ms,3.3V 51.7621ms,3.3
+ 51.7622ms,0.0V 51.7799ms,0.0
+ 51.7800ms,3.3V 51.7821ms,3.3
+ 51.7822ms,0.0V 51.7999ms,0.0
+ 51.8000ms,3.3V 51.8021ms,3.3
+ 51.8022ms,0.0V 51.8199ms,0.0
+ 51.8200ms,3.3V 51.8221ms,3.3
+ 51.8222ms,0.0V 51.8399ms,0.0
+ 51.8400ms,3.3V 51.8421ms,3.3
+ 51.8422ms,0.0V 51.8599ms,0.0
+ 51.8600ms,3.3V 51.8621ms,3.3
+ 51.8622ms,0.0V 51.8799ms,0.0
+ 51.8800ms,3.3V 51.8821ms,3.3
+ 51.8822ms,0.0V 51.8999ms,0.0
+ 51.9000ms,3.3V 51.9021ms,3.3
+ 51.9022ms,0.0V 51.9199ms,0.0
+ 51.9200ms,3.3V 51.9221ms,3.3
+ 51.9222ms,0.0V 51.9399ms,0.0
+ 51.9400ms,3.3V 51.9421ms,3.3
+ 51.9422ms,0.0V 51.9599ms,0.0
+ 51.9600ms,3.3V 51.9621ms,3.3
+ 51.9622ms,0.0V 51.9799ms,0.0
+ 51.9800ms,3.3V 51.9821ms,3.3
+ 51.9822ms,0.0V 51.9999ms,0.0
+ 52.0000ms,3.3V 52.0021ms,3.3
+ 52.0022ms,0.0V 52.0199ms,0.0
+ 52.0200ms,3.3V 52.0221ms,3.3
+ 52.0222ms,0.0V 52.0399ms,0.0
+ 52.0400ms,3.3V 52.0421ms,3.3
+ 52.0422ms,0.0V 52.0599ms,0.0
+ 52.0600ms,3.3V 52.0621ms,3.3
+ 52.0622ms,0.0V 52.0799ms,0.0
+ 52.0800ms,3.3V 52.0821ms,3.3
+ 52.0822ms,0.0V 52.0999ms,0.0
+ 52.1000ms,3.3V 52.1021ms,3.3
+ 52.1022ms,0.0V 52.1199ms,0.0
+ 52.1200ms,3.3V 52.1221ms,3.3
+ 52.1222ms,0.0V 52.1399ms,0.0
+ 52.1400ms,3.3V 52.1421ms,3.3
+ 52.1422ms,0.0V 52.1599ms,0.0
+ 52.1600ms,3.3V 52.1621ms,3.3
+ 52.1622ms,0.0V 52.1799ms,0.0
+ 52.1800ms,3.3V 52.1821ms,3.3
+ 52.1822ms,0.0V 52.1999ms,0.0
+ 52.2000ms,3.3V 52.2021ms,3.3
+ 52.2022ms,0.0V 52.2199ms,0.0
+ 52.2200ms,3.3V 52.2221ms,3.3
+ 52.2222ms,0.0V 52.2399ms,0.0
+ 52.2400ms,3.3V 52.2421ms,3.3
+ 52.2422ms,0.0V 52.2599ms,0.0
+ 52.2600ms,3.3V 52.2621ms,3.3
+ 52.2622ms,0.0V 52.2799ms,0.0
+ 52.2800ms,3.3V 52.2821ms,3.3
+ 52.2822ms,0.0V 52.2999ms,0.0
+ 52.3000ms,3.3V 52.3021ms,3.3
+ 52.3022ms,0.0V 52.3199ms,0.0
+ 52.3200ms,3.3V 52.3221ms,3.3
+ 52.3222ms,0.0V 52.3399ms,0.0
+ 52.3400ms,3.3V 52.3421ms,3.3
+ 52.3422ms,0.0V 52.3599ms,0.0
+ 52.3600ms,3.3V 52.3621ms,3.3
+ 52.3622ms,0.0V 52.3799ms,0.0
+ 52.3800ms,3.3V 52.3821ms,3.3
+ 52.3822ms,0.0V 52.3999ms,0.0
+ 52.4000ms,3.3V 52.4021ms,3.3
+ 52.4022ms,0.0V 52.4199ms,0.0
+ 52.4200ms,3.3V 52.4221ms,3.3
+ 52.4222ms,0.0V 52.4399ms,0.0
+ 52.4400ms,3.3V 52.4421ms,3.3
+ 52.4422ms,0.0V 52.4599ms,0.0
+ 52.4600ms,3.3V 52.4621ms,3.3
+ 52.4622ms,0.0V 52.4799ms,0.0
+ 52.4800ms,3.3V 52.4821ms,3.3
+ 52.4822ms,0.0V 52.4999ms,0.0
+ 52.5000ms,3.3V 52.5021ms,3.3
+ 52.5022ms,0.0V 52.5199ms,0.0
+ 52.5200ms,3.3V 52.5221ms,3.3
+ 52.5222ms,0.0V 52.5399ms,0.0
+ 52.5400ms,3.3V 52.5421ms,3.3
+ 52.5422ms,0.0V 52.5599ms,0.0
+ 52.5600ms,3.3V 52.5621ms,3.3
+ 52.5622ms,0.0V 52.5799ms,0.0
+ 52.5800ms,3.3V 52.5821ms,3.3
+ 52.5822ms,0.0V 52.5999ms,0.0
+ 52.6000ms,3.3V 52.6021ms,3.3
+ 52.6022ms,0.0V 52.6199ms,0.0
+ 52.6200ms,3.3V 52.6221ms,3.3
+ 52.6222ms,0.0V 52.6399ms,0.0
+ 52.6400ms,3.3V 52.6421ms,3.3
+ 52.6422ms,0.0V 52.6599ms,0.0
+ 52.6600ms,3.3V 52.6621ms,3.3
+ 52.6622ms,0.0V 52.6799ms,0.0
+ 52.6800ms,3.3V 52.6821ms,3.3
+ 52.6822ms,0.0V 52.6999ms,0.0
+ 52.7000ms,3.3V 52.7021ms,3.3
+ 52.7022ms,0.0V 52.7199ms,0.0
+ 52.7200ms,3.3V 52.7221ms,3.3
+ 52.7222ms,0.0V 52.7399ms,0.0
+ 52.7400ms,3.3V 52.7421ms,3.3
+ 52.7422ms,0.0V 52.7599ms,0.0
+ 52.7600ms,3.3V 52.7621ms,3.3
+ 52.7622ms,0.0V 52.7799ms,0.0
+ 52.7800ms,3.3V 52.7821ms,3.3
+ 52.7822ms,0.0V 52.7999ms,0.0
+ 52.8000ms,3.3V 52.8021ms,3.3
+ 52.8022ms,0.0V 52.8199ms,0.0
+ 52.8200ms,3.3V 52.8221ms,3.3
+ 52.8222ms,0.0V 52.8399ms,0.0
+ 52.8400ms,3.3V 52.8421ms,3.3
+ 52.8422ms,0.0V 52.8599ms,0.0
+ 52.8600ms,3.3V 52.8621ms,3.3
+ 52.8622ms,0.0V 52.8799ms,0.0
+ 52.8800ms,3.3V 52.8821ms,3.3
+ 52.8822ms,0.0V 52.8999ms,0.0
+ 52.9000ms,3.3V 52.9021ms,3.3
+ 52.9022ms,0.0V 52.9199ms,0.0
+ 52.9200ms,3.3V 52.9221ms,3.3
+ 52.9222ms,0.0V 52.9399ms,0.0
+ 52.9400ms,3.3V 52.9421ms,3.3
+ 52.9422ms,0.0V 52.9599ms,0.0
+ 52.9600ms,3.3V 52.9621ms,3.3
+ 52.9622ms,0.0V 52.9799ms,0.0
+ 52.9800ms,3.3V 52.9821ms,3.3
+ 52.9822ms,0.0V 52.9999ms,0.0
+ 53.0000ms,3.3V 53.0021ms,3.3
+ 53.0022ms,0.0V 53.0199ms,0.0
+ 53.0200ms,3.3V 53.0221ms,3.3
+ 53.0222ms,0.0V 53.0399ms,0.0
+ 53.0400ms,3.3V 53.0421ms,3.3
+ 53.0422ms,0.0V 53.0599ms,0.0
+ 53.0600ms,3.3V 53.0621ms,3.3
+ 53.0622ms,0.0V 53.0799ms,0.0
+ 53.0800ms,3.3V 53.0821ms,3.3
+ 53.0822ms,0.0V 53.0999ms,0.0
+ 53.1000ms,3.3V 53.1021ms,3.3
+ 53.1022ms,0.0V 53.1199ms,0.0
+ 53.1200ms,3.3V 53.1221ms,3.3
+ 53.1222ms,0.0V 53.1399ms,0.0
+ 53.1400ms,3.3V 53.1421ms,3.3
+ 53.1422ms,0.0V 53.1599ms,0.0
+ 53.1600ms,3.3V 53.1621ms,3.3
+ 53.1622ms,0.0V 53.1799ms,0.0
+ 53.1800ms,3.3V 53.1821ms,3.3
+ 53.1822ms,0.0V 53.1999ms,0.0
+ 53.2000ms,3.3V 53.2021ms,3.3
+ 53.2022ms,0.0V 53.2199ms,0.0
+ 53.2200ms,3.3V 53.2221ms,3.3
+ 53.2222ms,0.0V 53.2399ms,0.0
+ 53.2400ms,3.3V 53.2421ms,3.3
+ 53.2422ms,0.0V 53.2599ms,0.0
+ 53.2600ms,3.3V 53.2621ms,3.3
+ 53.2622ms,0.0V 53.2799ms,0.0
+ 53.2800ms,3.3V 53.2821ms,3.3
+ 53.2822ms,0.0V 53.2999ms,0.0
+ 53.3000ms,3.3V 53.3021ms,3.3
+ 53.3022ms,0.0V 53.3199ms,0.0
+ 53.3200ms,3.3V 53.3221ms,3.3
+ 53.3222ms,0.0V 53.3399ms,0.0
+ 53.3400ms,3.3V 53.3421ms,3.3
+ 53.3422ms,0.0V 53.3599ms,0.0
+ 53.3600ms,3.3V 53.3621ms,3.3
+ 53.3622ms,0.0V 53.3799ms,0.0
+ 53.3800ms,3.3V 53.3821ms,3.3
+ 53.3822ms,0.0V 53.3999ms,0.0
+ 53.4000ms,3.3V 53.4021ms,3.3
+ 53.4022ms,0.0V 53.4199ms,0.0
+ 53.4200ms,3.3V 53.4221ms,3.3
+ 53.4222ms,0.0V 53.4399ms,0.0
+ 53.4400ms,3.3V 53.4421ms,3.3
+ 53.4422ms,0.0V 53.4599ms,0.0
+ 53.4600ms,3.3V 53.4621ms,3.3
+ 53.4622ms,0.0V 53.4799ms,0.0
+ 53.4800ms,3.3V 53.4821ms,3.3
+ 53.4822ms,0.0V 53.4999ms,0.0
+ 53.5000ms,3.3V 53.5021ms,3.3
+ 53.5022ms,0.0V 53.5199ms,0.0
+ 53.5200ms,3.3V 53.5221ms,3.3
+ 53.5222ms,0.0V 53.5399ms,0.0
+ 53.5400ms,3.3V 53.5421ms,3.3
+ 53.5422ms,0.0V 53.5599ms,0.0
+ 53.5600ms,3.3V 53.5621ms,3.3
+ 53.5622ms,0.0V 53.5799ms,0.0
+ 53.5800ms,3.3V 53.5821ms,3.3
+ 53.5822ms,0.0V 53.5999ms,0.0
+ 53.6000ms,3.3V 53.6021ms,3.3
+ 53.6022ms,0.0V 53.6199ms,0.0
+ 53.6200ms,3.3V 53.6221ms,3.3
+ 53.6222ms,0.0V 53.6399ms,0.0
+ 53.6400ms,3.3V 53.6421ms,3.3
+ 53.6422ms,0.0V 53.6599ms,0.0
+ 53.6600ms,3.3V 53.6621ms,3.3
+ 53.6622ms,0.0V 53.6799ms,0.0
+ 53.6800ms,3.3V 53.6821ms,3.3
+ 53.6822ms,0.0V 53.6999ms,0.0
+ 53.7000ms,3.3V 53.7021ms,3.3
+ 53.7022ms,0.0V 53.7199ms,0.0
+ 53.7200ms,3.3V 53.7221ms,3.3
+ 53.7222ms,0.0V 53.7399ms,0.0
+ 53.7400ms,3.3V 53.7421ms,3.3
+ 53.7422ms,0.0V 53.7599ms,0.0
+ 53.7600ms,3.3V 53.7621ms,3.3
+ 53.7622ms,0.0V 53.7799ms,0.0
+ 53.7800ms,3.3V 53.7821ms,3.3
+ 53.7822ms,0.0V 53.7999ms,0.0
+ 53.8000ms,3.3V 53.8021ms,3.3
+ 53.8022ms,0.0V 53.8199ms,0.0
+ 53.8200ms,3.3V 53.8221ms,3.3
+ 53.8222ms,0.0V 53.8399ms,0.0
+ 53.8400ms,3.3V 53.8421ms,3.3
+ 53.8422ms,0.0V 53.8599ms,0.0
+ 53.8600ms,3.3V 53.8621ms,3.3
+ 53.8622ms,0.0V 53.8799ms,0.0
+ 53.8800ms,3.3V 53.8821ms,3.3
+ 53.8822ms,0.0V 53.8999ms,0.0
+ 53.9000ms,3.3V 53.9021ms,3.3
+ 53.9022ms,0.0V 53.9199ms,0.0
+ 53.9200ms,3.3V 53.9221ms,3.3
+ 53.9222ms,0.0V 53.9399ms,0.0
+ 53.9400ms,3.3V 53.9421ms,3.3
+ 53.9422ms,0.0V 53.9599ms,0.0
+ 53.9600ms,3.3V 53.9621ms,3.3
+ 53.9622ms,0.0V 53.9799ms,0.0
+ 53.9800ms,3.3V 53.9821ms,3.3
+ 53.9822ms,0.0V 53.9999ms,0.0
+ 54.0000ms,3.3V 54.0021ms,3.3
+ 54.0022ms,0.0V 54.0199ms,0.0
+ 54.0200ms,3.3V 54.0221ms,3.3
+ 54.0222ms,0.0V 54.0399ms,0.0
+ 54.0400ms,3.3V 54.0421ms,3.3
+ 54.0422ms,0.0V 54.0599ms,0.0
+ 54.0600ms,3.3V 54.0621ms,3.3
+ 54.0622ms,0.0V 54.0799ms,0.0
+ 54.0800ms,3.3V 54.0821ms,3.3
+ 54.0822ms,0.0V 54.0999ms,0.0
+ 54.1000ms,3.3V 54.1021ms,3.3
+ 54.1022ms,0.0V 54.1199ms,0.0
+ 54.1200ms,3.3V 54.1221ms,3.3
+ 54.1222ms,0.0V 54.1399ms,0.0
+ 54.1400ms,3.3V 54.1421ms,3.3
+ 54.1422ms,0.0V 54.1599ms,0.0
+ 54.1600ms,3.3V 54.1621ms,3.3
+ 54.1622ms,0.0V 54.1799ms,0.0
+ 54.1800ms,3.3V 54.1821ms,3.3
+ 54.1822ms,0.0V 54.1999ms,0.0
+ 54.2000ms,3.3V 54.2021ms,3.3
+ 54.2022ms,0.0V 54.2199ms,0.0
+ 54.2200ms,3.3V 54.2221ms,3.3
+ 54.2222ms,0.0V 54.2399ms,0.0
+ 54.2400ms,3.3V 54.2421ms,3.3
+ 54.2422ms,0.0V 54.2599ms,0.0
+ 54.2600ms,3.3V 54.2621ms,3.3
+ 54.2622ms,0.0V 54.2799ms,0.0
+ 54.2800ms,3.3V 54.2821ms,3.3
+ 54.2822ms,0.0V 54.2999ms,0.0
+ 54.3000ms,3.3V 54.3021ms,3.3
+ 54.3022ms,0.0V 54.3199ms,0.0
+ 54.3200ms,3.3V 54.3221ms,3.3
+ 54.3222ms,0.0V 54.3399ms,0.0
+ 54.3400ms,3.3V 54.3421ms,3.3
+ 54.3422ms,0.0V 54.3599ms,0.0
+ 54.3600ms,3.3V 54.3621ms,3.3
+ 54.3622ms,0.0V 54.3799ms,0.0
+ 54.3800ms,3.3V 54.3821ms,3.3
+ 54.3822ms,0.0V 54.3999ms,0.0
+ 54.4000ms,3.3V 54.4021ms,3.3
+ 54.4022ms,0.0V 54.4199ms,0.0
+ 54.4200ms,3.3V 54.4221ms,3.3
+ 54.4222ms,0.0V 54.4399ms,0.0
+ 54.4400ms,3.3V 54.4421ms,3.3
+ 54.4422ms,0.0V 54.4599ms,0.0
+ 54.4600ms,3.3V 54.4621ms,3.3
+ 54.4622ms,0.0V 54.4799ms,0.0
+ 54.4800ms,3.3V 54.4821ms,3.3
+ 54.4822ms,0.0V 54.4999ms,0.0
+ 54.5000ms,3.3V 54.5021ms,3.3
+ 54.5022ms,0.0V 54.5199ms,0.0
+ 54.5200ms,3.3V 54.5221ms,3.3
+ 54.5222ms,0.0V 54.5399ms,0.0
+ 54.5400ms,3.3V 54.5421ms,3.3
+ 54.5422ms,0.0V 54.5599ms,0.0
+ 54.5600ms,3.3V 54.5621ms,3.3
+ 54.5622ms,0.0V 54.5799ms,0.0
+ 54.5800ms,3.3V 54.5821ms,3.3
+ 54.5822ms,0.0V 54.5999ms,0.0
+ 54.6000ms,3.3V 54.6021ms,3.3
+ 54.6022ms,0.0V 54.6199ms,0.0
+ 54.6200ms,3.3V 54.6221ms,3.3
+ 54.6222ms,0.0V 54.6399ms,0.0
+ 54.6400ms,3.3V 54.6421ms,3.3
+ 54.6422ms,0.0V 54.6599ms,0.0
+ 54.6600ms,3.3V 54.6621ms,3.3
+ 54.6622ms,0.0V 54.6799ms,0.0
+ 54.6800ms,3.3V 54.6821ms,3.3
+ 54.6822ms,0.0V 54.6999ms,0.0
+ 54.7000ms,3.3V 54.7021ms,3.3
+ 54.7022ms,0.0V 54.7199ms,0.0
+ 54.7200ms,3.3V 54.7221ms,3.3
+ 54.7222ms,0.0V 54.7399ms,0.0
+ 54.7400ms,3.3V 54.7421ms,3.3
+ 54.7422ms,0.0V 54.7599ms,0.0
+ 54.7600ms,3.3V 54.7621ms,3.3
+ 54.7622ms,0.0V 54.7799ms,0.0
+ 54.7800ms,3.3V 54.7821ms,3.3
+ 54.7822ms,0.0V 54.7999ms,0.0
+ 54.8000ms,3.3V 54.8021ms,3.3
+ 54.8022ms,0.0V 54.8199ms,0.0
+ 54.8200ms,3.3V 54.8221ms,3.3
+ 54.8222ms,0.0V 54.8399ms,0.0
+ 54.8400ms,3.3V 54.8421ms,3.3
+ 54.8422ms,0.0V 54.8599ms,0.0
+ 54.8600ms,3.3V 54.8621ms,3.3
+ 54.8622ms,0.0V 54.8799ms,0.0
+ 54.8800ms,3.3V 54.8821ms,3.3
+ 54.8822ms,0.0V 54.8999ms,0.0
+ 54.9000ms,3.3V 54.9021ms,3.3
+ 54.9022ms,0.0V 54.9199ms,0.0
+ 54.9200ms,3.3V 54.9221ms,3.3
+ 54.9222ms,0.0V 54.9399ms,0.0
+ 54.9400ms,3.3V 54.9421ms,3.3
+ 54.9422ms,0.0V 54.9599ms,0.0
+ 54.9600ms,3.3V 54.9621ms,3.3
+ 54.9622ms,0.0V 54.9799ms,0.0
+ 54.9800ms,3.3V 54.9821ms,3.3
+ 54.9822ms,0.0V 54.9999ms,0.0
+ 55.0000ms,3.3V 55.0021ms,3.3
+ 55.0022ms,0.0V 55.0199ms,0.0
+ 55.0200ms,3.3V 55.0221ms,3.3
+ 55.0222ms,0.0V 55.0399ms,0.0
+ 55.0400ms,3.3V 55.0421ms,3.3
+ 55.0422ms,0.0V 55.0599ms,0.0
+ 55.0600ms,3.3V 55.0621ms,3.3
+ 55.0622ms,0.0V 55.0799ms,0.0
+ 55.0800ms,3.3V 55.0821ms,3.3
+ 55.0822ms,0.0V 55.0999ms,0.0
+ 55.1000ms,3.3V 55.1021ms,3.3
+ 55.1022ms,0.0V 55.1199ms,0.0
+ 55.1200ms,3.3V 55.1223ms,3.3
+ 55.1224ms,0.0V 55.1399ms,0.0
+ 55.1400ms,3.3V 55.1423ms,3.3
+ 55.1424ms,0.0V 55.1599ms,0.0
+ 55.1600ms,3.3V 55.1623ms,3.3
+ 55.1624ms,0.0V 55.1799ms,0.0
+ 55.1800ms,3.3V 55.1823ms,3.3
+ 55.1824ms,0.0V 55.1999ms,0.0
+ 55.2000ms,3.3V 55.2023ms,3.3
+ 55.2024ms,0.0V 55.2199ms,0.0
+ 55.2200ms,3.3V 55.2223ms,3.3
+ 55.2224ms,0.0V 55.2399ms,0.0
+ 55.2400ms,3.3V 55.2423ms,3.3
+ 55.2424ms,0.0V 55.2599ms,0.0
+ 55.2600ms,3.3V 55.2623ms,3.3
+ 55.2624ms,0.0V 55.2799ms,0.0
+ 55.2800ms,3.3V 55.2823ms,3.3
+ 55.2824ms,0.0V 55.2999ms,0.0
+ 55.3000ms,3.3V 55.3023ms,3.3
+ 55.3024ms,0.0V 55.3199ms,0.0
+ 55.3200ms,3.3V 55.3223ms,3.3
+ 55.3224ms,0.0V 55.3399ms,0.0
+ 55.3400ms,3.3V 55.3423ms,3.3
+ 55.3424ms,0.0V 55.3599ms,0.0
+ 55.3600ms,3.3V 55.3623ms,3.3
+ 55.3624ms,0.0V 55.3799ms,0.0
+ 55.3800ms,3.3V 55.3823ms,3.3
+ 55.3824ms,0.0V 55.3999ms,0.0
+ 55.4000ms,3.3V 55.4023ms,3.3
+ 55.4024ms,0.0V 55.4199ms,0.0
+ 55.4200ms,3.3V 55.4223ms,3.3
+ 55.4224ms,0.0V 55.4399ms,0.0
+ 55.4400ms,3.3V 55.4423ms,3.3
+ 55.4424ms,0.0V 55.4599ms,0.0
+ 55.4600ms,3.3V 55.4623ms,3.3
+ 55.4624ms,0.0V 55.4799ms,0.0
+ 55.4800ms,3.3V 55.4823ms,3.3
+ 55.4824ms,0.0V 55.4999ms,0.0
+ 55.5000ms,3.3V 55.5023ms,3.3
+ 55.5024ms,0.0V 55.5199ms,0.0
+ 55.5200ms,3.3V 55.5223ms,3.3
+ 55.5224ms,0.0V 55.5399ms,0.0
+ 55.5400ms,3.3V 55.5423ms,3.3
+ 55.5424ms,0.0V 55.5599ms,0.0
+ 55.5600ms,3.3V 55.5623ms,3.3
+ 55.5624ms,0.0V 55.5799ms,0.0
+ 55.5800ms,3.3V 55.5823ms,3.3
+ 55.5824ms,0.0V 55.5999ms,0.0
+ 55.6000ms,3.3V 55.6023ms,3.3
+ 55.6024ms,0.0V 55.6199ms,0.0
+ 55.6200ms,3.3V 55.6223ms,3.3
+ 55.6224ms,0.0V 55.6399ms,0.0
+ 55.6400ms,3.3V 55.6423ms,3.3
+ 55.6424ms,0.0V 55.6599ms,0.0
+ 55.6600ms,3.3V 55.6623ms,3.3
+ 55.6624ms,0.0V 55.6799ms,0.0
+ 55.6800ms,3.3V 55.6823ms,3.3
+ 55.6824ms,0.0V 55.6999ms,0.0
+ 55.7000ms,3.3V 55.7023ms,3.3
+ 55.7024ms,0.0V 55.7199ms,0.0
+ 55.7200ms,3.3V 55.7223ms,3.3
+ 55.7224ms,0.0V 55.7399ms,0.0
+ 55.7400ms,3.3V 55.7423ms,3.3
+ 55.7424ms,0.0V 55.7599ms,0.0
+ 55.7600ms,3.3V 55.7623ms,3.3
+ 55.7624ms,0.0V 55.7799ms,0.0
+ 55.7800ms,3.3V 55.7823ms,3.3
+ 55.7824ms,0.0V 55.7999ms,0.0
+ 55.8000ms,3.3V 55.8023ms,3.3
+ 55.8024ms,0.0V 55.8199ms,0.0
+ 55.8200ms,3.3V 55.8223ms,3.3
+ 55.8224ms,0.0V 55.8399ms,0.0
+ 55.8400ms,3.3V 55.8423ms,3.3
+ 55.8424ms,0.0V 55.8599ms,0.0
+ 55.8600ms,3.3V 55.8623ms,3.3
+ 55.8624ms,0.0V 55.8799ms,0.0
+ 55.8800ms,3.3V 55.8823ms,3.3
+ 55.8824ms,0.0V 55.8999ms,0.0
+ 55.9000ms,3.3V 55.9023ms,3.3
+ 55.9024ms,0.0V 55.9199ms,0.0
+ 55.9200ms,3.3V 55.9223ms,3.3
+ 55.9224ms,0.0V 55.9399ms,0.0
+ 55.9400ms,3.3V 55.9423ms,3.3
+ 55.9424ms,0.0V 55.9599ms,0.0
+ 55.9600ms,3.3V 55.9623ms,3.3
+ 55.9624ms,0.0V 55.9799ms,0.0
+ 55.9800ms,3.3V 55.9823ms,3.3
+ 55.9824ms,0.0V 55.9999ms,0.0
+ 56.0000ms,3.3V 56.0023ms,3.3
+ 56.0024ms,0.0V 56.0199ms,0.0
+ 56.0200ms,3.3V 56.0223ms,3.3
+ 56.0224ms,0.0V 56.0399ms,0.0
+ 56.0400ms,3.3V 56.0423ms,3.3
+ 56.0424ms,0.0V 56.0599ms,0.0
+ 56.0600ms,3.3V 56.0623ms,3.3
+ 56.0624ms,0.0V 56.0799ms,0.0
+ 56.0800ms,3.3V 56.0823ms,3.3
+ 56.0824ms,0.0V 56.0999ms,0.0
+ 56.1000ms,3.3V 56.1023ms,3.3
+ 56.1024ms,0.0V 56.1199ms,0.0
+ 56.1200ms,3.3V 56.1223ms,3.3
+ 56.1224ms,0.0V 56.1399ms,0.0
+ 56.1400ms,3.3V 56.1423ms,3.3
+ 56.1424ms,0.0V 56.1599ms,0.0
+ 56.1600ms,3.3V 56.1623ms,3.3
+ 56.1624ms,0.0V 56.1799ms,0.0
+ 56.1800ms,3.3V 56.1823ms,3.3
+ 56.1824ms,0.0V 56.1999ms,0.0
+ 56.2000ms,3.3V 56.2023ms,3.3
+ 56.2024ms,0.0V 56.2199ms,0.0
+ 56.2200ms,3.3V 56.2223ms,3.3
+ 56.2224ms,0.0V 56.2399ms,0.0
+ 56.2400ms,3.3V 56.2423ms,3.3
+ 56.2424ms,0.0V 56.2599ms,0.0
+ 56.2600ms,3.3V 56.2623ms,3.3
+ 56.2624ms,0.0V 56.2799ms,0.0
+ 56.2800ms,3.3V 56.2823ms,3.3
+ 56.2824ms,0.0V 56.2999ms,0.0
+ 56.3000ms,3.3V 56.3023ms,3.3
+ 56.3024ms,0.0V 56.3199ms,0.0
+ 56.3200ms,3.3V 56.3223ms,3.3
+ 56.3224ms,0.0V 56.3399ms,0.0
+ 56.3400ms,3.3V 56.3423ms,3.3
+ 56.3424ms,0.0V 56.3599ms,0.0
+ 56.3600ms,3.3V 56.3623ms,3.3
+ 56.3624ms,0.0V 56.3799ms,0.0
+ 56.3800ms,3.3V 56.3823ms,3.3
+ 56.3824ms,0.0V 56.3999ms,0.0
+ 56.4000ms,3.3V 56.4023ms,3.3
+ 56.4024ms,0.0V 56.4199ms,0.0
+ 56.4200ms,3.3V 56.4223ms,3.3
+ 56.4224ms,0.0V 56.4399ms,0.0
+ 56.4400ms,3.3V 56.4423ms,3.3
+ 56.4424ms,0.0V 56.4599ms,0.0
+ 56.4600ms,3.3V 56.4623ms,3.3
+ 56.4624ms,0.0V 56.4799ms,0.0
+ 56.4800ms,3.3V 56.4823ms,3.3
+ 56.4824ms,0.0V 56.4999ms,0.0
+ 56.5000ms,3.3V 56.5023ms,3.3
+ 56.5024ms,0.0V 56.5199ms,0.0
+ 56.5200ms,3.3V 56.5223ms,3.3
+ 56.5224ms,0.0V 56.5399ms,0.0
+ 56.5400ms,3.3V 56.5423ms,3.3
+ 56.5424ms,0.0V 56.5599ms,0.0
+ 56.5600ms,3.3V 56.5623ms,3.3
+ 56.5624ms,0.0V 56.5799ms,0.0
+ 56.5800ms,3.3V 56.5823ms,3.3
+ 56.5824ms,0.0V 56.5999ms,0.0
+ 56.6000ms,3.3V 56.6023ms,3.3
+ 56.6024ms,0.0V 56.6199ms,0.0
+ 56.6200ms,3.3V 56.6223ms,3.3
+ 56.6224ms,0.0V 56.6399ms,0.0
+ 56.6400ms,3.3V 56.6423ms,3.3
+ 56.6424ms,0.0V 56.6599ms,0.0
+ 56.6600ms,3.3V 56.6623ms,3.3
+ 56.6624ms,0.0V 56.6799ms,0.0
+ 56.6800ms,3.3V 56.6823ms,3.3
+ 56.6824ms,0.0V 56.6999ms,0.0
+ 56.7000ms,3.3V 56.7023ms,3.3
+ 56.7024ms,0.0V 56.7199ms,0.0
+ 56.7200ms,3.3V 56.7223ms,3.3
+ 56.7224ms,0.0V 56.7399ms,0.0
+ 56.7400ms,3.3V 56.7423ms,3.3
+ 56.7424ms,0.0V 56.7599ms,0.0
+ 56.7600ms,3.3V 56.7623ms,3.3
+ 56.7624ms,0.0V 56.7799ms,0.0
+ 56.7800ms,3.3V 56.7823ms,3.3
+ 56.7824ms,0.0V 56.7999ms,0.0
+ 56.8000ms,3.3V 56.8023ms,3.3
+ 56.8024ms,0.0V 56.8199ms,0.0
+ 56.8200ms,3.3V 56.8223ms,3.3
+ 56.8224ms,0.0V 56.8399ms,0.0
+ 56.8400ms,3.3V 56.8423ms,3.3
+ 56.8424ms,0.0V 56.8599ms,0.0
+ 56.8600ms,3.3V 56.8623ms,3.3
+ 56.8624ms,0.0V 56.8799ms,0.0
+ 56.8800ms,3.3V 56.8823ms,3.3
+ 56.8824ms,0.0V 56.8999ms,0.0
+ 56.9000ms,3.3V 56.9023ms,3.3
+ 56.9024ms,0.0V 56.9199ms,0.0
+ 56.9200ms,3.3V 56.9223ms,3.3
+ 56.9224ms,0.0V 56.9399ms,0.0
+ 56.9400ms,3.3V 56.9423ms,3.3
+ 56.9424ms,0.0V 56.9599ms,0.0
+ 56.9600ms,3.3V 56.9623ms,3.3
+ 56.9624ms,0.0V 56.9799ms,0.0
+ 56.9800ms,3.3V 56.9823ms,3.3
+ 56.9824ms,0.0V 56.9999ms,0.0
+ 57.0000ms,3.3V 57.0023ms,3.3
+ 57.0024ms,0.0V 57.0199ms,0.0
+ 57.0200ms,3.3V 57.0223ms,3.3
+ 57.0224ms,0.0V 57.0399ms,0.0
+ 57.0400ms,3.3V 57.0423ms,3.3
+ 57.0424ms,0.0V 57.0599ms,0.0
+ 57.0600ms,3.3V 57.0623ms,3.3
+ 57.0624ms,0.0V 57.0799ms,0.0
+ 57.0800ms,3.3V 57.0823ms,3.3
+ 57.0824ms,0.0V 57.0999ms,0.0
+ 57.1000ms,3.3V 57.1023ms,3.3
+ 57.1024ms,0.0V 57.1199ms,0.0
+ 57.1200ms,3.3V 57.1223ms,3.3
+ 57.1224ms,0.0V 57.1399ms,0.0
+ 57.1400ms,3.3V 57.1423ms,3.3
+ 57.1424ms,0.0V 57.1599ms,0.0
+ 57.1600ms,3.3V 57.1623ms,3.3
+ 57.1624ms,0.0V 57.1799ms,0.0
+ 57.1800ms,3.3V 57.1823ms,3.3
+ 57.1824ms,0.0V 57.1999ms,0.0
+ 57.2000ms,3.3V 57.2023ms,3.3
+ 57.2024ms,0.0V 57.2199ms,0.0
+ 57.2200ms,3.3V 57.2223ms,3.3
+ 57.2224ms,0.0V 57.2399ms,0.0
+ 57.2400ms,3.3V 57.2423ms,3.3
+ 57.2424ms,0.0V 57.2599ms,0.0
+ 57.2600ms,3.3V 57.2623ms,3.3
+ 57.2624ms,0.0V 57.2799ms,0.0
+ 57.2800ms,3.3V 57.2823ms,3.3
+ 57.2824ms,0.0V 57.2999ms,0.0
+ 57.3000ms,3.3V 57.3023ms,3.3
+ 57.3024ms,0.0V 57.3199ms,0.0
+ 57.3200ms,3.3V 57.3223ms,3.3
+ 57.3224ms,0.0V 57.3399ms,0.0
+ 57.3400ms,3.3V 57.3423ms,3.3
+ 57.3424ms,0.0V 57.3599ms,0.0
+ 57.3600ms,3.3V 57.3623ms,3.3
+ 57.3624ms,0.0V 57.3799ms,0.0
+ 57.3800ms,3.3V 57.3823ms,3.3
+ 57.3824ms,0.0V 57.3999ms,0.0
+ 57.4000ms,3.3V 57.4023ms,3.3
+ 57.4024ms,0.0V 57.4199ms,0.0
+ 57.4200ms,3.3V 57.4223ms,3.3
+ 57.4224ms,0.0V 57.4399ms,0.0
+ 57.4400ms,3.3V 57.4423ms,3.3
+ 57.4424ms,0.0V 57.4599ms,0.0
+ 57.4600ms,3.3V 57.4623ms,3.3
+ 57.4624ms,0.0V 57.4799ms,0.0
+ 57.4800ms,3.3V 57.4823ms,3.3
+ 57.4824ms,0.0V 57.4999ms,0.0
+ 57.5000ms,3.3V 57.5023ms,3.3
+ 57.5024ms,0.0V 57.5199ms,0.0
+ 57.5200ms,3.3V 57.5223ms,3.3
+ 57.5224ms,0.0V 57.5399ms,0.0
+ 57.5400ms,3.3V 57.5423ms,3.3
+ 57.5424ms,0.0V 57.5599ms,0.0
+ 57.5600ms,3.3V 57.5623ms,3.3
+ 57.5624ms,0.0V 57.5799ms,0.0
+ 57.5800ms,3.3V 57.5823ms,3.3
+ 57.5824ms,0.0V 57.5999ms,0.0
+ 57.6000ms,3.3V 57.6023ms,3.3
+ 57.6024ms,0.0V 57.6199ms,0.0
+ 57.6200ms,3.3V 57.6223ms,3.3
+ 57.6224ms,0.0V 57.6399ms,0.0
+ 57.6400ms,3.3V 57.6423ms,3.3
+ 57.6424ms,0.0V 57.6599ms,0.0
+ 57.6600ms,3.3V 57.6623ms,3.3
+ 57.6624ms,0.0V 57.6799ms,0.0
+ 57.6800ms,3.3V 57.6823ms,3.3
+ 57.6824ms,0.0V 57.6999ms,0.0
+ 57.7000ms,3.3V 57.7023ms,3.3
+ 57.7024ms,0.0V 57.7199ms,0.0
+ 57.7200ms,3.3V 57.7223ms,3.3
+ 57.7224ms,0.0V 57.7399ms,0.0
+ 57.7400ms,3.3V 57.7423ms,3.3
+ 57.7424ms,0.0V 57.7599ms,0.0
+ 57.7600ms,3.3V 57.7623ms,3.3
+ 57.7624ms,0.0V 57.7799ms,0.0
+ 57.7800ms,3.3V 57.7823ms,3.3
+ 57.7824ms,0.0V 57.7999ms,0.0
+ 57.8000ms,3.3V 57.8023ms,3.3
+ 57.8024ms,0.0V 57.8199ms,0.0
+ 57.8200ms,3.3V 57.8223ms,3.3
+ 57.8224ms,0.0V 57.8399ms,0.0
+ 57.8400ms,3.3V 57.8423ms,3.3
+ 57.8424ms,0.0V 57.8599ms,0.0
+ 57.8600ms,3.3V 57.8623ms,3.3
+ 57.8624ms,0.0V 57.8799ms,0.0
+ 57.8800ms,3.3V 57.8823ms,3.3
+ 57.8824ms,0.0V 57.8999ms,0.0
+ 57.9000ms,3.3V 57.9023ms,3.3
+ 57.9024ms,0.0V 57.9199ms,0.0
+ 57.9200ms,3.3V 57.9223ms,3.3
+ 57.9224ms,0.0V 57.9399ms,0.0
+ 57.9400ms,3.3V 57.9423ms,3.3
+ 57.9424ms,0.0V 57.9599ms,0.0
+ 57.9600ms,3.3V 57.9623ms,3.3
+ 57.9624ms,0.0V 57.9799ms,0.0
+ 57.9800ms,3.3V 57.9823ms,3.3
+ 57.9824ms,0.0V 57.9999ms,0.0
+ 58.0000ms,3.3V 58.0023ms,3.3
+ 58.0024ms,0.0V 58.0199ms,0.0
+ 58.0200ms,3.3V 58.0223ms,3.3
+ 58.0224ms,0.0V 58.0399ms,0.0
+ 58.0400ms,3.3V 58.0423ms,3.3
+ 58.0424ms,0.0V 58.0599ms,0.0
+ 58.0600ms,3.3V 58.0623ms,3.3
+ 58.0624ms,0.0V 58.0799ms,0.0
+ 58.0800ms,3.3V 58.0823ms,3.3
+ 58.0824ms,0.0V 58.0999ms,0.0
+ 58.1000ms,3.3V 58.1023ms,3.3
+ 58.1024ms,0.0V 58.1199ms,0.0
+ 58.1200ms,3.3V 58.1223ms,3.3
+ 58.1224ms,0.0V 58.1399ms,0.0
+ 58.1400ms,3.3V 58.1423ms,3.3
+ 58.1424ms,0.0V 58.1599ms,0.0
+ 58.1600ms,3.3V 58.1623ms,3.3
+ 58.1624ms,0.0V 58.1799ms,0.0
+ 58.1800ms,3.3V 58.1823ms,3.3
+ 58.1824ms,0.0V 58.1999ms,0.0
+ 58.2000ms,3.3V 58.2023ms,3.3
+ 58.2024ms,0.0V 58.2199ms,0.0
+ 58.2200ms,3.3V 58.2223ms,3.3
+ 58.2224ms,0.0V 58.2399ms,0.0
+ 58.2400ms,3.3V 58.2423ms,3.3
+ 58.2424ms,0.0V 58.2599ms,0.0
+ 58.2600ms,3.3V 58.2623ms,3.3
+ 58.2624ms,0.0V 58.2799ms,0.0
+ 58.2800ms,3.3V 58.2823ms,3.3
+ 58.2824ms,0.0V 58.2999ms,0.0
+ 58.3000ms,3.3V 58.3023ms,3.3
+ 58.3024ms,0.0V 58.3199ms,0.0
+ 58.3200ms,3.3V 58.3223ms,3.3
+ 58.3224ms,0.0V 58.3399ms,0.0
+ 58.3400ms,3.3V 58.3423ms,3.3
+ 58.3424ms,0.0V 58.3599ms,0.0
+ 58.3600ms,3.3V 58.3623ms,3.3
+ 58.3624ms,0.0V 58.3799ms,0.0
+ 58.3800ms,3.3V 58.3823ms,3.3
+ 58.3824ms,0.0V 58.3999ms,0.0
+ 58.4000ms,3.3V 58.4023ms,3.3
+ 58.4024ms,0.0V 58.4199ms,0.0
+ 58.4200ms,3.3V 58.4223ms,3.3
+ 58.4224ms,0.0V 58.4399ms,0.0
+ 58.4400ms,3.3V 58.4423ms,3.3
+ 58.4424ms,0.0V 58.4599ms,0.0
+ 58.4600ms,3.3V 58.4623ms,3.3
+ 58.4624ms,0.0V 58.4799ms,0.0
+ 58.4800ms,3.3V 58.4823ms,3.3
+ 58.4824ms,0.0V 58.4999ms,0.0
+ 58.5000ms,3.3V 58.5023ms,3.3
+ 58.5024ms,0.0V 58.5199ms,0.0
+ 58.5200ms,3.3V 58.5223ms,3.3
+ 58.5224ms,0.0V 58.5399ms,0.0
+ 58.5400ms,3.3V 58.5423ms,3.3
+ 58.5424ms,0.0V 58.5599ms,0.0
+ 58.5600ms,3.3V 58.5623ms,3.3
+ 58.5624ms,0.0V 58.5799ms,0.0
+ 58.5800ms,3.3V 58.5823ms,3.3
+ 58.5824ms,0.0V 58.5999ms,0.0
+ 58.6000ms,3.3V 58.6023ms,3.3
+ 58.6024ms,0.0V 58.6199ms,0.0
+ 58.6200ms,3.3V 58.6223ms,3.3
+ 58.6224ms,0.0V 58.6399ms,0.0
+ 58.6400ms,3.3V 58.6423ms,3.3
+ 58.6424ms,0.0V 58.6599ms,0.0
+ 58.6600ms,3.3V 58.6623ms,3.3
+ 58.6624ms,0.0V 58.6799ms,0.0
+ 58.6800ms,3.3V 58.6823ms,3.3
+ 58.6824ms,0.0V 58.6999ms,0.0
+ 58.7000ms,3.3V 58.7023ms,3.3
+ 58.7024ms,0.0V 58.7199ms,0.0
+ 58.7200ms,3.3V 58.7223ms,3.3
+ 58.7224ms,0.0V 58.7399ms,0.0
+ 58.7400ms,3.3V 58.7423ms,3.3
+ 58.7424ms,0.0V 58.7599ms,0.0
+ 58.7600ms,3.3V 58.7623ms,3.3
+ 58.7624ms,0.0V 58.7799ms,0.0
+ 58.7800ms,3.3V 58.7823ms,3.3
+ 58.7824ms,0.0V 58.7999ms,0.0
+ 58.8000ms,3.3V 58.8023ms,3.3
+ 58.8024ms,0.0V 58.8199ms,0.0
+ 58.8200ms,3.3V 58.8223ms,3.3
+ 58.8224ms,0.0V 58.8399ms,0.0
+ 58.8400ms,3.3V 58.8423ms,3.3
+ 58.8424ms,0.0V 58.8599ms,0.0
+ 58.8600ms,3.3V 58.8623ms,3.3
+ 58.8624ms,0.0V 58.8799ms,0.0
+ 58.8800ms,3.3V 58.8823ms,3.3
+ 58.8824ms,0.0V 58.8999ms,0.0
+ 58.9000ms,3.3V 58.9023ms,3.3
+ 58.9024ms,0.0V 58.9199ms,0.0
+ 58.9200ms,3.3V 58.9223ms,3.3
+ 58.9224ms,0.0V 58.9399ms,0.0
+ 58.9400ms,3.3V 58.9423ms,3.3
+ 58.9424ms,0.0V 58.9599ms,0.0
+ 58.9600ms,3.3V 58.9623ms,3.3
+ 58.9624ms,0.0V 58.9799ms,0.0
+ 58.9800ms,3.3V 58.9823ms,3.3
+ 58.9824ms,0.0V 58.9999ms,0.0
+ 59.0000ms,3.3V 59.0023ms,3.3
+ 59.0024ms,0.0V 59.0199ms,0.0
+ 59.0200ms,3.3V 59.0223ms,3.3
+ 59.0224ms,0.0V 59.0399ms,0.0
+ 59.0400ms,3.3V 59.0423ms,3.3
+ 59.0424ms,0.0V 59.0599ms,0.0
+ 59.0600ms,3.3V 59.0623ms,3.3
+ 59.0624ms,0.0V 59.0799ms,0.0
+ 59.0800ms,3.3V 59.0823ms,3.3
+ 59.0824ms,0.0V 59.0999ms,0.0
+ 59.1000ms,3.3V 59.1023ms,3.3
+ 59.1024ms,0.0V 59.1199ms,0.0
+ 59.1200ms,3.3V 59.1223ms,3.3
+ 59.1224ms,0.0V 59.1399ms,0.0
+ 59.1400ms,3.3V 59.1423ms,3.3
+ 59.1424ms,0.0V 59.1599ms,0.0
+ 59.1600ms,3.3V 59.1623ms,3.3
+ 59.1624ms,0.0V 59.1799ms,0.0
+ 59.1800ms,3.3V 59.1823ms,3.3
+ 59.1824ms,0.0V 59.1999ms,0.0
+ 59.2000ms,3.3V 59.2023ms,3.3
+ 59.2024ms,0.0V 59.2199ms,0.0
+ 59.2200ms,3.3V 59.2223ms,3.3
+ 59.2224ms,0.0V 59.2399ms,0.0
+ 59.2400ms,3.3V 59.2423ms,3.3
+ 59.2424ms,0.0V 59.2599ms,0.0
+ 59.2600ms,3.3V 59.2623ms,3.3
+ 59.2624ms,0.0V 59.2799ms,0.0
+ 59.2800ms,3.3V 59.2823ms,3.3
+ 59.2824ms,0.0V 59.2999ms,0.0
+ 59.3000ms,3.3V 59.3023ms,3.3
+ 59.3024ms,0.0V 59.3199ms,0.0
+ 59.3200ms,3.3V 59.3223ms,3.3
+ 59.3224ms,0.0V 59.3399ms,0.0
+ 59.3400ms,3.3V 59.3423ms,3.3
+ 59.3424ms,0.0V 59.3599ms,0.0
+ 59.3600ms,3.3V 59.3623ms,3.3
+ 59.3624ms,0.0V 59.3799ms,0.0
+ 59.3800ms,3.3V 59.3823ms,3.3
+ 59.3824ms,0.0V 59.3999ms,0.0
+ 59.4000ms,3.3V 59.4023ms,3.3
+ 59.4024ms,0.0V 59.4199ms,0.0
+ 59.4200ms,3.3V 59.4223ms,3.3
+ 59.4224ms,0.0V 59.4399ms,0.0
+ 59.4400ms,3.3V 59.4423ms,3.3
+ 59.4424ms,0.0V 59.4599ms,0.0
+ 59.4600ms,3.3V 59.4623ms,3.3
+ 59.4624ms,0.0V 59.4799ms,0.0
+ 59.4800ms,3.3V 59.4823ms,3.3
+ 59.4824ms,0.0V 59.4999ms,0.0
+ 59.5000ms,3.3V 59.5023ms,3.3
+ 59.5024ms,0.0V 59.5199ms,0.0
+ 59.5200ms,3.3V 59.5223ms,3.3
+ 59.5224ms,0.0V 59.5399ms,0.0
+ 59.5400ms,3.3V 59.5423ms,3.3
+ 59.5424ms,0.0V 59.5599ms,0.0
+ 59.5600ms,3.3V 59.5623ms,3.3
+ 59.5624ms,0.0V 59.5799ms,0.0
+ 59.5800ms,3.3V 59.5823ms,3.3
+ 59.5824ms,0.0V 59.5999ms,0.0
+ 59.6000ms,3.3V 59.6023ms,3.3
+ 59.6024ms,0.0V 59.6199ms,0.0
+ 59.6200ms,3.3V 59.6223ms,3.3
+ 59.6224ms,0.0V 59.6399ms,0.0
+ 59.6400ms,3.3V 59.6423ms,3.3
+ 59.6424ms,0.0V 59.6599ms,0.0
+ 59.6600ms,3.3V 59.6623ms,3.3
+ 59.6624ms,0.0V 59.6799ms,0.0
+ 59.6800ms,3.3V 59.6823ms,3.3
+ 59.6824ms,0.0V 59.6999ms,0.0
+ 59.7000ms,3.3V 59.7023ms,3.3
+ 59.7024ms,0.0V 59.7199ms,0.0
+ 59.7200ms,3.3V 59.7223ms,3.3
+ 59.7224ms,0.0V 59.7399ms,0.0
+ 59.7400ms,3.3V 59.7423ms,3.3
+ 59.7424ms,0.0V 59.7599ms,0.0
+ 59.7600ms,3.3V 59.7623ms,3.3
+ 59.7624ms,0.0V 59.7799ms,0.0
+ 59.7800ms,3.3V 59.7823ms,3.3
+ 59.7824ms,0.0V 59.7999ms,0.0
+ 59.8000ms,3.3V 59.8023ms,3.3
+ 59.8024ms,0.0V 59.8199ms,0.0
+ 59.8200ms,3.3V 59.8223ms,3.3
+ 59.8224ms,0.0V 59.8399ms,0.0
+ 59.8400ms,3.3V 59.8423ms,3.3
+ 59.8424ms,0.0V 59.8599ms,0.0
+ 59.8600ms,3.3V 59.8623ms,3.3
+ 59.8624ms,0.0V 59.8799ms,0.0
+ 59.8800ms,3.3V 59.8823ms,3.3
+ 59.8824ms,0.0V 59.8999ms,0.0
+ 59.9000ms,3.3V 59.9023ms,3.3
+ 59.9024ms,0.0V 59.9199ms,0.0
+ 59.9200ms,3.3V 59.9223ms,3.3
+ 59.9224ms,0.0V 59.9399ms,0.0
+ 59.9400ms,3.3V 59.9423ms,3.3
+ 59.9424ms,0.0V 59.9599ms,0.0
+ 59.9600ms,3.3V 59.9623ms,3.3
+ 59.9624ms,0.0V 59.9799ms,0.0
+ 59.9800ms,3.3V 59.9823ms,3.3
+ 59.9824ms,0.0V 59.9999ms,0.0
+ 60.0000ms,3.3V 60.0023ms,3.3
+ 60.0024ms,0.0V 60.0199ms,0.0
+ 60.0200ms,3.3V 60.0223ms,3.3
+ 60.0224ms,0.0V 60.0399ms,0.0
+ 60.0400ms,3.3V 60.0423ms,3.3
+ 60.0424ms,0.0V 60.0599ms,0.0
+ 60.0600ms,3.3V 60.0623ms,3.3
+ 60.0624ms,0.0V 60.0799ms,0.0
+ 60.0800ms,3.3V 60.0823ms,3.3
+ 60.0824ms,0.0V 60.0999ms,0.0
+ 60.1000ms,3.3V 60.1023ms,3.3
+ 60.1024ms,0.0V 60.1199ms,0.0
+ 60.1200ms,3.3V 60.1225ms,3.3
+ 60.1226ms,0.0V 60.1399ms,0.0
+ 60.1400ms,3.3V 60.1425ms,3.3
+ 60.1426ms,0.0V 60.1599ms,0.0
+ 60.1600ms,3.3V 60.1625ms,3.3
+ 60.1626ms,0.0V 60.1799ms,0.0
+ 60.1800ms,3.3V 60.1825ms,3.3
+ 60.1826ms,0.0V 60.1999ms,0.0
+ 60.2000ms,3.3V 60.2025ms,3.3
+ 60.2026ms,0.0V 60.2199ms,0.0
+ 60.2200ms,3.3V 60.2225ms,3.3
+ 60.2226ms,0.0V 60.2399ms,0.0
+ 60.2400ms,3.3V 60.2425ms,3.3
+ 60.2426ms,0.0V 60.2599ms,0.0
+ 60.2600ms,3.3V 60.2625ms,3.3
+ 60.2626ms,0.0V 60.2799ms,0.0
+ 60.2800ms,3.3V 60.2825ms,3.3
+ 60.2826ms,0.0V 60.2999ms,0.0
+ 60.3000ms,3.3V 60.3025ms,3.3
+ 60.3026ms,0.0V 60.3199ms,0.0
+ 60.3200ms,3.3V 60.3225ms,3.3
+ 60.3226ms,0.0V 60.3399ms,0.0
+ 60.3400ms,3.3V 60.3425ms,3.3
+ 60.3426ms,0.0V 60.3599ms,0.0
+ 60.3600ms,3.3V 60.3625ms,3.3
+ 60.3626ms,0.0V 60.3799ms,0.0
+ 60.3800ms,3.3V 60.3825ms,3.3
+ 60.3826ms,0.0V 60.3999ms,0.0
+ 60.4000ms,3.3V 60.4025ms,3.3
+ 60.4026ms,0.0V 60.4199ms,0.0
+ 60.4200ms,3.3V 60.4225ms,3.3
+ 60.4226ms,0.0V 60.4399ms,0.0
+ 60.4400ms,3.3V 60.4425ms,3.3
+ 60.4426ms,0.0V 60.4599ms,0.0
+ 60.4600ms,3.3V 60.4625ms,3.3
+ 60.4626ms,0.0V 60.4799ms,0.0
+ 60.4800ms,3.3V 60.4825ms,3.3
+ 60.4826ms,0.0V 60.4999ms,0.0
+ 60.5000ms,3.3V 60.5025ms,3.3
+ 60.5026ms,0.0V 60.5199ms,0.0
+ 60.5200ms,3.3V 60.5225ms,3.3
+ 60.5226ms,0.0V 60.5399ms,0.0
+ 60.5400ms,3.3V 60.5425ms,3.3
+ 60.5426ms,0.0V 60.5599ms,0.0
+ 60.5600ms,3.3V 60.5625ms,3.3
+ 60.5626ms,0.0V 60.5799ms,0.0
+ 60.5800ms,3.3V 60.5825ms,3.3
+ 60.5826ms,0.0V 60.5999ms,0.0
+ 60.6000ms,3.3V 60.6025ms,3.3
+ 60.6026ms,0.0V 60.6199ms,0.0
+ 60.6200ms,3.3V 60.6225ms,3.3
+ 60.6226ms,0.0V 60.6399ms,0.0
+ 60.6400ms,3.3V 60.6425ms,3.3
+ 60.6426ms,0.0V 60.6599ms,0.0
+ 60.6600ms,3.3V 60.6625ms,3.3
+ 60.6626ms,0.0V 60.6799ms,0.0
+ 60.6800ms,3.3V 60.6825ms,3.3
+ 60.6826ms,0.0V 60.6999ms,0.0
+ 60.7000ms,3.3V 60.7025ms,3.3
+ 60.7026ms,0.0V 60.7199ms,0.0
+ 60.7200ms,3.3V 60.7225ms,3.3
+ 60.7226ms,0.0V 60.7399ms,0.0
+ 60.7400ms,3.3V 60.7425ms,3.3
+ 60.7426ms,0.0V 60.7599ms,0.0
+ 60.7600ms,3.3V 60.7625ms,3.3
+ 60.7626ms,0.0V 60.7799ms,0.0
+ 60.7800ms,3.3V 60.7825ms,3.3
+ 60.7826ms,0.0V 60.7999ms,0.0
+ 60.8000ms,3.3V 60.8025ms,3.3
+ 60.8026ms,0.0V 60.8199ms,0.0
+ 60.8200ms,3.3V 60.8225ms,3.3
+ 60.8226ms,0.0V 60.8399ms,0.0
+ 60.8400ms,3.3V 60.8425ms,3.3
+ 60.8426ms,0.0V 60.8599ms,0.0
+ 60.8600ms,3.3V 60.8625ms,3.3
+ 60.8626ms,0.0V 60.8799ms,0.0
+ 60.8800ms,3.3V 60.8825ms,3.3
+ 60.8826ms,0.0V 60.8999ms,0.0
+ 60.9000ms,3.3V 60.9025ms,3.3
+ 60.9026ms,0.0V 60.9199ms,0.0
+ 60.9200ms,3.3V 60.9225ms,3.3
+ 60.9226ms,0.0V 60.9399ms,0.0
+ 60.9400ms,3.3V 60.9425ms,3.3
+ 60.9426ms,0.0V 60.9599ms,0.0
+ 60.9600ms,3.3V 60.9625ms,3.3
+ 60.9626ms,0.0V 60.9799ms,0.0
+ 60.9800ms,3.3V 60.9825ms,3.3
+ 60.9826ms,0.0V 60.9999ms,0.0
+ 61.0000ms,3.3V 61.0025ms,3.3
+ 61.0026ms,0.0V 61.0199ms,0.0
+ 61.0200ms,3.3V 61.0225ms,3.3
+ 61.0226ms,0.0V 61.0399ms,0.0
+ 61.0400ms,3.3V 61.0425ms,3.3
+ 61.0426ms,0.0V 61.0599ms,0.0
+ 61.0600ms,3.3V 61.0625ms,3.3
+ 61.0626ms,0.0V 61.0799ms,0.0
+ 61.0800ms,3.3V 61.0825ms,3.3
+ 61.0826ms,0.0V 61.0999ms,0.0
+ 61.1000ms,3.3V 61.1025ms,3.3
+ 61.1026ms,0.0V 61.1199ms,0.0
+ 61.1200ms,3.3V 61.1225ms,3.3
+ 61.1226ms,0.0V 61.1399ms,0.0
+ 61.1400ms,3.3V 61.1425ms,3.3
+ 61.1426ms,0.0V 61.1599ms,0.0
+ 61.1600ms,3.3V 61.1625ms,3.3
+ 61.1626ms,0.0V 61.1799ms,0.0
+ 61.1800ms,3.3V 61.1825ms,3.3
+ 61.1826ms,0.0V 61.1999ms,0.0
+ 61.2000ms,3.3V 61.2025ms,3.3
+ 61.2026ms,0.0V 61.2199ms,0.0
+ 61.2200ms,3.3V 61.2225ms,3.3
+ 61.2226ms,0.0V 61.2399ms,0.0
+ 61.2400ms,3.3V 61.2425ms,3.3
+ 61.2426ms,0.0V 61.2599ms,0.0
+ 61.2600ms,3.3V 61.2625ms,3.3
+ 61.2626ms,0.0V 61.2799ms,0.0
+ 61.2800ms,3.3V 61.2825ms,3.3
+ 61.2826ms,0.0V 61.2999ms,0.0
+ 61.3000ms,3.3V 61.3025ms,3.3
+ 61.3026ms,0.0V 61.3199ms,0.0
+ 61.3200ms,3.3V 61.3225ms,3.3
+ 61.3226ms,0.0V 61.3399ms,0.0
+ 61.3400ms,3.3V 61.3425ms,3.3
+ 61.3426ms,0.0V 61.3599ms,0.0
+ 61.3600ms,3.3V 61.3625ms,3.3
+ 61.3626ms,0.0V 61.3799ms,0.0
+ 61.3800ms,3.3V 61.3825ms,3.3
+ 61.3826ms,0.0V 61.3999ms,0.0
+ 61.4000ms,3.3V 61.4025ms,3.3
+ 61.4026ms,0.0V 61.4199ms,0.0
+ 61.4200ms,3.3V 61.4225ms,3.3
+ 61.4226ms,0.0V 61.4399ms,0.0
+ 61.4400ms,3.3V 61.4425ms,3.3
+ 61.4426ms,0.0V 61.4599ms,0.0
+ 61.4600ms,3.3V 61.4625ms,3.3
+ 61.4626ms,0.0V 61.4799ms,0.0
+ 61.4800ms,3.3V 61.4825ms,3.3
+ 61.4826ms,0.0V 61.4999ms,0.0
+ 61.5000ms,3.3V 61.5025ms,3.3
+ 61.5026ms,0.0V 61.5199ms,0.0
+ 61.5200ms,3.3V 61.5225ms,3.3
+ 61.5226ms,0.0V 61.5399ms,0.0
+ 61.5400ms,3.3V 61.5425ms,3.3
+ 61.5426ms,0.0V 61.5599ms,0.0
+ 61.5600ms,3.3V 61.5625ms,3.3
+ 61.5626ms,0.0V 61.5799ms,0.0
+ 61.5800ms,3.3V 61.5825ms,3.3
+ 61.5826ms,0.0V 61.5999ms,0.0
+ 61.6000ms,3.3V 61.6025ms,3.3
+ 61.6026ms,0.0V 61.6199ms,0.0
+ 61.6200ms,3.3V 61.6225ms,3.3
+ 61.6226ms,0.0V 61.6399ms,0.0
+ 61.6400ms,3.3V 61.6425ms,3.3
+ 61.6426ms,0.0V 61.6599ms,0.0
+ 61.6600ms,3.3V 61.6625ms,3.3
+ 61.6626ms,0.0V 61.6799ms,0.0
+ 61.6800ms,3.3V 61.6825ms,3.3
+ 61.6826ms,0.0V 61.6999ms,0.0
+ 61.7000ms,3.3V 61.7025ms,3.3
+ 61.7026ms,0.0V 61.7199ms,0.0
+ 61.7200ms,3.3V 61.7225ms,3.3
+ 61.7226ms,0.0V 61.7399ms,0.0
+ 61.7400ms,3.3V 61.7425ms,3.3
+ 61.7426ms,0.0V 61.7599ms,0.0
+ 61.7600ms,3.3V 61.7625ms,3.3
+ 61.7626ms,0.0V 61.7799ms,0.0
+ 61.7800ms,3.3V 61.7825ms,3.3
+ 61.7826ms,0.0V 61.7999ms,0.0
+ 61.8000ms,3.3V 61.8025ms,3.3
+ 61.8026ms,0.0V 61.8199ms,0.0
+ 61.8200ms,3.3V 61.8225ms,3.3
+ 61.8226ms,0.0V 61.8399ms,0.0
+ 61.8400ms,3.3V 61.8425ms,3.3
+ 61.8426ms,0.0V 61.8599ms,0.0
+ 61.8600ms,3.3V 61.8625ms,3.3
+ 61.8626ms,0.0V 61.8799ms,0.0
+ 61.8800ms,3.3V 61.8825ms,3.3
+ 61.8826ms,0.0V 61.8999ms,0.0
+ 61.9000ms,3.3V 61.9025ms,3.3
+ 61.9026ms,0.0V 61.9199ms,0.0
+ 61.9200ms,3.3V 61.9225ms,3.3
+ 61.9226ms,0.0V 61.9399ms,0.0
+ 61.9400ms,3.3V 61.9425ms,3.3
+ 61.9426ms,0.0V 61.9599ms,0.0
+ 61.9600ms,3.3V 61.9625ms,3.3
+ 61.9626ms,0.0V 61.9799ms,0.0
+ 61.9800ms,3.3V 61.9825ms,3.3
+ 61.9826ms,0.0V 61.9999ms,0.0
+ 62.0000ms,3.3V 62.0025ms,3.3
+ 62.0026ms,0.0V 62.0199ms,0.0
+ 62.0200ms,3.3V 62.0225ms,3.3
+ 62.0226ms,0.0V 62.0399ms,0.0
+ 62.0400ms,3.3V 62.0425ms,3.3
+ 62.0426ms,0.0V 62.0599ms,0.0
+ 62.0600ms,3.3V 62.0625ms,3.3
+ 62.0626ms,0.0V 62.0799ms,0.0
+ 62.0800ms,3.3V 62.0825ms,3.3
+ 62.0826ms,0.0V 62.0999ms,0.0
+ 62.1000ms,3.3V 62.1025ms,3.3
+ 62.1026ms,0.0V 62.1199ms,0.0
+ 62.1200ms,3.3V 62.1225ms,3.3
+ 62.1226ms,0.0V 62.1399ms,0.0
+ 62.1400ms,3.3V 62.1425ms,3.3
+ 62.1426ms,0.0V 62.1599ms,0.0
+ 62.1600ms,3.3V 62.1625ms,3.3
+ 62.1626ms,0.0V 62.1799ms,0.0
+ 62.1800ms,3.3V 62.1825ms,3.3
+ 62.1826ms,0.0V 62.1999ms,0.0
+ 62.2000ms,3.3V 62.2025ms,3.3
+ 62.2026ms,0.0V 62.2199ms,0.0
+ 62.2200ms,3.3V 62.2225ms,3.3
+ 62.2226ms,0.0V 62.2399ms,0.0
+ 62.2400ms,3.3V 62.2425ms,3.3
+ 62.2426ms,0.0V 62.2599ms,0.0
+ 62.2600ms,3.3V 62.2625ms,3.3
+ 62.2626ms,0.0V 62.2799ms,0.0
+ 62.2800ms,3.3V 62.2825ms,3.3
+ 62.2826ms,0.0V 62.2999ms,0.0
+ 62.3000ms,3.3V 62.3025ms,3.3
+ 62.3026ms,0.0V 62.3199ms,0.0
+ 62.3200ms,3.3V 62.3225ms,3.3
+ 62.3226ms,0.0V 62.3399ms,0.0
+ 62.3400ms,3.3V 62.3425ms,3.3
+ 62.3426ms,0.0V 62.3599ms,0.0
+ 62.3600ms,3.3V 62.3625ms,3.3
+ 62.3626ms,0.0V 62.3799ms,0.0
+ 62.3800ms,3.3V 62.3825ms,3.3
+ 62.3826ms,0.0V 62.3999ms,0.0
+ 62.4000ms,3.3V 62.4025ms,3.3
+ 62.4026ms,0.0V 62.4199ms,0.0
+ 62.4200ms,3.3V 62.4225ms,3.3
+ 62.4226ms,0.0V 62.4399ms,0.0
+ 62.4400ms,3.3V 62.4425ms,3.3
+ 62.4426ms,0.0V 62.4599ms,0.0
+ 62.4600ms,3.3V 62.4625ms,3.3
+ 62.4626ms,0.0V 62.4799ms,0.0
+ 62.4800ms,3.3V 62.4825ms,3.3
+ 62.4826ms,0.0V 62.4999ms,0.0
+ 62.5000ms,3.3V 62.5025ms,3.3
+ 62.5026ms,0.0V 62.5199ms,0.0
+ 62.5200ms,3.3V 62.5225ms,3.3
+ 62.5226ms,0.0V 62.5399ms,0.0
+ 62.5400ms,3.3V 62.5425ms,3.3
+ 62.5426ms,0.0V 62.5599ms,0.0
+ 62.5600ms,3.3V 62.5625ms,3.3
+ 62.5626ms,0.0V 62.5799ms,0.0
+ 62.5800ms,3.3V 62.5825ms,3.3
+ 62.5826ms,0.0V 62.5999ms,0.0
+ 62.6000ms,3.3V 62.6025ms,3.3
+ 62.6026ms,0.0V 62.6199ms,0.0
+ 62.6200ms,3.3V 62.6225ms,3.3
+ 62.6226ms,0.0V 62.6399ms,0.0
+ 62.6400ms,3.3V 62.6425ms,3.3
+ 62.6426ms,0.0V 62.6599ms,0.0
+ 62.6600ms,3.3V 62.6625ms,3.3
+ 62.6626ms,0.0V 62.6799ms,0.0
+ 62.6800ms,3.3V 62.6825ms,3.3
+ 62.6826ms,0.0V 62.6999ms,0.0
+ 62.7000ms,3.3V 62.7025ms,3.3
+ 62.7026ms,0.0V 62.7199ms,0.0
+ 62.7200ms,3.3V 62.7225ms,3.3
+ 62.7226ms,0.0V 62.7399ms,0.0
+ 62.7400ms,3.3V 62.7425ms,3.3
+ 62.7426ms,0.0V 62.7599ms,0.0
+ 62.7600ms,3.3V 62.7625ms,3.3
+ 62.7626ms,0.0V 62.7799ms,0.0
+ 62.7800ms,3.3V 62.7825ms,3.3
+ 62.7826ms,0.0V 62.7999ms,0.0
+ 62.8000ms,3.3V 62.8025ms,3.3
+ 62.8026ms,0.0V 62.8199ms,0.0
+ 62.8200ms,3.3V 62.8225ms,3.3
+ 62.8226ms,0.0V 62.8399ms,0.0
+ 62.8400ms,3.3V 62.8425ms,3.3
+ 62.8426ms,0.0V 62.8599ms,0.0
+ 62.8600ms,3.3V 62.8625ms,3.3
+ 62.8626ms,0.0V 62.8799ms,0.0
+ 62.8800ms,3.3V 62.8825ms,3.3
+ 62.8826ms,0.0V 62.8999ms,0.0
+ 62.9000ms,3.3V 62.9025ms,3.3
+ 62.9026ms,0.0V 62.9199ms,0.0
+ 62.9200ms,3.3V 62.9225ms,3.3
+ 62.9226ms,0.0V 62.9399ms,0.0
+ 62.9400ms,3.3V 62.9425ms,3.3
+ 62.9426ms,0.0V 62.9599ms,0.0
+ 62.9600ms,3.3V 62.9625ms,3.3
+ 62.9626ms,0.0V 62.9799ms,0.0
+ 62.9800ms,3.3V 62.9825ms,3.3
+ 62.9826ms,0.0V 62.9999ms,0.0
+ 63.0000ms,3.3V 63.0025ms,3.3
+ 63.0026ms,0.0V 63.0199ms,0.0
+ 63.0200ms,3.3V 63.0225ms,3.3
+ 63.0226ms,0.0V 63.0399ms,0.0
+ 63.0400ms,3.3V 63.0425ms,3.3
+ 63.0426ms,0.0V 63.0599ms,0.0
+ 63.0600ms,3.3V 63.0625ms,3.3
+ 63.0626ms,0.0V 63.0799ms,0.0
+ 63.0800ms,3.3V 63.0825ms,3.3
+ 63.0826ms,0.0V 63.0999ms,0.0
+ 63.1000ms,3.3V 63.1025ms,3.3
+ 63.1026ms,0.0V 63.1199ms,0.0
+ 63.1200ms,3.3V 63.1225ms,3.3
+ 63.1226ms,0.0V 63.1399ms,0.0
+ 63.1400ms,3.3V 63.1425ms,3.3
+ 63.1426ms,0.0V 63.1599ms,0.0
+ 63.1600ms,3.3V 63.1625ms,3.3
+ 63.1626ms,0.0V 63.1799ms,0.0
+ 63.1800ms,3.3V 63.1825ms,3.3
+ 63.1826ms,0.0V 63.1999ms,0.0
+ 63.2000ms,3.3V 63.2025ms,3.3
+ 63.2026ms,0.0V 63.2199ms,0.0
+ 63.2200ms,3.3V 63.2225ms,3.3
+ 63.2226ms,0.0V 63.2399ms,0.0
+ 63.2400ms,3.3V 63.2425ms,3.3
+ 63.2426ms,0.0V 63.2599ms,0.0
+ 63.2600ms,3.3V 63.2625ms,3.3
+ 63.2626ms,0.0V 63.2799ms,0.0
+ 63.2800ms,3.3V 63.2825ms,3.3
+ 63.2826ms,0.0V 63.2999ms,0.0
+ 63.3000ms,3.3V 63.3025ms,3.3
+ 63.3026ms,0.0V 63.3199ms,0.0
+ 63.3200ms,3.3V 63.3225ms,3.3
+ 63.3226ms,0.0V 63.3399ms,0.0
+ 63.3400ms,3.3V 63.3425ms,3.3
+ 63.3426ms,0.0V 63.3599ms,0.0
+ 63.3600ms,3.3V 63.3625ms,3.3
+ 63.3626ms,0.0V 63.3799ms,0.0
+ 63.3800ms,3.3V 63.3825ms,3.3
+ 63.3826ms,0.0V 63.3999ms,0.0
+ 63.4000ms,3.3V 63.4025ms,3.3
+ 63.4026ms,0.0V 63.4199ms,0.0
+ 63.4200ms,3.3V 63.4225ms,3.3
+ 63.4226ms,0.0V 63.4399ms,0.0
+ 63.4400ms,3.3V 63.4425ms,3.3
+ 63.4426ms,0.0V 63.4599ms,0.0
+ 63.4600ms,3.3V 63.4625ms,3.3
+ 63.4626ms,0.0V 63.4799ms,0.0
+ 63.4800ms,3.3V 63.4825ms,3.3
+ 63.4826ms,0.0V 63.4999ms,0.0
+ 63.5000ms,3.3V 63.5025ms,3.3
+ 63.5026ms,0.0V 63.5199ms,0.0
+ 63.5200ms,3.3V 63.5225ms,3.3
+ 63.5226ms,0.0V 63.5399ms,0.0
+ 63.5400ms,3.3V 63.5425ms,3.3
+ 63.5426ms,0.0V 63.5599ms,0.0
+ 63.5600ms,3.3V 63.5625ms,3.3
+ 63.5626ms,0.0V 63.5799ms,0.0
+ 63.5800ms,3.3V 63.5825ms,3.3
+ 63.5826ms,0.0V 63.5999ms,0.0
+ 63.6000ms,3.3V 63.6025ms,3.3
+ 63.6026ms,0.0V 63.6199ms,0.0
+ 63.6200ms,3.3V 63.6225ms,3.3
+ 63.6226ms,0.0V 63.6399ms,0.0
+ 63.6400ms,3.3V 63.6425ms,3.3
+ 63.6426ms,0.0V 63.6599ms,0.0
+ 63.6600ms,3.3V 63.6625ms,3.3
+ 63.6626ms,0.0V 63.6799ms,0.0
+ 63.6800ms,3.3V 63.6825ms,3.3
+ 63.6826ms,0.0V 63.6999ms,0.0
+ 63.7000ms,3.3V 63.7025ms,3.3
+ 63.7026ms,0.0V 63.7199ms,0.0
+ 63.7200ms,3.3V 63.7225ms,3.3
+ 63.7226ms,0.0V 63.7399ms,0.0
+ 63.7400ms,3.3V 63.7425ms,3.3
+ 63.7426ms,0.0V 63.7599ms,0.0
+ 63.7600ms,3.3V 63.7625ms,3.3
+ 63.7626ms,0.0V 63.7799ms,0.0
+ 63.7800ms,3.3V 63.7825ms,3.3
+ 63.7826ms,0.0V 63.7999ms,0.0
+ 63.8000ms,3.3V 63.8025ms,3.3
+ 63.8026ms,0.0V 63.8199ms,0.0
+ 63.8200ms,3.3V 63.8225ms,3.3
+ 63.8226ms,0.0V 63.8399ms,0.0
+ 63.8400ms,3.3V 63.8425ms,3.3
+ 63.8426ms,0.0V 63.8599ms,0.0
+ 63.8600ms,3.3V 63.8625ms,3.3
+ 63.8626ms,0.0V 63.8799ms,0.0
+ 63.8800ms,3.3V 63.8825ms,3.3
+ 63.8826ms,0.0V 63.8999ms,0.0
+ 63.9000ms,3.3V 63.9025ms,3.3
+ 63.9026ms,0.0V 63.9199ms,0.0
+ 63.9200ms,3.3V 63.9225ms,3.3
+ 63.9226ms,0.0V 63.9399ms,0.0
+ 63.9400ms,3.3V 63.9425ms,3.3
+ 63.9426ms,0.0V 63.9599ms,0.0
+ 63.9600ms,3.3V 63.9625ms,3.3
+ 63.9626ms,0.0V 63.9799ms,0.0
+ 63.9800ms,3.3V 63.9825ms,3.3
+ 63.9826ms,0.0V 63.9999ms,0.0
+ 64.0000ms,3.3V 64.0025ms,3.3
+ 64.0026ms,0.0V 64.0199ms,0.0
+ 64.0200ms,3.3V 64.0225ms,3.3
+ 64.0226ms,0.0V 64.0399ms,0.0
+ 64.0400ms,3.3V 64.0425ms,3.3
+ 64.0426ms,0.0V 64.0599ms,0.0
+ 64.0600ms,3.3V 64.0625ms,3.3
+ 64.0626ms,0.0V 64.0799ms,0.0
+ 64.0800ms,3.3V 64.0825ms,3.3
+ 64.0826ms,0.0V 64.0999ms,0.0
+ 64.1000ms,3.3V 64.1025ms,3.3
+ 64.1026ms,0.0V 64.1199ms,0.0
+ 64.1200ms,3.3V 64.1225ms,3.3
+ 64.1226ms,0.0V 64.1399ms,0.0
+ 64.1400ms,3.3V 64.1425ms,3.3
+ 64.1426ms,0.0V 64.1599ms,0.0
+ 64.1600ms,3.3V 64.1625ms,3.3
+ 64.1626ms,0.0V 64.1799ms,0.0
+ 64.1800ms,3.3V 64.1825ms,3.3
+ 64.1826ms,0.0V 64.1999ms,0.0
+ 64.2000ms,3.3V 64.2025ms,3.3
+ 64.2026ms,0.0V 64.2199ms,0.0
+ 64.2200ms,3.3V 64.2225ms,3.3
+ 64.2226ms,0.0V 64.2399ms,0.0
+ 64.2400ms,3.3V 64.2425ms,3.3
+ 64.2426ms,0.0V 64.2599ms,0.0
+ 64.2600ms,3.3V 64.2625ms,3.3
+ 64.2626ms,0.0V 64.2799ms,0.0
+ 64.2800ms,3.3V 64.2825ms,3.3
+ 64.2826ms,0.0V 64.2999ms,0.0
+ 64.3000ms,3.3V 64.3025ms,3.3
+ 64.3026ms,0.0V 64.3199ms,0.0
+ 64.3200ms,3.3V 64.3225ms,3.3
+ 64.3226ms,0.0V 64.3399ms,0.0
+ 64.3400ms,3.3V 64.3425ms,3.3
+ 64.3426ms,0.0V 64.3599ms,0.0
+ 64.3600ms,3.3V 64.3625ms,3.3
+ 64.3626ms,0.0V 64.3799ms,0.0
+ 64.3800ms,3.3V 64.3825ms,3.3
+ 64.3826ms,0.0V 64.3999ms,0.0
+ 64.4000ms,3.3V 64.4025ms,3.3
+ 64.4026ms,0.0V 64.4199ms,0.0
+ 64.4200ms,3.3V 64.4225ms,3.3
+ 64.4226ms,0.0V 64.4399ms,0.0
+ 64.4400ms,3.3V 64.4425ms,3.3
+ 64.4426ms,0.0V 64.4599ms,0.0
+ 64.4600ms,3.3V 64.4625ms,3.3
+ 64.4626ms,0.0V 64.4799ms,0.0
+ 64.4800ms,3.3V 64.4825ms,3.3
+ 64.4826ms,0.0V 64.4999ms,0.0
+ 64.5000ms,3.3V 64.5025ms,3.3
+ 64.5026ms,0.0V 64.5199ms,0.0
+ 64.5200ms,3.3V 64.5225ms,3.3
+ 64.5226ms,0.0V 64.5399ms,0.0
+ 64.5400ms,3.3V 64.5425ms,3.3
+ 64.5426ms,0.0V 64.5599ms,0.0
+ 64.5600ms,3.3V 64.5625ms,3.3
+ 64.5626ms,0.0V 64.5799ms,0.0
+ 64.5800ms,3.3V 64.5825ms,3.3
+ 64.5826ms,0.0V 64.5999ms,0.0
+ 64.6000ms,3.3V 64.6025ms,3.3
+ 64.6026ms,0.0V 64.6199ms,0.0
+ 64.6200ms,3.3V 64.6225ms,3.3
+ 64.6226ms,0.0V 64.6399ms,0.0
+ 64.6400ms,3.3V 64.6425ms,3.3
+ 64.6426ms,0.0V 64.6599ms,0.0
+ 64.6600ms,3.3V 64.6625ms,3.3
+ 64.6626ms,0.0V 64.6799ms,0.0
+ 64.6800ms,3.3V 64.6825ms,3.3
+ 64.6826ms,0.0V 64.6999ms,0.0
+ 64.7000ms,3.3V 64.7025ms,3.3
+ 64.7026ms,0.0V 64.7199ms,0.0
+ 64.7200ms,3.3V 64.7225ms,3.3
+ 64.7226ms,0.0V 64.7399ms,0.0
+ 64.7400ms,3.3V 64.7425ms,3.3
+ 64.7426ms,0.0V 64.7599ms,0.0
+ 64.7600ms,3.3V 64.7625ms,3.3
+ 64.7626ms,0.0V 64.7799ms,0.0
+ 64.7800ms,3.3V 64.7825ms,3.3
+ 64.7826ms,0.0V 64.7999ms,0.0
+ 64.8000ms,3.3V 64.8025ms,3.3
+ 64.8026ms,0.0V 64.8199ms,0.0
+ 64.8200ms,3.3V 64.8225ms,3.3
+ 64.8226ms,0.0V 64.8399ms,0.0
+ 64.8400ms,3.3V 64.8425ms,3.3
+ 64.8426ms,0.0V 64.8599ms,0.0
+ 64.8600ms,3.3V 64.8625ms,3.3
+ 64.8626ms,0.0V 64.8799ms,0.0
+ 64.8800ms,3.3V 64.8825ms,3.3
+ 64.8826ms,0.0V 64.8999ms,0.0
+ 64.9000ms,3.3V 64.9025ms,3.3
+ 64.9026ms,0.0V 64.9199ms,0.0
+ 64.9200ms,3.3V 64.9225ms,3.3
+ 64.9226ms,0.0V 64.9399ms,0.0
+ 64.9400ms,3.3V 64.9425ms,3.3
+ 64.9426ms,0.0V 64.9599ms,0.0
+ 64.9600ms,3.3V 64.9625ms,3.3
+ 64.9626ms,0.0V 64.9799ms,0.0
+ 64.9800ms,3.3V 64.9825ms,3.3
+ 64.9826ms,0.0V 64.9999ms,0.0
+ 65.0000ms,3.3V 65.0025ms,3.3
+ 65.0026ms,0.0V 65.0199ms,0.0
+ 65.0200ms,3.3V 65.0225ms,3.3
+ 65.0226ms,0.0V 65.0399ms,0.0
+ 65.0400ms,3.3V 65.0425ms,3.3
+ 65.0426ms,0.0V 65.0599ms,0.0
+ 65.0600ms,3.3V 65.0625ms,3.3
+ 65.0626ms,0.0V 65.0799ms,0.0
+ 65.0800ms,3.3V 65.0825ms,3.3
+ 65.0826ms,0.0V 65.0999ms,0.0
+ 65.1000ms,3.3V 65.1025ms,3.3
+ 65.1026ms,0.0V 65.1199ms,0.0
+ 65.1200ms,3.3V 65.1227ms,3.3
+ 65.1228ms,0.0V 65.1399ms,0.0
+ 65.1400ms,3.3V 65.1427ms,3.3
+ 65.1428ms,0.0V 65.1599ms,0.0
+ 65.1600ms,3.3V 65.1627ms,3.3
+ 65.1628ms,0.0V 65.1799ms,0.0
+ 65.1800ms,3.3V 65.1827ms,3.3
+ 65.1828ms,0.0V 65.1999ms,0.0
+ 65.2000ms,3.3V 65.2027ms,3.3
+ 65.2028ms,0.0V 65.2199ms,0.0
+ 65.2200ms,3.3V 65.2227ms,3.3
+ 65.2228ms,0.0V 65.2399ms,0.0
+ 65.2400ms,3.3V 65.2427ms,3.3
+ 65.2428ms,0.0V 65.2599ms,0.0
+ 65.2600ms,3.3V 65.2627ms,3.3
+ 65.2628ms,0.0V 65.2799ms,0.0
+ 65.2800ms,3.3V 65.2827ms,3.3
+ 65.2828ms,0.0V 65.2999ms,0.0
+ 65.3000ms,3.3V 65.3027ms,3.3
+ 65.3028ms,0.0V 65.3199ms,0.0
+ 65.3200ms,3.3V 65.3227ms,3.3
+ 65.3228ms,0.0V 65.3399ms,0.0
+ 65.3400ms,3.3V 65.3427ms,3.3
+ 65.3428ms,0.0V 65.3599ms,0.0
+ 65.3600ms,3.3V 65.3627ms,3.3
+ 65.3628ms,0.0V 65.3799ms,0.0
+ 65.3800ms,3.3V 65.3827ms,3.3
+ 65.3828ms,0.0V 65.3999ms,0.0
+ 65.4000ms,3.3V 65.4027ms,3.3
+ 65.4028ms,0.0V 65.4199ms,0.0
+ 65.4200ms,3.3V 65.4227ms,3.3
+ 65.4228ms,0.0V 65.4399ms,0.0
+ 65.4400ms,3.3V 65.4427ms,3.3
+ 65.4428ms,0.0V 65.4599ms,0.0
+ 65.4600ms,3.3V 65.4627ms,3.3
+ 65.4628ms,0.0V 65.4799ms,0.0
+ 65.4800ms,3.3V 65.4827ms,3.3
+ 65.4828ms,0.0V 65.4999ms,0.0
+ 65.5000ms,3.3V 65.5027ms,3.3
+ 65.5028ms,0.0V 65.5199ms,0.0
+ 65.5200ms,3.3V 65.5227ms,3.3
+ 65.5228ms,0.0V 65.5399ms,0.0
+ 65.5400ms,3.3V 65.5427ms,3.3
+ 65.5428ms,0.0V 65.5599ms,0.0
+ 65.5600ms,3.3V 65.5627ms,3.3
+ 65.5628ms,0.0V 65.5799ms,0.0
+ 65.5800ms,3.3V 65.5827ms,3.3
+ 65.5828ms,0.0V 65.5999ms,0.0
+ 65.6000ms,3.3V 65.6027ms,3.3
+ 65.6028ms,0.0V 65.6199ms,0.0
+ 65.6200ms,3.3V 65.6227ms,3.3
+ 65.6228ms,0.0V 65.6399ms,0.0
+ 65.6400ms,3.3V 65.6427ms,3.3
+ 65.6428ms,0.0V 65.6599ms,0.0
+ 65.6600ms,3.3V 65.6627ms,3.3
+ 65.6628ms,0.0V 65.6799ms,0.0
+ 65.6800ms,3.3V 65.6827ms,3.3
+ 65.6828ms,0.0V 65.6999ms,0.0
+ 65.7000ms,3.3V 65.7027ms,3.3
+ 65.7028ms,0.0V 65.7199ms,0.0
+ 65.7200ms,3.3V 65.7227ms,3.3
+ 65.7228ms,0.0V 65.7399ms,0.0
+ 65.7400ms,3.3V 65.7427ms,3.3
+ 65.7428ms,0.0V 65.7599ms,0.0
+ 65.7600ms,3.3V 65.7627ms,3.3
+ 65.7628ms,0.0V 65.7799ms,0.0
+ 65.7800ms,3.3V 65.7827ms,3.3
+ 65.7828ms,0.0V 65.7999ms,0.0
+ 65.8000ms,3.3V 65.8027ms,3.3
+ 65.8028ms,0.0V 65.8199ms,0.0
+ 65.8200ms,3.3V 65.8227ms,3.3
+ 65.8228ms,0.0V 65.8399ms,0.0
+ 65.8400ms,3.3V 65.8427ms,3.3
+ 65.8428ms,0.0V 65.8599ms,0.0
+ 65.8600ms,3.3V 65.8627ms,3.3
+ 65.8628ms,0.0V 65.8799ms,0.0
+ 65.8800ms,3.3V 65.8827ms,3.3
+ 65.8828ms,0.0V 65.8999ms,0.0
+ 65.9000ms,3.3V 65.9027ms,3.3
+ 65.9028ms,0.0V 65.9199ms,0.0
+ 65.9200ms,3.3V 65.9227ms,3.3
+ 65.9228ms,0.0V 65.9399ms,0.0
+ 65.9400ms,3.3V 65.9427ms,3.3
+ 65.9428ms,0.0V 65.9599ms,0.0
+ 65.9600ms,3.3V 65.9627ms,3.3
+ 65.9628ms,0.0V 65.9799ms,0.0
+ 65.9800ms,3.3V 65.9827ms,3.3
+ 65.9828ms,0.0V 65.9999ms,0.0
+ 66.0000ms,3.3V 66.0027ms,3.3
+ 66.0028ms,0.0V 66.0199ms,0.0
+ 66.0200ms,3.3V 66.0227ms,3.3
+ 66.0228ms,0.0V 66.0399ms,0.0
+ 66.0400ms,3.3V 66.0427ms,3.3
+ 66.0428ms,0.0V 66.0599ms,0.0
+ 66.0600ms,3.3V 66.0627ms,3.3
+ 66.0628ms,0.0V 66.0799ms,0.0
+ 66.0800ms,3.3V 66.0827ms,3.3
+ 66.0828ms,0.0V 66.0999ms,0.0
+ 66.1000ms,3.3V 66.1027ms,3.3
+ 66.1028ms,0.0V 66.1199ms,0.0
+ 66.1200ms,3.3V 66.1227ms,3.3
+ 66.1228ms,0.0V 66.1399ms,0.0
+ 66.1400ms,3.3V 66.1427ms,3.3
+ 66.1428ms,0.0V 66.1599ms,0.0
+ 66.1600ms,3.3V 66.1627ms,3.3
+ 66.1628ms,0.0V 66.1799ms,0.0
+ 66.1800ms,3.3V 66.1827ms,3.3
+ 66.1828ms,0.0V 66.1999ms,0.0
+ 66.2000ms,3.3V 66.2027ms,3.3
+ 66.2028ms,0.0V 66.2199ms,0.0
+ 66.2200ms,3.3V 66.2227ms,3.3
+ 66.2228ms,0.0V 66.2399ms,0.0
+ 66.2400ms,3.3V 66.2427ms,3.3
+ 66.2428ms,0.0V 66.2599ms,0.0
+ 66.2600ms,3.3V 66.2627ms,3.3
+ 66.2628ms,0.0V 66.2799ms,0.0
+ 66.2800ms,3.3V 66.2827ms,3.3
+ 66.2828ms,0.0V 66.2999ms,0.0
+ 66.3000ms,3.3V 66.3027ms,3.3
+ 66.3028ms,0.0V 66.3199ms,0.0
+ 66.3200ms,3.3V 66.3227ms,3.3
+ 66.3228ms,0.0V 66.3399ms,0.0
+ 66.3400ms,3.3V 66.3427ms,3.3
+ 66.3428ms,0.0V 66.3599ms,0.0
+ 66.3600ms,3.3V 66.3627ms,3.3
+ 66.3628ms,0.0V 66.3799ms,0.0
+ 66.3800ms,3.3V 66.3827ms,3.3
+ 66.3828ms,0.0V 66.3999ms,0.0
+ 66.4000ms,3.3V 66.4027ms,3.3
+ 66.4028ms,0.0V 66.4199ms,0.0
+ 66.4200ms,3.3V 66.4227ms,3.3
+ 66.4228ms,0.0V 66.4399ms,0.0
+ 66.4400ms,3.3V 66.4427ms,3.3
+ 66.4428ms,0.0V 66.4599ms,0.0
+ 66.4600ms,3.3V 66.4627ms,3.3
+ 66.4628ms,0.0V 66.4799ms,0.0
+ 66.4800ms,3.3V 66.4827ms,3.3
+ 66.4828ms,0.0V 66.4999ms,0.0
+ 66.5000ms,3.3V 66.5027ms,3.3
+ 66.5028ms,0.0V 66.5199ms,0.0
+ 66.5200ms,3.3V 66.5227ms,3.3
+ 66.5228ms,0.0V 66.5399ms,0.0
+ 66.5400ms,3.3V 66.5427ms,3.3
+ 66.5428ms,0.0V 66.5599ms,0.0
+ 66.5600ms,3.3V 66.5627ms,3.3
+ 66.5628ms,0.0V 66.5799ms,0.0
+ 66.5800ms,3.3V 66.5827ms,3.3
+ 66.5828ms,0.0V 66.5999ms,0.0
+ 66.6000ms,3.3V 66.6027ms,3.3
+ 66.6028ms,0.0V 66.6199ms,0.0
+ 66.6200ms,3.3V 66.6227ms,3.3
+ 66.6228ms,0.0V 66.6399ms,0.0
+ 66.6400ms,3.3V 66.6427ms,3.3
+ 66.6428ms,0.0V 66.6599ms,0.0
+ 66.6600ms,3.3V 66.6627ms,3.3
+ 66.6628ms,0.0V 66.6799ms,0.0
+ 66.6800ms,3.3V 66.6827ms,3.3
+ 66.6828ms,0.0V 66.6999ms,0.0
+ 66.7000ms,3.3V 66.7027ms,3.3
+ 66.7028ms,0.0V 66.7199ms,0.0
+ 66.7200ms,3.3V 66.7227ms,3.3
+ 66.7228ms,0.0V 66.7399ms,0.0
+ 66.7400ms,3.3V 66.7427ms,3.3
+ 66.7428ms,0.0V 66.7599ms,0.0
+ 66.7600ms,3.3V 66.7627ms,3.3
+ 66.7628ms,0.0V 66.7799ms,0.0
+ 66.7800ms,3.3V 66.7827ms,3.3
+ 66.7828ms,0.0V 66.7999ms,0.0
+ 66.8000ms,3.3V 66.8027ms,3.3
+ 66.8028ms,0.0V 66.8199ms,0.0
+ 66.8200ms,3.3V 66.8227ms,3.3
+ 66.8228ms,0.0V 66.8399ms,0.0
+ 66.8400ms,3.3V 66.8427ms,3.3
+ 66.8428ms,0.0V 66.8599ms,0.0
+ 66.8600ms,3.3V 66.8627ms,3.3
+ 66.8628ms,0.0V 66.8799ms,0.0
+ 66.8800ms,3.3V 66.8827ms,3.3
+ 66.8828ms,0.0V 66.8999ms,0.0
+ 66.9000ms,3.3V 66.9027ms,3.3
+ 66.9028ms,0.0V 66.9199ms,0.0
+ 66.9200ms,3.3V 66.9227ms,3.3
+ 66.9228ms,0.0V 66.9399ms,0.0
+ 66.9400ms,3.3V 66.9427ms,3.3
+ 66.9428ms,0.0V 66.9599ms,0.0
+ 66.9600ms,3.3V 66.9627ms,3.3
+ 66.9628ms,0.0V 66.9799ms,0.0
+ 66.9800ms,3.3V 66.9827ms,3.3
+ 66.9828ms,0.0V 66.9999ms,0.0
+ 67.0000ms,3.3V 67.0027ms,3.3
+ 67.0028ms,0.0V 67.0199ms,0.0
+ 67.0200ms,3.3V 67.0227ms,3.3
+ 67.0228ms,0.0V 67.0399ms,0.0
+ 67.0400ms,3.3V 67.0427ms,3.3
+ 67.0428ms,0.0V 67.0599ms,0.0
+ 67.0600ms,3.3V 67.0627ms,3.3
+ 67.0628ms,0.0V 67.0799ms,0.0
+ 67.0800ms,3.3V 67.0827ms,3.3
+ 67.0828ms,0.0V 67.0999ms,0.0
+ 67.1000ms,3.3V 67.1027ms,3.3
+ 67.1028ms,0.0V 67.1199ms,0.0
+ 67.1200ms,3.3V 67.1227ms,3.3
+ 67.1228ms,0.0V 67.1399ms,0.0
+ 67.1400ms,3.3V 67.1427ms,3.3
+ 67.1428ms,0.0V 67.1599ms,0.0
+ 67.1600ms,3.3V 67.1627ms,3.3
+ 67.1628ms,0.0V 67.1799ms,0.0
+ 67.1800ms,3.3V 67.1827ms,3.3
+ 67.1828ms,0.0V 67.1999ms,0.0
+ 67.2000ms,3.3V 67.2027ms,3.3
+ 67.2028ms,0.0V 67.2199ms,0.0
+ 67.2200ms,3.3V 67.2227ms,3.3
+ 67.2228ms,0.0V 67.2399ms,0.0
+ 67.2400ms,3.3V 67.2427ms,3.3
+ 67.2428ms,0.0V 67.2599ms,0.0
+ 67.2600ms,3.3V 67.2627ms,3.3
+ 67.2628ms,0.0V 67.2799ms,0.0
+ 67.2800ms,3.3V 67.2827ms,3.3
+ 67.2828ms,0.0V 67.2999ms,0.0
+ 67.3000ms,3.3V 67.3027ms,3.3
+ 67.3028ms,0.0V 67.3199ms,0.0
+ 67.3200ms,3.3V 67.3227ms,3.3
+ 67.3228ms,0.0V 67.3399ms,0.0
+ 67.3400ms,3.3V 67.3427ms,3.3
+ 67.3428ms,0.0V 67.3599ms,0.0
+ 67.3600ms,3.3V 67.3627ms,3.3
+ 67.3628ms,0.0V 67.3799ms,0.0
+ 67.3800ms,3.3V 67.3827ms,3.3
+ 67.3828ms,0.0V 67.3999ms,0.0
+ 67.4000ms,3.3V 67.4027ms,3.3
+ 67.4028ms,0.0V 67.4199ms,0.0
+ 67.4200ms,3.3V 67.4227ms,3.3
+ 67.4228ms,0.0V 67.4399ms,0.0
+ 67.4400ms,3.3V 67.4427ms,3.3
+ 67.4428ms,0.0V 67.4599ms,0.0
+ 67.4600ms,3.3V 67.4627ms,3.3
+ 67.4628ms,0.0V 67.4799ms,0.0
+ 67.4800ms,3.3V 67.4827ms,3.3
+ 67.4828ms,0.0V 67.4999ms,0.0
+ 67.5000ms,3.3V 67.5027ms,3.3
+ 67.5028ms,0.0V 67.5199ms,0.0
+ 67.5200ms,3.3V 67.5227ms,3.3
+ 67.5228ms,0.0V 67.5399ms,0.0
+ 67.5400ms,3.3V 67.5427ms,3.3
+ 67.5428ms,0.0V 67.5599ms,0.0
+ 67.5600ms,3.3V 67.5627ms,3.3
+ 67.5628ms,0.0V 67.5799ms,0.0
+ 67.5800ms,3.3V 67.5827ms,3.3
+ 67.5828ms,0.0V 67.5999ms,0.0
+ 67.6000ms,3.3V 67.6027ms,3.3
+ 67.6028ms,0.0V 67.6199ms,0.0
+ 67.6200ms,3.3V 67.6227ms,3.3
+ 67.6228ms,0.0V 67.6399ms,0.0
+ 67.6400ms,3.3V 67.6427ms,3.3
+ 67.6428ms,0.0V 67.6599ms,0.0
+ 67.6600ms,3.3V 67.6627ms,3.3
+ 67.6628ms,0.0V 67.6799ms,0.0
+ 67.6800ms,3.3V 67.6827ms,3.3
+ 67.6828ms,0.0V 67.6999ms,0.0
+ 67.7000ms,3.3V 67.7027ms,3.3
+ 67.7028ms,0.0V 67.7199ms,0.0
+ 67.7200ms,3.3V 67.7227ms,3.3
+ 67.7228ms,0.0V 67.7399ms,0.0
+ 67.7400ms,3.3V 67.7427ms,3.3
+ 67.7428ms,0.0V 67.7599ms,0.0
+ 67.7600ms,3.3V 67.7627ms,3.3
+ 67.7628ms,0.0V 67.7799ms,0.0
+ 67.7800ms,3.3V 67.7827ms,3.3
+ 67.7828ms,0.0V 67.7999ms,0.0
+ 67.8000ms,3.3V 67.8027ms,3.3
+ 67.8028ms,0.0V 67.8199ms,0.0
+ 67.8200ms,3.3V 67.8227ms,3.3
+ 67.8228ms,0.0V 67.8399ms,0.0
+ 67.8400ms,3.3V 67.8427ms,3.3
+ 67.8428ms,0.0V 67.8599ms,0.0
+ 67.8600ms,3.3V 67.8627ms,3.3
+ 67.8628ms,0.0V 67.8799ms,0.0
+ 67.8800ms,3.3V 67.8827ms,3.3
+ 67.8828ms,0.0V 67.8999ms,0.0
+ 67.9000ms,3.3V 67.9027ms,3.3
+ 67.9028ms,0.0V 67.9199ms,0.0
+ 67.9200ms,3.3V 67.9227ms,3.3
+ 67.9228ms,0.0V 67.9399ms,0.0
+ 67.9400ms,3.3V 67.9427ms,3.3
+ 67.9428ms,0.0V 67.9599ms,0.0
+ 67.9600ms,3.3V 67.9627ms,3.3
+ 67.9628ms,0.0V 67.9799ms,0.0
+ 67.9800ms,3.3V 67.9827ms,3.3
+ 67.9828ms,0.0V 67.9999ms,0.0
+ 68.0000ms,3.3V 68.0027ms,3.3
+ 68.0028ms,0.0V 68.0199ms,0.0
+ 68.0200ms,3.3V 68.0227ms,3.3
+ 68.0228ms,0.0V 68.0399ms,0.0
+ 68.0400ms,3.3V 68.0427ms,3.3
+ 68.0428ms,0.0V 68.0599ms,0.0
+ 68.0600ms,3.3V 68.0627ms,3.3
+ 68.0628ms,0.0V 68.0799ms,0.0
+ 68.0800ms,3.3V 68.0827ms,3.3
+ 68.0828ms,0.0V 68.0999ms,0.0
+ 68.1000ms,3.3V 68.1027ms,3.3
+ 68.1028ms,0.0V 68.1199ms,0.0
+ 68.1200ms,3.3V 68.1227ms,3.3
+ 68.1228ms,0.0V 68.1399ms,0.0
+ 68.1400ms,3.3V 68.1427ms,3.3
+ 68.1428ms,0.0V 68.1599ms,0.0
+ 68.1600ms,3.3V 68.1627ms,3.3
+ 68.1628ms,0.0V 68.1799ms,0.0
+ 68.1800ms,3.3V 68.1827ms,3.3
+ 68.1828ms,0.0V 68.1999ms,0.0
+ 68.2000ms,3.3V 68.2027ms,3.3
+ 68.2028ms,0.0V 68.2199ms,0.0
+ 68.2200ms,3.3V 68.2227ms,3.3
+ 68.2228ms,0.0V 68.2399ms,0.0
+ 68.2400ms,3.3V 68.2427ms,3.3
+ 68.2428ms,0.0V 68.2599ms,0.0
+ 68.2600ms,3.3V 68.2627ms,3.3
+ 68.2628ms,0.0V 68.2799ms,0.0
+ 68.2800ms,3.3V 68.2827ms,3.3
+ 68.2828ms,0.0V 68.2999ms,0.0
+ 68.3000ms,3.3V 68.3027ms,3.3
+ 68.3028ms,0.0V 68.3199ms,0.0
+ 68.3200ms,3.3V 68.3227ms,3.3
+ 68.3228ms,0.0V 68.3399ms,0.0
+ 68.3400ms,3.3V 68.3427ms,3.3
+ 68.3428ms,0.0V 68.3599ms,0.0
+ 68.3600ms,3.3V 68.3627ms,3.3
+ 68.3628ms,0.0V 68.3799ms,0.0
+ 68.3800ms,3.3V 68.3827ms,3.3
+ 68.3828ms,0.0V 68.3999ms,0.0
+ 68.4000ms,3.3V 68.4027ms,3.3
+ 68.4028ms,0.0V 68.4199ms,0.0
+ 68.4200ms,3.3V 68.4227ms,3.3
+ 68.4228ms,0.0V 68.4399ms,0.0
+ 68.4400ms,3.3V 68.4427ms,3.3
+ 68.4428ms,0.0V 68.4599ms,0.0
+ 68.4600ms,3.3V 68.4627ms,3.3
+ 68.4628ms,0.0V 68.4799ms,0.0
+ 68.4800ms,3.3V 68.4827ms,3.3
+ 68.4828ms,0.0V 68.4999ms,0.0
+ 68.5000ms,3.3V 68.5027ms,3.3
+ 68.5028ms,0.0V 68.5199ms,0.0
+ 68.5200ms,3.3V 68.5227ms,3.3
+ 68.5228ms,0.0V 68.5399ms,0.0
+ 68.5400ms,3.3V 68.5427ms,3.3
+ 68.5428ms,0.0V 68.5599ms,0.0
+ 68.5600ms,3.3V 68.5627ms,3.3
+ 68.5628ms,0.0V 68.5799ms,0.0
+ 68.5800ms,3.3V 68.5827ms,3.3
+ 68.5828ms,0.0V 68.5999ms,0.0
+ 68.6000ms,3.3V 68.6027ms,3.3
+ 68.6028ms,0.0V 68.6199ms,0.0
+ 68.6200ms,3.3V 68.6227ms,3.3
+ 68.6228ms,0.0V 68.6399ms,0.0
+ 68.6400ms,3.3V 68.6427ms,3.3
+ 68.6428ms,0.0V 68.6599ms,0.0
+ 68.6600ms,3.3V 68.6627ms,3.3
+ 68.6628ms,0.0V 68.6799ms,0.0
+ 68.6800ms,3.3V 68.6827ms,3.3
+ 68.6828ms,0.0V 68.6999ms,0.0
+ 68.7000ms,3.3V 68.7027ms,3.3
+ 68.7028ms,0.0V 68.7199ms,0.0
+ 68.7200ms,3.3V 68.7227ms,3.3
+ 68.7228ms,0.0V 68.7399ms,0.0
+ 68.7400ms,3.3V 68.7427ms,3.3
+ 68.7428ms,0.0V 68.7599ms,0.0
+ 68.7600ms,3.3V 68.7627ms,3.3
+ 68.7628ms,0.0V 68.7799ms,0.0
+ 68.7800ms,3.3V 68.7827ms,3.3
+ 68.7828ms,0.0V 68.7999ms,0.0
+ 68.8000ms,3.3V 68.8027ms,3.3
+ 68.8028ms,0.0V 68.8199ms,0.0
+ 68.8200ms,3.3V 68.8227ms,3.3
+ 68.8228ms,0.0V 68.8399ms,0.0
+ 68.8400ms,3.3V 68.8427ms,3.3
+ 68.8428ms,0.0V 68.8599ms,0.0
+ 68.8600ms,3.3V 68.8627ms,3.3
+ 68.8628ms,0.0V 68.8799ms,0.0
+ 68.8800ms,3.3V 68.8827ms,3.3
+ 68.8828ms,0.0V 68.8999ms,0.0
+ 68.9000ms,3.3V 68.9027ms,3.3
+ 68.9028ms,0.0V 68.9199ms,0.0
+ 68.9200ms,3.3V 68.9227ms,3.3
+ 68.9228ms,0.0V 68.9399ms,0.0
+ 68.9400ms,3.3V 68.9427ms,3.3
+ 68.9428ms,0.0V 68.9599ms,0.0
+ 68.9600ms,3.3V 68.9627ms,3.3
+ 68.9628ms,0.0V 68.9799ms,0.0
+ 68.9800ms,3.3V 68.9827ms,3.3
+ 68.9828ms,0.0V 68.9999ms,0.0
+ 69.0000ms,3.3V 69.0027ms,3.3
+ 69.0028ms,0.0V 69.0199ms,0.0
+ 69.0200ms,3.3V 69.0227ms,3.3
+ 69.0228ms,0.0V 69.0399ms,0.0
+ 69.0400ms,3.3V 69.0427ms,3.3
+ 69.0428ms,0.0V 69.0599ms,0.0
+ 69.0600ms,3.3V 69.0627ms,3.3
+ 69.0628ms,0.0V 69.0799ms,0.0
+ 69.0800ms,3.3V 69.0827ms,3.3
+ 69.0828ms,0.0V 69.0999ms,0.0
+ 69.1000ms,3.3V 69.1027ms,3.3
+ 69.1028ms,0.0V 69.1199ms,0.0
+ 69.1200ms,3.3V 69.1227ms,3.3
+ 69.1228ms,0.0V 69.1399ms,0.0
+ 69.1400ms,3.3V 69.1427ms,3.3
+ 69.1428ms,0.0V 69.1599ms,0.0
+ 69.1600ms,3.3V 69.1627ms,3.3
+ 69.1628ms,0.0V 69.1799ms,0.0
+ 69.1800ms,3.3V 69.1827ms,3.3
+ 69.1828ms,0.0V 69.1999ms,0.0
+ 69.2000ms,3.3V 69.2027ms,3.3
+ 69.2028ms,0.0V 69.2199ms,0.0
+ 69.2200ms,3.3V 69.2227ms,3.3
+ 69.2228ms,0.0V 69.2399ms,0.0
+ 69.2400ms,3.3V 69.2427ms,3.3
+ 69.2428ms,0.0V 69.2599ms,0.0
+ 69.2600ms,3.3V 69.2627ms,3.3
+ 69.2628ms,0.0V 69.2799ms,0.0
+ 69.2800ms,3.3V 69.2827ms,3.3
+ 69.2828ms,0.0V 69.2999ms,0.0
+ 69.3000ms,3.3V 69.3027ms,3.3
+ 69.3028ms,0.0V 69.3199ms,0.0
+ 69.3200ms,3.3V 69.3227ms,3.3
+ 69.3228ms,0.0V 69.3399ms,0.0
+ 69.3400ms,3.3V 69.3427ms,3.3
+ 69.3428ms,0.0V 69.3599ms,0.0
+ 69.3600ms,3.3V 69.3627ms,3.3
+ 69.3628ms,0.0V 69.3799ms,0.0
+ 69.3800ms,3.3V 69.3827ms,3.3
+ 69.3828ms,0.0V 69.3999ms,0.0
+ 69.4000ms,3.3V 69.4027ms,3.3
+ 69.4028ms,0.0V 69.4199ms,0.0
+ 69.4200ms,3.3V 69.4227ms,3.3
+ 69.4228ms,0.0V 69.4399ms,0.0
+ 69.4400ms,3.3V 69.4427ms,3.3
+ 69.4428ms,0.0V 69.4599ms,0.0
+ 69.4600ms,3.3V 69.4627ms,3.3
+ 69.4628ms,0.0V 69.4799ms,0.0
+ 69.4800ms,3.3V 69.4827ms,3.3
+ 69.4828ms,0.0V 69.4999ms,0.0
+ 69.5000ms,3.3V 69.5027ms,3.3
+ 69.5028ms,0.0V 69.5199ms,0.0
+ 69.5200ms,3.3V 69.5227ms,3.3
+ 69.5228ms,0.0V 69.5399ms,0.0
+ 69.5400ms,3.3V 69.5427ms,3.3
+ 69.5428ms,0.0V 69.5599ms,0.0
+ 69.5600ms,3.3V 69.5627ms,3.3
+ 69.5628ms,0.0V 69.5799ms,0.0
+ 69.5800ms,3.3V 69.5827ms,3.3
+ 69.5828ms,0.0V 69.5999ms,0.0
+ 69.6000ms,3.3V 69.6027ms,3.3
+ 69.6028ms,0.0V 69.6199ms,0.0
+ 69.6200ms,3.3V 69.6227ms,3.3
+ 69.6228ms,0.0V 69.6399ms,0.0
+ 69.6400ms,3.3V 69.6427ms,3.3
+ 69.6428ms,0.0V 69.6599ms,0.0
+ 69.6600ms,3.3V 69.6627ms,3.3
+ 69.6628ms,0.0V 69.6799ms,0.0
+ 69.6800ms,3.3V 69.6827ms,3.3
+ 69.6828ms,0.0V 69.6999ms,0.0
+ 69.7000ms,3.3V 69.7027ms,3.3
+ 69.7028ms,0.0V 69.7199ms,0.0
+ 69.7200ms,3.3V 69.7227ms,3.3
+ 69.7228ms,0.0V 69.7399ms,0.0
+ 69.7400ms,3.3V 69.7427ms,3.3
+ 69.7428ms,0.0V 69.7599ms,0.0
+ 69.7600ms,3.3V 69.7627ms,3.3
+ 69.7628ms,0.0V 69.7799ms,0.0
+ 69.7800ms,3.3V 69.7827ms,3.3
+ 69.7828ms,0.0V 69.7999ms,0.0
+ 69.8000ms,3.3V 69.8027ms,3.3
+ 69.8028ms,0.0V 69.8199ms,0.0
+ 69.8200ms,3.3V 69.8227ms,3.3
+ 69.8228ms,0.0V 69.8399ms,0.0
+ 69.8400ms,3.3V 69.8427ms,3.3
+ 69.8428ms,0.0V 69.8599ms,0.0
+ 69.8600ms,3.3V 69.8627ms,3.3
+ 69.8628ms,0.0V 69.8799ms,0.0
+ 69.8800ms,3.3V 69.8827ms,3.3
+ 69.8828ms,0.0V 69.8999ms,0.0
+ 69.9000ms,3.3V 69.9027ms,3.3
+ 69.9028ms,0.0V 69.9199ms,0.0
+ 69.9200ms,3.3V 69.9227ms,3.3
+ 69.9228ms,0.0V 69.9399ms,0.0
+ 69.9400ms,3.3V 69.9427ms,3.3
+ 69.9428ms,0.0V 69.9599ms,0.0
+ 69.9600ms,3.3V 69.9627ms,3.3
+ 69.9628ms,0.0V 69.9799ms,0.0
+ 69.9800ms,3.3V 69.9827ms,3.3
+ 69.9828ms,0.0V 69.9999ms,0.0
+ 70.0000ms,3.3V 70.0027ms,3.3
+ 70.0028ms,0.0V 70.0199ms,0.0
+ 70.0200ms,3.3V 70.0227ms,3.3
+ 70.0228ms,0.0V 70.0399ms,0.0
+ 70.0400ms,3.3V 70.0427ms,3.3
+ 70.0428ms,0.0V 70.0599ms,0.0
+ 70.0600ms,3.3V 70.0627ms,3.3
+ 70.0628ms,0.0V 70.0799ms,0.0
+ 70.0800ms,3.3V 70.0827ms,3.3
+ 70.0828ms,0.0V 70.0999ms,0.0
+ 70.1000ms,3.3V 70.1027ms,3.3
+ 70.1028ms,0.0V 70.1199ms,0.0
+ 70.1200ms,3.3V 70.1227ms,3.3
+ 70.1228ms,0.0V 70.1399ms,0.0
+ 70.1400ms,3.3V 70.1429ms,3.3
+ 70.1430ms,0.0V 70.1599ms,0.0
+ 70.1600ms,3.3V 70.1629ms,3.3
+ 70.1630ms,0.0V 70.1799ms,0.0
+ 70.1800ms,3.3V 70.1829ms,3.3
+ 70.1830ms,0.0V 70.1999ms,0.0
+ 70.2000ms,3.3V 70.2029ms,3.3
+ 70.2030ms,0.0V 70.2199ms,0.0
+ 70.2200ms,3.3V 70.2229ms,3.3
+ 70.2230ms,0.0V 70.2399ms,0.0
+ 70.2400ms,3.3V 70.2429ms,3.3
+ 70.2430ms,0.0V 70.2599ms,0.0
+ 70.2600ms,3.3V 70.2629ms,3.3
+ 70.2630ms,0.0V 70.2799ms,0.0
+ 70.2800ms,3.3V 70.2829ms,3.3
+ 70.2830ms,0.0V 70.2999ms,0.0
+ 70.3000ms,3.3V 70.3029ms,3.3
+ 70.3030ms,0.0V 70.3199ms,0.0
+ 70.3200ms,3.3V 70.3229ms,3.3
+ 70.3230ms,0.0V 70.3399ms,0.0
+ 70.3400ms,3.3V 70.3429ms,3.3
+ 70.3430ms,0.0V 70.3599ms,0.0
+ 70.3600ms,3.3V 70.3629ms,3.3
+ 70.3630ms,0.0V 70.3799ms,0.0
+ 70.3800ms,3.3V 70.3829ms,3.3
+ 70.3830ms,0.0V 70.3999ms,0.0
+ 70.4000ms,3.3V 70.4029ms,3.3
+ 70.4030ms,0.0V 70.4199ms,0.0
+ 70.4200ms,3.3V 70.4229ms,3.3
+ 70.4230ms,0.0V 70.4399ms,0.0
+ 70.4400ms,3.3V 70.4429ms,3.3
+ 70.4430ms,0.0V 70.4599ms,0.0
+ 70.4600ms,3.3V 70.4629ms,3.3
+ 70.4630ms,0.0V 70.4799ms,0.0
+ 70.4800ms,3.3V 70.4829ms,3.3
+ 70.4830ms,0.0V 70.4999ms,0.0
+ 70.5000ms,3.3V 70.5029ms,3.3
+ 70.5030ms,0.0V 70.5199ms,0.0
+ 70.5200ms,3.3V 70.5229ms,3.3
+ 70.5230ms,0.0V 70.5399ms,0.0
+ 70.5400ms,3.3V 70.5429ms,3.3
+ 70.5430ms,0.0V 70.5599ms,0.0
+ 70.5600ms,3.3V 70.5629ms,3.3
+ 70.5630ms,0.0V 70.5799ms,0.0
+ 70.5800ms,3.3V 70.5829ms,3.3
+ 70.5830ms,0.0V 70.5999ms,0.0
+ 70.6000ms,3.3V 70.6029ms,3.3
+ 70.6030ms,0.0V 70.6199ms,0.0
+ 70.6200ms,3.3V 70.6229ms,3.3
+ 70.6230ms,0.0V 70.6399ms,0.0
+ 70.6400ms,3.3V 70.6429ms,3.3
+ 70.6430ms,0.0V 70.6599ms,0.0
+ 70.6600ms,3.3V 70.6629ms,3.3
+ 70.6630ms,0.0V 70.6799ms,0.0
+ 70.6800ms,3.3V 70.6829ms,3.3
+ 70.6830ms,0.0V 70.6999ms,0.0
+ 70.7000ms,3.3V 70.7029ms,3.3
+ 70.7030ms,0.0V 70.7199ms,0.0
+ 70.7200ms,3.3V 70.7229ms,3.3
+ 70.7230ms,0.0V 70.7399ms,0.0
+ 70.7400ms,3.3V 70.7429ms,3.3
+ 70.7430ms,0.0V 70.7599ms,0.0
+ 70.7600ms,3.3V 70.7629ms,3.3
+ 70.7630ms,0.0V 70.7799ms,0.0
+ 70.7800ms,3.3V 70.7829ms,3.3
+ 70.7830ms,0.0V 70.7999ms,0.0
+ 70.8000ms,3.3V 70.8029ms,3.3
+ 70.8030ms,0.0V 70.8199ms,0.0
+ 70.8200ms,3.3V 70.8229ms,3.3
+ 70.8230ms,0.0V 70.8399ms,0.0
+ 70.8400ms,3.3V 70.8429ms,3.3
+ 70.8430ms,0.0V 70.8599ms,0.0
+ 70.8600ms,3.3V 70.8629ms,3.3
+ 70.8630ms,0.0V 70.8799ms,0.0
+ 70.8800ms,3.3V 70.8829ms,3.3
+ 70.8830ms,0.0V 70.8999ms,0.0
+ 70.9000ms,3.3V 70.9029ms,3.3
+ 70.9030ms,0.0V 70.9199ms,0.0
+ 70.9200ms,3.3V 70.9229ms,3.3
+ 70.9230ms,0.0V 70.9399ms,0.0
+ 70.9400ms,3.3V 70.9429ms,3.3
+ 70.9430ms,0.0V 70.9599ms,0.0
+ 70.9600ms,3.3V 70.9629ms,3.3
+ 70.9630ms,0.0V 70.9799ms,0.0
+ 70.9800ms,3.3V 70.9829ms,3.3
+ 70.9830ms,0.0V 70.9999ms,0.0
+ 71.0000ms,3.3V 71.0029ms,3.3
+ 71.0030ms,0.0V 71.0199ms,0.0
+ 71.0200ms,3.3V 71.0229ms,3.3
+ 71.0230ms,0.0V 71.0399ms,0.0
+ 71.0400ms,3.3V 71.0429ms,3.3
+ 71.0430ms,0.0V 71.0599ms,0.0
+ 71.0600ms,3.3V 71.0629ms,3.3
+ 71.0630ms,0.0V 71.0799ms,0.0
+ 71.0800ms,3.3V 71.0829ms,3.3
+ 71.0830ms,0.0V 71.0999ms,0.0
+ 71.1000ms,3.3V 71.1029ms,3.3
+ 71.1030ms,0.0V 71.1199ms,0.0
+ 71.1200ms,3.3V 71.1229ms,3.3
+ 71.1230ms,0.0V 71.1399ms,0.0
+ 71.1400ms,3.3V 71.1429ms,3.3
+ 71.1430ms,0.0V 71.1599ms,0.0
+ 71.1600ms,3.3V 71.1629ms,3.3
+ 71.1630ms,0.0V 71.1799ms,0.0
+ 71.1800ms,3.3V 71.1829ms,3.3
+ 71.1830ms,0.0V 71.1999ms,0.0
+ 71.2000ms,3.3V 71.2029ms,3.3
+ 71.2030ms,0.0V 71.2199ms,0.0
+ 71.2200ms,3.3V 71.2229ms,3.3
+ 71.2230ms,0.0V 71.2399ms,0.0
+ 71.2400ms,3.3V 71.2429ms,3.3
+ 71.2430ms,0.0V 71.2599ms,0.0
+ 71.2600ms,3.3V 71.2629ms,3.3
+ 71.2630ms,0.0V 71.2799ms,0.0
+ 71.2800ms,3.3V 71.2829ms,3.3
+ 71.2830ms,0.0V 71.2999ms,0.0
+ 71.3000ms,3.3V 71.3029ms,3.3
+ 71.3030ms,0.0V 71.3199ms,0.0
+ 71.3200ms,3.3V 71.3229ms,3.3
+ 71.3230ms,0.0V 71.3399ms,0.0
+ 71.3400ms,3.3V 71.3429ms,3.3
+ 71.3430ms,0.0V 71.3599ms,0.0
+ 71.3600ms,3.3V 71.3629ms,3.3
+ 71.3630ms,0.0V 71.3799ms,0.0
+ 71.3800ms,3.3V 71.3829ms,3.3
+ 71.3830ms,0.0V 71.3999ms,0.0
+ 71.4000ms,3.3V 71.4029ms,3.3
+ 71.4030ms,0.0V 71.4199ms,0.0
+ 71.4200ms,3.3V 71.4229ms,3.3
+ 71.4230ms,0.0V 71.4399ms,0.0
+ 71.4400ms,3.3V 71.4429ms,3.3
+ 71.4430ms,0.0V 71.4599ms,0.0
+ 71.4600ms,3.3V 71.4629ms,3.3
+ 71.4630ms,0.0V 71.4799ms,0.0
+ 71.4800ms,3.3V 71.4829ms,3.3
+ 71.4830ms,0.0V 71.4999ms,0.0
+ 71.5000ms,3.3V 71.5029ms,3.3
+ 71.5030ms,0.0V 71.5199ms,0.0
+ 71.5200ms,3.3V 71.5229ms,3.3
+ 71.5230ms,0.0V 71.5399ms,0.0
+ 71.5400ms,3.3V 71.5429ms,3.3
+ 71.5430ms,0.0V 71.5599ms,0.0
+ 71.5600ms,3.3V 71.5629ms,3.3
+ 71.5630ms,0.0V 71.5799ms,0.0
+ 71.5800ms,3.3V 71.5829ms,3.3
+ 71.5830ms,0.0V 71.5999ms,0.0
+ 71.6000ms,3.3V 71.6029ms,3.3
+ 71.6030ms,0.0V 71.6199ms,0.0
+ 71.6200ms,3.3V 71.6229ms,3.3
+ 71.6230ms,0.0V 71.6399ms,0.0
+ 71.6400ms,3.3V 71.6429ms,3.3
+ 71.6430ms,0.0V 71.6599ms,0.0
+ 71.6600ms,3.3V 71.6629ms,3.3
+ 71.6630ms,0.0V 71.6799ms,0.0
+ 71.6800ms,3.3V 71.6829ms,3.3
+ 71.6830ms,0.0V 71.6999ms,0.0
+ 71.7000ms,3.3V 71.7029ms,3.3
+ 71.7030ms,0.0V 71.7199ms,0.0
+ 71.7200ms,3.3V 71.7229ms,3.3
+ 71.7230ms,0.0V 71.7399ms,0.0
+ 71.7400ms,3.3V 71.7429ms,3.3
+ 71.7430ms,0.0V 71.7599ms,0.0
+ 71.7600ms,3.3V 71.7629ms,3.3
+ 71.7630ms,0.0V 71.7799ms,0.0
+ 71.7800ms,3.3V 71.7829ms,3.3
+ 71.7830ms,0.0V 71.7999ms,0.0
+ 71.8000ms,3.3V 71.8029ms,3.3
+ 71.8030ms,0.0V 71.8199ms,0.0
+ 71.8200ms,3.3V 71.8229ms,3.3
+ 71.8230ms,0.0V 71.8399ms,0.0
+ 71.8400ms,3.3V 71.8429ms,3.3
+ 71.8430ms,0.0V 71.8599ms,0.0
+ 71.8600ms,3.3V 71.8629ms,3.3
+ 71.8630ms,0.0V 71.8799ms,0.0
+ 71.8800ms,3.3V 71.8829ms,3.3
+ 71.8830ms,0.0V 71.8999ms,0.0
+ 71.9000ms,3.3V 71.9029ms,3.3
+ 71.9030ms,0.0V 71.9199ms,0.0
+ 71.9200ms,3.3V 71.9229ms,3.3
+ 71.9230ms,0.0V 71.9399ms,0.0
+ 71.9400ms,3.3V 71.9429ms,3.3
+ 71.9430ms,0.0V 71.9599ms,0.0
+ 71.9600ms,3.3V 71.9629ms,3.3
+ 71.9630ms,0.0V 71.9799ms,0.0
+ 71.9800ms,3.3V 71.9829ms,3.3
+ 71.9830ms,0.0V 71.9999ms,0.0
+ 72.0000ms,3.3V 72.0029ms,3.3
+ 72.0030ms,0.0V 72.0199ms,0.0
+ 72.0200ms,3.3V 72.0229ms,3.3
+ 72.0230ms,0.0V 72.0399ms,0.0
+ 72.0400ms,3.3V 72.0429ms,3.3
+ 72.0430ms,0.0V 72.0599ms,0.0
+ 72.0600ms,3.3V 72.0629ms,3.3
+ 72.0630ms,0.0V 72.0799ms,0.0
+ 72.0800ms,3.3V 72.0829ms,3.3
+ 72.0830ms,0.0V 72.0999ms,0.0
+ 72.1000ms,3.3V 72.1029ms,3.3
+ 72.1030ms,0.0V 72.1199ms,0.0
+ 72.1200ms,3.3V 72.1229ms,3.3
+ 72.1230ms,0.0V 72.1399ms,0.0
+ 72.1400ms,3.3V 72.1429ms,3.3
+ 72.1430ms,0.0V 72.1599ms,0.0
+ 72.1600ms,3.3V 72.1629ms,3.3
+ 72.1630ms,0.0V 72.1799ms,0.0
+ 72.1800ms,3.3V 72.1829ms,3.3
+ 72.1830ms,0.0V 72.1999ms,0.0
+ 72.2000ms,3.3V 72.2029ms,3.3
+ 72.2030ms,0.0V 72.2199ms,0.0
+ 72.2200ms,3.3V 72.2229ms,3.3
+ 72.2230ms,0.0V 72.2399ms,0.0
+ 72.2400ms,3.3V 72.2429ms,3.3
+ 72.2430ms,0.0V 72.2599ms,0.0
+ 72.2600ms,3.3V 72.2629ms,3.3
+ 72.2630ms,0.0V 72.2799ms,0.0
+ 72.2800ms,3.3V 72.2829ms,3.3
+ 72.2830ms,0.0V 72.2999ms,0.0
+ 72.3000ms,3.3V 72.3029ms,3.3
+ 72.3030ms,0.0V 72.3199ms,0.0
+ 72.3200ms,3.3V 72.3229ms,3.3
+ 72.3230ms,0.0V 72.3399ms,0.0
+ 72.3400ms,3.3V 72.3429ms,3.3
+ 72.3430ms,0.0V 72.3599ms,0.0
+ 72.3600ms,3.3V 72.3629ms,3.3
+ 72.3630ms,0.0V 72.3799ms,0.0
+ 72.3800ms,3.3V 72.3829ms,3.3
+ 72.3830ms,0.0V 72.3999ms,0.0
+ 72.4000ms,3.3V 72.4029ms,3.3
+ 72.4030ms,0.0V 72.4199ms,0.0
+ 72.4200ms,3.3V 72.4229ms,3.3
+ 72.4230ms,0.0V 72.4399ms,0.0
+ 72.4400ms,3.3V 72.4429ms,3.3
+ 72.4430ms,0.0V 72.4599ms,0.0
+ 72.4600ms,3.3V 72.4629ms,3.3
+ 72.4630ms,0.0V 72.4799ms,0.0
+ 72.4800ms,3.3V 72.4829ms,3.3
+ 72.4830ms,0.0V 72.4999ms,0.0
+ 72.5000ms,3.3V 72.5029ms,3.3
+ 72.5030ms,0.0V 72.5199ms,0.0
+ 72.5200ms,3.3V 72.5229ms,3.3
+ 72.5230ms,0.0V 72.5399ms,0.0
+ 72.5400ms,3.3V 72.5429ms,3.3
+ 72.5430ms,0.0V 72.5599ms,0.0
+ 72.5600ms,3.3V 72.5629ms,3.3
+ 72.5630ms,0.0V 72.5799ms,0.0
+ 72.5800ms,3.3V 72.5829ms,3.3
+ 72.5830ms,0.0V 72.5999ms,0.0
+ 72.6000ms,3.3V 72.6029ms,3.3
+ 72.6030ms,0.0V 72.6199ms,0.0
+ 72.6200ms,3.3V 72.6229ms,3.3
+ 72.6230ms,0.0V 72.6399ms,0.0
+ 72.6400ms,3.3V 72.6429ms,3.3
+ 72.6430ms,0.0V 72.6599ms,0.0
+ 72.6600ms,3.3V 72.6629ms,3.3
+ 72.6630ms,0.0V 72.6799ms,0.0
+ 72.6800ms,3.3V 72.6829ms,3.3
+ 72.6830ms,0.0V 72.6999ms,0.0
+ 72.7000ms,3.3V 72.7029ms,3.3
+ 72.7030ms,0.0V 72.7199ms,0.0
+ 72.7200ms,3.3V 72.7229ms,3.3
+ 72.7230ms,0.0V 72.7399ms,0.0
+ 72.7400ms,3.3V 72.7429ms,3.3
+ 72.7430ms,0.0V 72.7599ms,0.0
+ 72.7600ms,3.3V 72.7629ms,3.3
+ 72.7630ms,0.0V 72.7799ms,0.0
+ 72.7800ms,3.3V 72.7829ms,3.3
+ 72.7830ms,0.0V 72.7999ms,0.0
+ 72.8000ms,3.3V 72.8029ms,3.3
+ 72.8030ms,0.0V 72.8199ms,0.0
+ 72.8200ms,3.3V 72.8229ms,3.3
+ 72.8230ms,0.0V 72.8399ms,0.0
+ 72.8400ms,3.3V 72.8429ms,3.3
+ 72.8430ms,0.0V 72.8599ms,0.0
+ 72.8600ms,3.3V 72.8629ms,3.3
+ 72.8630ms,0.0V 72.8799ms,0.0
+ 72.8800ms,3.3V 72.8829ms,3.3
+ 72.8830ms,0.0V 72.8999ms,0.0
+ 72.9000ms,3.3V 72.9029ms,3.3
+ 72.9030ms,0.0V 72.9199ms,0.0
+ 72.9200ms,3.3V 72.9229ms,3.3
+ 72.9230ms,0.0V 72.9399ms,0.0
+ 72.9400ms,3.3V 72.9429ms,3.3
+ 72.9430ms,0.0V 72.9599ms,0.0
+ 72.9600ms,3.3V 72.9629ms,3.3
+ 72.9630ms,0.0V 72.9799ms,0.0
+ 72.9800ms,3.3V 72.9829ms,3.3
+ 72.9830ms,0.0V 72.9999ms,0.0
+ 73.0000ms,3.3V 73.0029ms,3.3
+ 73.0030ms,0.0V 73.0199ms,0.0
+ 73.0200ms,3.3V 73.0229ms,3.3
+ 73.0230ms,0.0V 73.0399ms,0.0
+ 73.0400ms,3.3V 73.0429ms,3.3
+ 73.0430ms,0.0V 73.0599ms,0.0
+ 73.0600ms,3.3V 73.0629ms,3.3
+ 73.0630ms,0.0V 73.0799ms,0.0
+ 73.0800ms,3.3V 73.0829ms,3.3
+ 73.0830ms,0.0V 73.0999ms,0.0
+ 73.1000ms,3.3V 73.1029ms,3.3
+ 73.1030ms,0.0V 73.1199ms,0.0
+ 73.1200ms,3.3V 73.1229ms,3.3
+ 73.1230ms,0.0V 73.1399ms,0.0
+ 73.1400ms,3.3V 73.1429ms,3.3
+ 73.1430ms,0.0V 73.1599ms,0.0
+ 73.1600ms,3.3V 73.1629ms,3.3
+ 73.1630ms,0.0V 73.1799ms,0.0
+ 73.1800ms,3.3V 73.1829ms,3.3
+ 73.1830ms,0.0V 73.1999ms,0.0
+ 73.2000ms,3.3V 73.2029ms,3.3
+ 73.2030ms,0.0V 73.2199ms,0.0
+ 73.2200ms,3.3V 73.2229ms,3.3
+ 73.2230ms,0.0V 73.2399ms,0.0
+ 73.2400ms,3.3V 73.2429ms,3.3
+ 73.2430ms,0.0V 73.2599ms,0.0
+ 73.2600ms,3.3V 73.2629ms,3.3
+ 73.2630ms,0.0V 73.2799ms,0.0
+ 73.2800ms,3.3V 73.2829ms,3.3
+ 73.2830ms,0.0V 73.2999ms,0.0
+ 73.3000ms,3.3V 73.3029ms,3.3
+ 73.3030ms,0.0V 73.3199ms,0.0
+ 73.3200ms,3.3V 73.3229ms,3.3
+ 73.3230ms,0.0V 73.3399ms,0.0
+ 73.3400ms,3.3V 73.3429ms,3.3
+ 73.3430ms,0.0V 73.3599ms,0.0
+ 73.3600ms,3.3V 73.3629ms,3.3
+ 73.3630ms,0.0V 73.3799ms,0.0
+ 73.3800ms,3.3V 73.3829ms,3.3
+ 73.3830ms,0.0V 73.3999ms,0.0
+ 73.4000ms,3.3V 73.4029ms,3.3
+ 73.4030ms,0.0V 73.4199ms,0.0
+ 73.4200ms,3.3V 73.4229ms,3.3
+ 73.4230ms,0.0V 73.4399ms,0.0
+ 73.4400ms,3.3V 73.4429ms,3.3
+ 73.4430ms,0.0V 73.4599ms,0.0
+ 73.4600ms,3.3V 73.4629ms,3.3
+ 73.4630ms,0.0V 73.4799ms,0.0
+ 73.4800ms,3.3V 73.4829ms,3.3
+ 73.4830ms,0.0V 73.4999ms,0.0
+ 73.5000ms,3.3V 73.5029ms,3.3
+ 73.5030ms,0.0V 73.5199ms,0.0
+ 73.5200ms,3.3V 73.5229ms,3.3
+ 73.5230ms,0.0V 73.5399ms,0.0
+ 73.5400ms,3.3V 73.5429ms,3.3
+ 73.5430ms,0.0V 73.5599ms,0.0
+ 73.5600ms,3.3V 73.5629ms,3.3
+ 73.5630ms,0.0V 73.5799ms,0.0
+ 73.5800ms,3.3V 73.5829ms,3.3
+ 73.5830ms,0.0V 73.5999ms,0.0
+ 73.6000ms,3.3V 73.6029ms,3.3
+ 73.6030ms,0.0V 73.6199ms,0.0
+ 73.6200ms,3.3V 73.6229ms,3.3
+ 73.6230ms,0.0V 73.6399ms,0.0
+ 73.6400ms,3.3V 73.6429ms,3.3
+ 73.6430ms,0.0V 73.6599ms,0.0
+ 73.6600ms,3.3V 73.6629ms,3.3
+ 73.6630ms,0.0V 73.6799ms,0.0
+ 73.6800ms,3.3V 73.6829ms,3.3
+ 73.6830ms,0.0V 73.6999ms,0.0
+ 73.7000ms,3.3V 73.7029ms,3.3
+ 73.7030ms,0.0V 73.7199ms,0.0
+ 73.7200ms,3.3V 73.7229ms,3.3
+ 73.7230ms,0.0V 73.7399ms,0.0
+ 73.7400ms,3.3V 73.7429ms,3.3
+ 73.7430ms,0.0V 73.7599ms,0.0
+ 73.7600ms,3.3V 73.7629ms,3.3
+ 73.7630ms,0.0V 73.7799ms,0.0
+ 73.7800ms,3.3V 73.7829ms,3.3
+ 73.7830ms,0.0V 73.7999ms,0.0
+ 73.8000ms,3.3V 73.8029ms,3.3
+ 73.8030ms,0.0V 73.8199ms,0.0
+ 73.8200ms,3.3V 73.8229ms,3.3
+ 73.8230ms,0.0V 73.8399ms,0.0
+ 73.8400ms,3.3V 73.8429ms,3.3
+ 73.8430ms,0.0V 73.8599ms,0.0
+ 73.8600ms,3.3V 73.8629ms,3.3
+ 73.8630ms,0.0V 73.8799ms,0.0
+ 73.8800ms,3.3V 73.8829ms,3.3
+ 73.8830ms,0.0V 73.8999ms,0.0
+ 73.9000ms,3.3V 73.9029ms,3.3
+ 73.9030ms,0.0V 73.9199ms,0.0
+ 73.9200ms,3.3V 73.9229ms,3.3
+ 73.9230ms,0.0V 73.9399ms,0.0
+ 73.9400ms,3.3V 73.9429ms,3.3
+ 73.9430ms,0.0V 73.9599ms,0.0
+ 73.9600ms,3.3V 73.9629ms,3.3
+ 73.9630ms,0.0V 73.9799ms,0.0
+ 73.9800ms,3.3V 73.9829ms,3.3
+ 73.9830ms,0.0V 73.9999ms,0.0
+ 74.0000ms,3.3V 74.0029ms,3.3
+ 74.0030ms,0.0V 74.0199ms,0.0
+ 74.0200ms,3.3V 74.0229ms,3.3
+ 74.0230ms,0.0V 74.0399ms,0.0
+ 74.0400ms,3.3V 74.0429ms,3.3
+ 74.0430ms,0.0V 74.0599ms,0.0
+ 74.0600ms,3.3V 74.0629ms,3.3
+ 74.0630ms,0.0V 74.0799ms,0.0
+ 74.0800ms,3.3V 74.0829ms,3.3
+ 74.0830ms,0.0V 74.0999ms,0.0
+ 74.1000ms,3.3V 74.1029ms,3.3
+ 74.1030ms,0.0V 74.1199ms,0.0
+ 74.1200ms,3.3V 74.1229ms,3.3
+ 74.1230ms,0.0V 74.1399ms,0.0
+ 74.1400ms,3.3V 74.1429ms,3.3
+ 74.1430ms,0.0V 74.1599ms,0.0
+ 74.1600ms,3.3V 74.1629ms,3.3
+ 74.1630ms,0.0V 74.1799ms,0.0
+ 74.1800ms,3.3V 74.1829ms,3.3
+ 74.1830ms,0.0V 74.1999ms,0.0
+ 74.2000ms,3.3V 74.2029ms,3.3
+ 74.2030ms,0.0V 74.2199ms,0.0
+ 74.2200ms,3.3V 74.2229ms,3.3
+ 74.2230ms,0.0V 74.2399ms,0.0
+ 74.2400ms,3.3V 74.2429ms,3.3
+ 74.2430ms,0.0V 74.2599ms,0.0
+ 74.2600ms,3.3V 74.2629ms,3.3
+ 74.2630ms,0.0V 74.2799ms,0.0
+ 74.2800ms,3.3V 74.2829ms,3.3
+ 74.2830ms,0.0V 74.2999ms,0.0
+ 74.3000ms,3.3V 74.3029ms,3.3
+ 74.3030ms,0.0V 74.3199ms,0.0
+ 74.3200ms,3.3V 74.3229ms,3.3
+ 74.3230ms,0.0V 74.3399ms,0.0
+ 74.3400ms,3.3V 74.3429ms,3.3
+ 74.3430ms,0.0V 74.3599ms,0.0
+ 74.3600ms,3.3V 74.3629ms,3.3
+ 74.3630ms,0.0V 74.3799ms,0.0
+ 74.3800ms,3.3V 74.3829ms,3.3
+ 74.3830ms,0.0V 74.3999ms,0.0
+ 74.4000ms,3.3V 74.4029ms,3.3
+ 74.4030ms,0.0V 74.4199ms,0.0
+ 74.4200ms,3.3V 74.4229ms,3.3
+ 74.4230ms,0.0V 74.4399ms,0.0
+ 74.4400ms,3.3V 74.4429ms,3.3
+ 74.4430ms,0.0V 74.4599ms,0.0
+ 74.4600ms,3.3V 74.4629ms,3.3
+ 74.4630ms,0.0V 74.4799ms,0.0
+ 74.4800ms,3.3V 74.4829ms,3.3
+ 74.4830ms,0.0V 74.4999ms,0.0
+ 74.5000ms,3.3V 74.5029ms,3.3
+ 74.5030ms,0.0V 74.5199ms,0.0
+ 74.5200ms,3.3V 74.5229ms,3.3
+ 74.5230ms,0.0V 74.5399ms,0.0
+ 74.5400ms,3.3V 74.5429ms,3.3
+ 74.5430ms,0.0V 74.5599ms,0.0
+ 74.5600ms,3.3V 74.5629ms,3.3
+ 74.5630ms,0.0V 74.5799ms,0.0
+ 74.5800ms,3.3V 74.5829ms,3.3
+ 74.5830ms,0.0V 74.5999ms,0.0
+ 74.6000ms,3.3V 74.6029ms,3.3
+ 74.6030ms,0.0V 74.6199ms,0.0
+ 74.6200ms,3.3V 74.6229ms,3.3
+ 74.6230ms,0.0V 74.6399ms,0.0
+ 74.6400ms,3.3V 74.6429ms,3.3
+ 74.6430ms,0.0V 74.6599ms,0.0
+ 74.6600ms,3.3V 74.6629ms,3.3
+ 74.6630ms,0.0V 74.6799ms,0.0
+ 74.6800ms,3.3V 74.6829ms,3.3
+ 74.6830ms,0.0V 74.6999ms,0.0
+ 74.7000ms,3.3V 74.7029ms,3.3
+ 74.7030ms,0.0V 74.7199ms,0.0
+ 74.7200ms,3.3V 74.7229ms,3.3
+ 74.7230ms,0.0V 74.7399ms,0.0
+ 74.7400ms,3.3V 74.7429ms,3.3
+ 74.7430ms,0.0V 74.7599ms,0.0
+ 74.7600ms,3.3V 74.7629ms,3.3
+ 74.7630ms,0.0V 74.7799ms,0.0
+ 74.7800ms,3.3V 74.7829ms,3.3
+ 74.7830ms,0.0V 74.7999ms,0.0
+ 74.8000ms,3.3V 74.8029ms,3.3
+ 74.8030ms,0.0V 74.8199ms,0.0
+ 74.8200ms,3.3V 74.8229ms,3.3
+ 74.8230ms,0.0V 74.8399ms,0.0
+ 74.8400ms,3.3V 74.8429ms,3.3
+ 74.8430ms,0.0V 74.8599ms,0.0
+ 74.8600ms,3.3V 74.8629ms,3.3
+ 74.8630ms,0.0V 74.8799ms,0.0
+ 74.8800ms,3.3V 74.8829ms,3.3
+ 74.8830ms,0.0V 74.8999ms,0.0
+ 74.9000ms,3.3V 74.9029ms,3.3
+ 74.9030ms,0.0V 74.9199ms,0.0
+ 74.9200ms,3.3V 74.9229ms,3.3
+ 74.9230ms,0.0V 74.9399ms,0.0
+ 74.9400ms,3.3V 74.9429ms,3.3
+ 74.9430ms,0.0V 74.9599ms,0.0
+ 74.9600ms,3.3V 74.9629ms,3.3
+ 74.9630ms,0.0V 74.9799ms,0.0
+ 74.9800ms,3.3V 74.9829ms,3.3
+ 74.9830ms,0.0V 74.9999ms,0.0
+ 75.0000ms,3.3V 75.0029ms,3.3
+ 75.0030ms,0.0V 75.0199ms,0.0
+ 75.0200ms,3.3V 75.0229ms,3.3
+ 75.0230ms,0.0V 75.0399ms,0.0
+ 75.0400ms,3.3V 75.0429ms,3.3
+ 75.0430ms,0.0V 75.0599ms,0.0
+ 75.0600ms,3.3V 75.0629ms,3.3
+ 75.0630ms,0.0V 75.0799ms,0.0
+ 75.0800ms,3.3V 75.0829ms,3.3
+ 75.0830ms,0.0V 75.0999ms,0.0
+ 75.1000ms,3.3V 75.1029ms,3.3
+ 75.1030ms,0.0V 75.1199ms,0.0
+ 75.1200ms,3.3V 75.1229ms,3.3
+ 75.1230ms,0.0V 75.1399ms,0.0
+ 75.1400ms,3.3V 75.1429ms,3.3
+ 75.1430ms,0.0V 75.1599ms,0.0
+ 75.1600ms,3.3V 75.1631ms,3.3
+ 75.1632ms,0.0V 75.1799ms,0.0
+ 75.1800ms,3.3V 75.1831ms,3.3
+ 75.1832ms,0.0V 75.1999ms,0.0
+ 75.2000ms,3.3V 75.2031ms,3.3
+ 75.2032ms,0.0V 75.2199ms,0.0
+ 75.2200ms,3.3V 75.2231ms,3.3
+ 75.2232ms,0.0V 75.2399ms,0.0
+ 75.2400ms,3.3V 75.2431ms,3.3
+ 75.2432ms,0.0V 75.2599ms,0.0
+ 75.2600ms,3.3V 75.2631ms,3.3
+ 75.2632ms,0.0V 75.2799ms,0.0
+ 75.2800ms,3.3V 75.2831ms,3.3
+ 75.2832ms,0.0V 75.2999ms,0.0
+ 75.3000ms,3.3V 75.3031ms,3.3
+ 75.3032ms,0.0V 75.3199ms,0.0
+ 75.3200ms,3.3V 75.3231ms,3.3
+ 75.3232ms,0.0V 75.3399ms,0.0
+ 75.3400ms,3.3V 75.3431ms,3.3
+ 75.3432ms,0.0V 75.3599ms,0.0
+ 75.3600ms,3.3V 75.3631ms,3.3
+ 75.3632ms,0.0V 75.3799ms,0.0
+ 75.3800ms,3.3V 75.3831ms,3.3
+ 75.3832ms,0.0V 75.3999ms,0.0
+ 75.4000ms,3.3V 75.4031ms,3.3
+ 75.4032ms,0.0V 75.4199ms,0.0
+ 75.4200ms,3.3V 75.4231ms,3.3
+ 75.4232ms,0.0V 75.4399ms,0.0
+ 75.4400ms,3.3V 75.4431ms,3.3
+ 75.4432ms,0.0V 75.4599ms,0.0
+ 75.4600ms,3.3V 75.4631ms,3.3
+ 75.4632ms,0.0V 75.4799ms,0.0
+ 75.4800ms,3.3V 75.4831ms,3.3
+ 75.4832ms,0.0V 75.4999ms,0.0
+ 75.5000ms,3.3V 75.5031ms,3.3
+ 75.5032ms,0.0V 75.5199ms,0.0
+ 75.5200ms,3.3V 75.5231ms,3.3
+ 75.5232ms,0.0V 75.5399ms,0.0
+ 75.5400ms,3.3V 75.5431ms,3.3
+ 75.5432ms,0.0V 75.5599ms,0.0
+ 75.5600ms,3.3V 75.5631ms,3.3
+ 75.5632ms,0.0V 75.5799ms,0.0
+ 75.5800ms,3.3V 75.5831ms,3.3
+ 75.5832ms,0.0V 75.5999ms,0.0
+ 75.6000ms,3.3V 75.6031ms,3.3
+ 75.6032ms,0.0V 75.6199ms,0.0
+ 75.6200ms,3.3V 75.6231ms,3.3
+ 75.6232ms,0.0V 75.6399ms,0.0
+ 75.6400ms,3.3V 75.6431ms,3.3
+ 75.6432ms,0.0V 75.6599ms,0.0
+ 75.6600ms,3.3V 75.6631ms,3.3
+ 75.6632ms,0.0V 75.6799ms,0.0
+ 75.6800ms,3.3V 75.6831ms,3.3
+ 75.6832ms,0.0V 75.6999ms,0.0
+ 75.7000ms,3.3V 75.7031ms,3.3
+ 75.7032ms,0.0V 75.7199ms,0.0
+ 75.7200ms,3.3V 75.7231ms,3.3
+ 75.7232ms,0.0V 75.7399ms,0.0
+ 75.7400ms,3.3V 75.7431ms,3.3
+ 75.7432ms,0.0V 75.7599ms,0.0
+ 75.7600ms,3.3V 75.7631ms,3.3
+ 75.7632ms,0.0V 75.7799ms,0.0
+ 75.7800ms,3.3V 75.7831ms,3.3
+ 75.7832ms,0.0V 75.7999ms,0.0
+ 75.8000ms,3.3V 75.8031ms,3.3
+ 75.8032ms,0.0V 75.8199ms,0.0
+ 75.8200ms,3.3V 75.8231ms,3.3
+ 75.8232ms,0.0V 75.8399ms,0.0
+ 75.8400ms,3.3V 75.8431ms,3.3
+ 75.8432ms,0.0V 75.8599ms,0.0
+ 75.8600ms,3.3V 75.8631ms,3.3
+ 75.8632ms,0.0V 75.8799ms,0.0
+ 75.8800ms,3.3V 75.8831ms,3.3
+ 75.8832ms,0.0V 75.8999ms,0.0
+ 75.9000ms,3.3V 75.9031ms,3.3
+ 75.9032ms,0.0V 75.9199ms,0.0
+ 75.9200ms,3.3V 75.9231ms,3.3
+ 75.9232ms,0.0V 75.9399ms,0.0
+ 75.9400ms,3.3V 75.9431ms,3.3
+ 75.9432ms,0.0V 75.9599ms,0.0
+ 75.9600ms,3.3V 75.9631ms,3.3
+ 75.9632ms,0.0V 75.9799ms,0.0
+ 75.9800ms,3.3V 75.9831ms,3.3
+ 75.9832ms,0.0V 75.9999ms,0.0
+ 76.0000ms,3.3V 76.0031ms,3.3
+ 76.0032ms,0.0V 76.0199ms,0.0
+ 76.0200ms,3.3V 76.0231ms,3.3
+ 76.0232ms,0.0V 76.0399ms,0.0
+ 76.0400ms,3.3V 76.0431ms,3.3
+ 76.0432ms,0.0V 76.0599ms,0.0
+ 76.0600ms,3.3V 76.0631ms,3.3
+ 76.0632ms,0.0V 76.0799ms,0.0
+ 76.0800ms,3.3V 76.0831ms,3.3
+ 76.0832ms,0.0V 76.0999ms,0.0
+ 76.1000ms,3.3V 76.1031ms,3.3
+ 76.1032ms,0.0V 76.1199ms,0.0
+ 76.1200ms,3.3V 76.1231ms,3.3
+ 76.1232ms,0.0V 76.1399ms,0.0
+ 76.1400ms,3.3V 76.1431ms,3.3
+ 76.1432ms,0.0V 76.1599ms,0.0
+ 76.1600ms,3.3V 76.1631ms,3.3
+ 76.1632ms,0.0V 76.1799ms,0.0
+ 76.1800ms,3.3V 76.1831ms,3.3
+ 76.1832ms,0.0V 76.1999ms,0.0
+ 76.2000ms,3.3V 76.2031ms,3.3
+ 76.2032ms,0.0V 76.2199ms,0.0
+ 76.2200ms,3.3V 76.2231ms,3.3
+ 76.2232ms,0.0V 76.2399ms,0.0
+ 76.2400ms,3.3V 76.2431ms,3.3
+ 76.2432ms,0.0V 76.2599ms,0.0
+ 76.2600ms,3.3V 76.2631ms,3.3
+ 76.2632ms,0.0V 76.2799ms,0.0
+ 76.2800ms,3.3V 76.2831ms,3.3
+ 76.2832ms,0.0V 76.2999ms,0.0
+ 76.3000ms,3.3V 76.3031ms,3.3
+ 76.3032ms,0.0V 76.3199ms,0.0
+ 76.3200ms,3.3V 76.3231ms,3.3
+ 76.3232ms,0.0V 76.3399ms,0.0
+ 76.3400ms,3.3V 76.3431ms,3.3
+ 76.3432ms,0.0V 76.3599ms,0.0
+ 76.3600ms,3.3V 76.3631ms,3.3
+ 76.3632ms,0.0V 76.3799ms,0.0
+ 76.3800ms,3.3V 76.3831ms,3.3
+ 76.3832ms,0.0V 76.3999ms,0.0
+ 76.4000ms,3.3V 76.4031ms,3.3
+ 76.4032ms,0.0V 76.4199ms,0.0
+ 76.4200ms,3.3V 76.4231ms,3.3
+ 76.4232ms,0.0V 76.4399ms,0.0
+ 76.4400ms,3.3V 76.4431ms,3.3
+ 76.4432ms,0.0V 76.4599ms,0.0
+ 76.4600ms,3.3V 76.4631ms,3.3
+ 76.4632ms,0.0V 76.4799ms,0.0
+ 76.4800ms,3.3V 76.4831ms,3.3
+ 76.4832ms,0.0V 76.4999ms,0.0
+ 76.5000ms,3.3V 76.5031ms,3.3
+ 76.5032ms,0.0V 76.5199ms,0.0
+ 76.5200ms,3.3V 76.5231ms,3.3
+ 76.5232ms,0.0V 76.5399ms,0.0
+ 76.5400ms,3.3V 76.5431ms,3.3
+ 76.5432ms,0.0V 76.5599ms,0.0
+ 76.5600ms,3.3V 76.5631ms,3.3
+ 76.5632ms,0.0V 76.5799ms,0.0
+ 76.5800ms,3.3V 76.5831ms,3.3
+ 76.5832ms,0.0V 76.5999ms,0.0
+ 76.6000ms,3.3V 76.6031ms,3.3
+ 76.6032ms,0.0V 76.6199ms,0.0
+ 76.6200ms,3.3V 76.6231ms,3.3
+ 76.6232ms,0.0V 76.6399ms,0.0
+ 76.6400ms,3.3V 76.6431ms,3.3
+ 76.6432ms,0.0V 76.6599ms,0.0
+ 76.6600ms,3.3V 76.6631ms,3.3
+ 76.6632ms,0.0V 76.6799ms,0.0
+ 76.6800ms,3.3V 76.6831ms,3.3
+ 76.6832ms,0.0V 76.6999ms,0.0
+ 76.7000ms,3.3V 76.7031ms,3.3
+ 76.7032ms,0.0V 76.7199ms,0.0
+ 76.7200ms,3.3V 76.7231ms,3.3
+ 76.7232ms,0.0V 76.7399ms,0.0
+ 76.7400ms,3.3V 76.7431ms,3.3
+ 76.7432ms,0.0V 76.7599ms,0.0
+ 76.7600ms,3.3V 76.7631ms,3.3
+ 76.7632ms,0.0V 76.7799ms,0.0
+ 76.7800ms,3.3V 76.7831ms,3.3
+ 76.7832ms,0.0V 76.7999ms,0.0
+ 76.8000ms,3.3V 76.8031ms,3.3
+ 76.8032ms,0.0V 76.8199ms,0.0
+ 76.8200ms,3.3V 76.8231ms,3.3
+ 76.8232ms,0.0V 76.8399ms,0.0
+ 76.8400ms,3.3V 76.8431ms,3.3
+ 76.8432ms,0.0V 76.8599ms,0.0
+ 76.8600ms,3.3V 76.8631ms,3.3
+ 76.8632ms,0.0V 76.8799ms,0.0
+ 76.8800ms,3.3V 76.8831ms,3.3
+ 76.8832ms,0.0V 76.8999ms,0.0
+ 76.9000ms,3.3V 76.9031ms,3.3
+ 76.9032ms,0.0V 76.9199ms,0.0
+ 76.9200ms,3.3V 76.9231ms,3.3
+ 76.9232ms,0.0V 76.9399ms,0.0
+ 76.9400ms,3.3V 76.9431ms,3.3
+ 76.9432ms,0.0V 76.9599ms,0.0
+ 76.9600ms,3.3V 76.9631ms,3.3
+ 76.9632ms,0.0V 76.9799ms,0.0
+ 76.9800ms,3.3V 76.9831ms,3.3
+ 76.9832ms,0.0V 76.9999ms,0.0
+ 77.0000ms,3.3V 77.0031ms,3.3
+ 77.0032ms,0.0V 77.0199ms,0.0
+ 77.0200ms,3.3V 77.0231ms,3.3
+ 77.0232ms,0.0V 77.0399ms,0.0
+ 77.0400ms,3.3V 77.0431ms,3.3
+ 77.0432ms,0.0V 77.0599ms,0.0
+ 77.0600ms,3.3V 77.0631ms,3.3
+ 77.0632ms,0.0V 77.0799ms,0.0
+ 77.0800ms,3.3V 77.0831ms,3.3
+ 77.0832ms,0.0V 77.0999ms,0.0
+ 77.1000ms,3.3V 77.1031ms,3.3
+ 77.1032ms,0.0V 77.1199ms,0.0
+ 77.1200ms,3.3V 77.1231ms,3.3
+ 77.1232ms,0.0V 77.1399ms,0.0
+ 77.1400ms,3.3V 77.1431ms,3.3
+ 77.1432ms,0.0V 77.1599ms,0.0
+ 77.1600ms,3.3V 77.1631ms,3.3
+ 77.1632ms,0.0V 77.1799ms,0.0
+ 77.1800ms,3.3V 77.1831ms,3.3
+ 77.1832ms,0.0V 77.1999ms,0.0
+ 77.2000ms,3.3V 77.2031ms,3.3
+ 77.2032ms,0.0V 77.2199ms,0.0
+ 77.2200ms,3.3V 77.2231ms,3.3
+ 77.2232ms,0.0V 77.2399ms,0.0
+ 77.2400ms,3.3V 77.2431ms,3.3
+ 77.2432ms,0.0V 77.2599ms,0.0
+ 77.2600ms,3.3V 77.2631ms,3.3
+ 77.2632ms,0.0V 77.2799ms,0.0
+ 77.2800ms,3.3V 77.2831ms,3.3
+ 77.2832ms,0.0V 77.2999ms,0.0
+ 77.3000ms,3.3V 77.3031ms,3.3
+ 77.3032ms,0.0V 77.3199ms,0.0
+ 77.3200ms,3.3V 77.3231ms,3.3
+ 77.3232ms,0.0V 77.3399ms,0.0
+ 77.3400ms,3.3V 77.3431ms,3.3
+ 77.3432ms,0.0V 77.3599ms,0.0
+ 77.3600ms,3.3V 77.3631ms,3.3
+ 77.3632ms,0.0V 77.3799ms,0.0
+ 77.3800ms,3.3V 77.3831ms,3.3
+ 77.3832ms,0.0V 77.3999ms,0.0
+ 77.4000ms,3.3V 77.4031ms,3.3
+ 77.4032ms,0.0V 77.4199ms,0.0
+ 77.4200ms,3.3V 77.4231ms,3.3
+ 77.4232ms,0.0V 77.4399ms,0.0
+ 77.4400ms,3.3V 77.4431ms,3.3
+ 77.4432ms,0.0V 77.4599ms,0.0
+ 77.4600ms,3.3V 77.4631ms,3.3
+ 77.4632ms,0.0V 77.4799ms,0.0
+ 77.4800ms,3.3V 77.4831ms,3.3
+ 77.4832ms,0.0V 77.4999ms,0.0
+ 77.5000ms,3.3V 77.5031ms,3.3
+ 77.5032ms,0.0V 77.5199ms,0.0
+ 77.5200ms,3.3V 77.5231ms,3.3
+ 77.5232ms,0.0V 77.5399ms,0.0
+ 77.5400ms,3.3V 77.5431ms,3.3
+ 77.5432ms,0.0V 77.5599ms,0.0
+ 77.5600ms,3.3V 77.5631ms,3.3
+ 77.5632ms,0.0V 77.5799ms,0.0
+ 77.5800ms,3.3V 77.5831ms,3.3
+ 77.5832ms,0.0V 77.5999ms,0.0
+ 77.6000ms,3.3V 77.6031ms,3.3
+ 77.6032ms,0.0V 77.6199ms,0.0
+ 77.6200ms,3.3V 77.6231ms,3.3
+ 77.6232ms,0.0V 77.6399ms,0.0
+ 77.6400ms,3.3V 77.6431ms,3.3
+ 77.6432ms,0.0V 77.6599ms,0.0
+ 77.6600ms,3.3V 77.6631ms,3.3
+ 77.6632ms,0.0V 77.6799ms,0.0
+ 77.6800ms,3.3V 77.6831ms,3.3
+ 77.6832ms,0.0V 77.6999ms,0.0
+ 77.7000ms,3.3V 77.7031ms,3.3
+ 77.7032ms,0.0V 77.7199ms,0.0
+ 77.7200ms,3.3V 77.7231ms,3.3
+ 77.7232ms,0.0V 77.7399ms,0.0
+ 77.7400ms,3.3V 77.7431ms,3.3
+ 77.7432ms,0.0V 77.7599ms,0.0
+ 77.7600ms,3.3V 77.7631ms,3.3
+ 77.7632ms,0.0V 77.7799ms,0.0
+ 77.7800ms,3.3V 77.7831ms,3.3
+ 77.7832ms,0.0V 77.7999ms,0.0
+ 77.8000ms,3.3V 77.8031ms,3.3
+ 77.8032ms,0.0V 77.8199ms,0.0
+ 77.8200ms,3.3V 77.8231ms,3.3
+ 77.8232ms,0.0V 77.8399ms,0.0
+ 77.8400ms,3.3V 77.8431ms,3.3
+ 77.8432ms,0.0V 77.8599ms,0.0
+ 77.8600ms,3.3V 77.8631ms,3.3
+ 77.8632ms,0.0V 77.8799ms,0.0
+ 77.8800ms,3.3V 77.8831ms,3.3
+ 77.8832ms,0.0V 77.8999ms,0.0
+ 77.9000ms,3.3V 77.9031ms,3.3
+ 77.9032ms,0.0V 77.9199ms,0.0
+ 77.9200ms,3.3V 77.9231ms,3.3
+ 77.9232ms,0.0V 77.9399ms,0.0
+ 77.9400ms,3.3V 77.9431ms,3.3
+ 77.9432ms,0.0V 77.9599ms,0.0
+ 77.9600ms,3.3V 77.9631ms,3.3
+ 77.9632ms,0.0V 77.9799ms,0.0
+ 77.9800ms,3.3V 77.9831ms,3.3
+ 77.9832ms,0.0V 77.9999ms,0.0
+ 78.0000ms,3.3V 78.0031ms,3.3
+ 78.0032ms,0.0V 78.0199ms,0.0
+ 78.0200ms,3.3V 78.0231ms,3.3
+ 78.0232ms,0.0V 78.0399ms,0.0
+ 78.0400ms,3.3V 78.0431ms,3.3
+ 78.0432ms,0.0V 78.0599ms,0.0
+ 78.0600ms,3.3V 78.0631ms,3.3
+ 78.0632ms,0.0V 78.0799ms,0.0
+ 78.0800ms,3.3V 78.0831ms,3.3
+ 78.0832ms,0.0V 78.0999ms,0.0
+ 78.1000ms,3.3V 78.1031ms,3.3
+ 78.1032ms,0.0V 78.1199ms,0.0
+ 78.1200ms,3.3V 78.1231ms,3.3
+ 78.1232ms,0.0V 78.1399ms,0.0
+ 78.1400ms,3.3V 78.1431ms,3.3
+ 78.1432ms,0.0V 78.1599ms,0.0
+ 78.1600ms,3.3V 78.1631ms,3.3
+ 78.1632ms,0.0V 78.1799ms,0.0
+ 78.1800ms,3.3V 78.1831ms,3.3
+ 78.1832ms,0.0V 78.1999ms,0.0
+ 78.2000ms,3.3V 78.2031ms,3.3
+ 78.2032ms,0.0V 78.2199ms,0.0
+ 78.2200ms,3.3V 78.2231ms,3.3
+ 78.2232ms,0.0V 78.2399ms,0.0
+ 78.2400ms,3.3V 78.2431ms,3.3
+ 78.2432ms,0.0V 78.2599ms,0.0
+ 78.2600ms,3.3V 78.2631ms,3.3
+ 78.2632ms,0.0V 78.2799ms,0.0
+ 78.2800ms,3.3V 78.2831ms,3.3
+ 78.2832ms,0.0V 78.2999ms,0.0
+ 78.3000ms,3.3V 78.3031ms,3.3
+ 78.3032ms,0.0V 78.3199ms,0.0
+ 78.3200ms,3.3V 78.3231ms,3.3
+ 78.3232ms,0.0V 78.3399ms,0.0
+ 78.3400ms,3.3V 78.3431ms,3.3
+ 78.3432ms,0.0V 78.3599ms,0.0
+ 78.3600ms,3.3V 78.3631ms,3.3
+ 78.3632ms,0.0V 78.3799ms,0.0
+ 78.3800ms,3.3V 78.3831ms,3.3
+ 78.3832ms,0.0V 78.3999ms,0.0
+ 78.4000ms,3.3V 78.4031ms,3.3
+ 78.4032ms,0.0V 78.4199ms,0.0
+ 78.4200ms,3.3V 78.4231ms,3.3
+ 78.4232ms,0.0V 78.4399ms,0.0
+ 78.4400ms,3.3V 78.4431ms,3.3
+ 78.4432ms,0.0V 78.4599ms,0.0
+ 78.4600ms,3.3V 78.4631ms,3.3
+ 78.4632ms,0.0V 78.4799ms,0.0
+ 78.4800ms,3.3V 78.4831ms,3.3
+ 78.4832ms,0.0V 78.4999ms,0.0
+ 78.5000ms,3.3V 78.5031ms,3.3
+ 78.5032ms,0.0V 78.5199ms,0.0
+ 78.5200ms,3.3V 78.5231ms,3.3
+ 78.5232ms,0.0V 78.5399ms,0.0
+ 78.5400ms,3.3V 78.5431ms,3.3
+ 78.5432ms,0.0V 78.5599ms,0.0
+ 78.5600ms,3.3V 78.5631ms,3.3
+ 78.5632ms,0.0V 78.5799ms,0.0
+ 78.5800ms,3.3V 78.5831ms,3.3
+ 78.5832ms,0.0V 78.5999ms,0.0
+ 78.6000ms,3.3V 78.6031ms,3.3
+ 78.6032ms,0.0V 78.6199ms,0.0
+ 78.6200ms,3.3V 78.6231ms,3.3
+ 78.6232ms,0.0V 78.6399ms,0.0
+ 78.6400ms,3.3V 78.6431ms,3.3
+ 78.6432ms,0.0V 78.6599ms,0.0
+ 78.6600ms,3.3V 78.6631ms,3.3
+ 78.6632ms,0.0V 78.6799ms,0.0
+ 78.6800ms,3.3V 78.6831ms,3.3
+ 78.6832ms,0.0V 78.6999ms,0.0
+ 78.7000ms,3.3V 78.7031ms,3.3
+ 78.7032ms,0.0V 78.7199ms,0.0
+ 78.7200ms,3.3V 78.7231ms,3.3
+ 78.7232ms,0.0V 78.7399ms,0.0
+ 78.7400ms,3.3V 78.7431ms,3.3
+ 78.7432ms,0.0V 78.7599ms,0.0
+ 78.7600ms,3.3V 78.7631ms,3.3
+ 78.7632ms,0.0V 78.7799ms,0.0
+ 78.7800ms,3.3V 78.7831ms,3.3
+ 78.7832ms,0.0V 78.7999ms,0.0
+ 78.8000ms,3.3V 78.8031ms,3.3
+ 78.8032ms,0.0V 78.8199ms,0.0
+ 78.8200ms,3.3V 78.8231ms,3.3
+ 78.8232ms,0.0V 78.8399ms,0.0
+ 78.8400ms,3.3V 78.8431ms,3.3
+ 78.8432ms,0.0V 78.8599ms,0.0
+ 78.8600ms,3.3V 78.8631ms,3.3
+ 78.8632ms,0.0V 78.8799ms,0.0
+ 78.8800ms,3.3V 78.8831ms,3.3
+ 78.8832ms,0.0V 78.8999ms,0.0
+ 78.9000ms,3.3V 78.9031ms,3.3
+ 78.9032ms,0.0V 78.9199ms,0.0
+ 78.9200ms,3.3V 78.9231ms,3.3
+ 78.9232ms,0.0V 78.9399ms,0.0
+ 78.9400ms,3.3V 78.9431ms,3.3
+ 78.9432ms,0.0V 78.9599ms,0.0
+ 78.9600ms,3.3V 78.9631ms,3.3
+ 78.9632ms,0.0V 78.9799ms,0.0
+ 78.9800ms,3.3V 78.9831ms,3.3
+ 78.9832ms,0.0V 78.9999ms,0.0
+ 79.0000ms,3.3V 79.0031ms,3.3
+ 79.0032ms,0.0V 79.0199ms,0.0
+ 79.0200ms,3.3V 79.0231ms,3.3
+ 79.0232ms,0.0V 79.0399ms,0.0
+ 79.0400ms,3.3V 79.0431ms,3.3
+ 79.0432ms,0.0V 79.0599ms,0.0
+ 79.0600ms,3.3V 79.0631ms,3.3
+ 79.0632ms,0.0V 79.0799ms,0.0
+ 79.0800ms,3.3V 79.0831ms,3.3
+ 79.0832ms,0.0V 79.0999ms,0.0
+ 79.1000ms,3.3V 79.1031ms,3.3
+ 79.1032ms,0.0V 79.1199ms,0.0
+ 79.1200ms,3.3V 79.1231ms,3.3
+ 79.1232ms,0.0V 79.1399ms,0.0
+ 79.1400ms,3.3V 79.1431ms,3.3
+ 79.1432ms,0.0V 79.1599ms,0.0
+ 79.1600ms,3.3V 79.1631ms,3.3
+ 79.1632ms,0.0V 79.1799ms,0.0
+ 79.1800ms,3.3V 79.1831ms,3.3
+ 79.1832ms,0.0V 79.1999ms,0.0
+ 79.2000ms,3.3V 79.2031ms,3.3
+ 79.2032ms,0.0V 79.2199ms,0.0
+ 79.2200ms,3.3V 79.2231ms,3.3
+ 79.2232ms,0.0V 79.2399ms,0.0
+ 79.2400ms,3.3V 79.2431ms,3.3
+ 79.2432ms,0.0V 79.2599ms,0.0
+ 79.2600ms,3.3V 79.2631ms,3.3
+ 79.2632ms,0.0V 79.2799ms,0.0
+ 79.2800ms,3.3V 79.2831ms,3.3
+ 79.2832ms,0.0V 79.2999ms,0.0
+ 79.3000ms,3.3V 79.3031ms,3.3
+ 79.3032ms,0.0V 79.3199ms,0.0
+ 79.3200ms,3.3V 79.3231ms,3.3
+ 79.3232ms,0.0V 79.3399ms,0.0
+ 79.3400ms,3.3V 79.3431ms,3.3
+ 79.3432ms,0.0V 79.3599ms,0.0
+ 79.3600ms,3.3V 79.3631ms,3.3
+ 79.3632ms,0.0V 79.3799ms,0.0
+ 79.3800ms,3.3V 79.3831ms,3.3
+ 79.3832ms,0.0V 79.3999ms,0.0
+ 79.4000ms,3.3V 79.4031ms,3.3
+ 79.4032ms,0.0V 79.4199ms,0.0
+ 79.4200ms,3.3V 79.4231ms,3.3
+ 79.4232ms,0.0V 79.4399ms,0.0
+ 79.4400ms,3.3V 79.4431ms,3.3
+ 79.4432ms,0.0V 79.4599ms,0.0
+ 79.4600ms,3.3V 79.4631ms,3.3
+ 79.4632ms,0.0V 79.4799ms,0.0
+ 79.4800ms,3.3V 79.4831ms,3.3
+ 79.4832ms,0.0V 79.4999ms,0.0
+ 79.5000ms,3.3V 79.5031ms,3.3
+ 79.5032ms,0.0V 79.5199ms,0.0
+ 79.5200ms,3.3V 79.5231ms,3.3
+ 79.5232ms,0.0V 79.5399ms,0.0
+ 79.5400ms,3.3V 79.5431ms,3.3
+ 79.5432ms,0.0V 79.5599ms,0.0
+ 79.5600ms,3.3V 79.5631ms,3.3
+ 79.5632ms,0.0V 79.5799ms,0.0
+ 79.5800ms,3.3V 79.5831ms,3.3
+ 79.5832ms,0.0V 79.5999ms,0.0
+ 79.6000ms,3.3V 79.6031ms,3.3
+ 79.6032ms,0.0V 79.6199ms,0.0
+ 79.6200ms,3.3V 79.6231ms,3.3
+ 79.6232ms,0.0V 79.6399ms,0.0
+ 79.6400ms,3.3V 79.6431ms,3.3
+ 79.6432ms,0.0V 79.6599ms,0.0
+ 79.6600ms,3.3V 79.6631ms,3.3
+ 79.6632ms,0.0V 79.6799ms,0.0
+ 79.6800ms,3.3V 79.6831ms,3.3
+ 79.6832ms,0.0V 79.6999ms,0.0
+ 79.7000ms,3.3V 79.7031ms,3.3
+ 79.7032ms,0.0V 79.7199ms,0.0
+ 79.7200ms,3.3V 79.7231ms,3.3
+ 79.7232ms,0.0V 79.7399ms,0.0
+ 79.7400ms,3.3V 79.7431ms,3.3
+ 79.7432ms,0.0V 79.7599ms,0.0
+ 79.7600ms,3.3V 79.7631ms,3.3
+ 79.7632ms,0.0V 79.7799ms,0.0
+ 79.7800ms,3.3V 79.7831ms,3.3
+ 79.7832ms,0.0V 79.7999ms,0.0
+ 79.8000ms,3.3V 79.8031ms,3.3
+ 79.8032ms,0.0V 79.8199ms,0.0
+ 79.8200ms,3.3V 79.8231ms,3.3
+ 79.8232ms,0.0V 79.8399ms,0.0
+ 79.8400ms,3.3V 79.8431ms,3.3
+ 79.8432ms,0.0V 79.8599ms,0.0
+ 79.8600ms,3.3V 79.8631ms,3.3
+ 79.8632ms,0.0V 79.8799ms,0.0
+ 79.8800ms,3.3V 79.8831ms,3.3
+ 79.8832ms,0.0V 79.8999ms,0.0
+ 79.9000ms,3.3V 79.9031ms,3.3
+ 79.9032ms,0.0V 79.9199ms,0.0
+ 79.9200ms,3.3V 79.9231ms,3.3
+ 79.9232ms,0.0V 79.9399ms,0.0
+ 79.9400ms,3.3V 79.9431ms,3.3
+ 79.9432ms,0.0V 79.9599ms,0.0
+ 79.9600ms,3.3V 79.9631ms,3.3
+ 79.9632ms,0.0V 79.9799ms,0.0
+ 79.9800ms,3.3V 79.9831ms,3.3
+ 79.9832ms,0.0V 79.9999ms,0.0
+ 80.0000ms,3.3V 80.0031ms,3.3
+ 80.0032ms,0.0V 80.0199ms,0.0
+ 80.0200ms,3.3V 80.0231ms,3.3
+ 80.0232ms,0.0V 80.0399ms,0.0
+ 80.0400ms,3.3V 80.0431ms,3.3
+ 80.0432ms,0.0V 80.0599ms,0.0
+ 80.0600ms,3.3V 80.0631ms,3.3
+ 80.0632ms,0.0V 80.0799ms,0.0
+ 80.0800ms,3.3V 80.0831ms,3.3
+ 80.0832ms,0.0V 80.0999ms,0.0
+ 80.1000ms,3.3V 80.1031ms,3.3
+ 80.1032ms,0.0V 80.1199ms,0.0
+ 80.1200ms,3.3V 80.1231ms,3.3
+ 80.1232ms,0.0V 80.1399ms,0.0
+ 80.1400ms,3.3V 80.1431ms,3.3
+ 80.1432ms,0.0V 80.1599ms,0.0
+ 80.1600ms,3.3V 80.1631ms,3.3
+ 80.1632ms,0.0V 80.1799ms,0.0
+ 80.1800ms,3.3V 80.1833ms,3.3
+ 80.1834ms,0.0V 80.1999ms,0.0
+ 80.2000ms,3.3V 80.2033ms,3.3
+ 80.2034ms,0.0V 80.2199ms,0.0
+ 80.2200ms,3.3V 80.2233ms,3.3
+ 80.2234ms,0.0V 80.2399ms,0.0
+ 80.2400ms,3.3V 80.2433ms,3.3
+ 80.2434ms,0.0V 80.2599ms,0.0
+ 80.2600ms,3.3V 80.2633ms,3.3
+ 80.2634ms,0.0V 80.2799ms,0.0
+ 80.2800ms,3.3V 80.2833ms,3.3
+ 80.2834ms,0.0V 80.2999ms,0.0
+ 80.3000ms,3.3V 80.3033ms,3.3
+ 80.3034ms,0.0V 80.3199ms,0.0
+ 80.3200ms,3.3V 80.3233ms,3.3
+ 80.3234ms,0.0V 80.3399ms,0.0
+ 80.3400ms,3.3V 80.3433ms,3.3
+ 80.3434ms,0.0V 80.3599ms,0.0
+ 80.3600ms,3.3V 80.3633ms,3.3
+ 80.3634ms,0.0V 80.3799ms,0.0
+ 80.3800ms,3.3V 80.3833ms,3.3
+ 80.3834ms,0.0V 80.3999ms,0.0
+ 80.4000ms,3.3V 80.4033ms,3.3
+ 80.4034ms,0.0V 80.4199ms,0.0
+ 80.4200ms,3.3V 80.4233ms,3.3
+ 80.4234ms,0.0V 80.4399ms,0.0
+ 80.4400ms,3.3V 80.4433ms,3.3
+ 80.4434ms,0.0V 80.4599ms,0.0
+ 80.4600ms,3.3V 80.4633ms,3.3
+ 80.4634ms,0.0V 80.4799ms,0.0
+ 80.4800ms,3.3V 80.4833ms,3.3
+ 80.4834ms,0.0V 80.4999ms,0.0
+ 80.5000ms,3.3V 80.5033ms,3.3
+ 80.5034ms,0.0V 80.5199ms,0.0
+ 80.5200ms,3.3V 80.5233ms,3.3
+ 80.5234ms,0.0V 80.5399ms,0.0
+ 80.5400ms,3.3V 80.5433ms,3.3
+ 80.5434ms,0.0V 80.5599ms,0.0
+ 80.5600ms,3.3V 80.5633ms,3.3
+ 80.5634ms,0.0V 80.5799ms,0.0
+ 80.5800ms,3.3V 80.5833ms,3.3
+ 80.5834ms,0.0V 80.5999ms,0.0
+ 80.6000ms,3.3V 80.6033ms,3.3
+ 80.6034ms,0.0V 80.6199ms,0.0
+ 80.6200ms,3.3V 80.6233ms,3.3
+ 80.6234ms,0.0V 80.6399ms,0.0
+ 80.6400ms,3.3V 80.6433ms,3.3
+ 80.6434ms,0.0V 80.6599ms,0.0
+ 80.6600ms,3.3V 80.6633ms,3.3
+ 80.6634ms,0.0V 80.6799ms,0.0
+ 80.6800ms,3.3V 80.6833ms,3.3
+ 80.6834ms,0.0V 80.6999ms,0.0
+ 80.7000ms,3.3V 80.7033ms,3.3
+ 80.7034ms,0.0V 80.7199ms,0.0
+ 80.7200ms,3.3V 80.7233ms,3.3
+ 80.7234ms,0.0V 80.7399ms,0.0
+ 80.7400ms,3.3V 80.7433ms,3.3
+ 80.7434ms,0.0V 80.7599ms,0.0
+ 80.7600ms,3.3V 80.7633ms,3.3
+ 80.7634ms,0.0V 80.7799ms,0.0
+ 80.7800ms,3.3V 80.7833ms,3.3
+ 80.7834ms,0.0V 80.7999ms,0.0
+ 80.8000ms,3.3V 80.8033ms,3.3
+ 80.8034ms,0.0V 80.8199ms,0.0
+ 80.8200ms,3.3V 80.8233ms,3.3
+ 80.8234ms,0.0V 80.8399ms,0.0
+ 80.8400ms,3.3V 80.8433ms,3.3
+ 80.8434ms,0.0V 80.8599ms,0.0
+ 80.8600ms,3.3V 80.8633ms,3.3
+ 80.8634ms,0.0V 80.8799ms,0.0
+ 80.8800ms,3.3V 80.8833ms,3.3
+ 80.8834ms,0.0V 80.8999ms,0.0
+ 80.9000ms,3.3V 80.9033ms,3.3
+ 80.9034ms,0.0V 80.9199ms,0.0
+ 80.9200ms,3.3V 80.9233ms,3.3
+ 80.9234ms,0.0V 80.9399ms,0.0
+ 80.9400ms,3.3V 80.9433ms,3.3
+ 80.9434ms,0.0V 80.9599ms,0.0
+ 80.9600ms,3.3V 80.9633ms,3.3
+ 80.9634ms,0.0V 80.9799ms,0.0
+ 80.9800ms,3.3V 80.9833ms,3.3
+ 80.9834ms,0.0V 80.9999ms,0.0
+ 81.0000ms,3.3V 81.0033ms,3.3
+ 81.0034ms,0.0V 81.0199ms,0.0
+ 81.0200ms,3.3V 81.0233ms,3.3
+ 81.0234ms,0.0V 81.0399ms,0.0
+ 81.0400ms,3.3V 81.0433ms,3.3
+ 81.0434ms,0.0V 81.0599ms,0.0
+ 81.0600ms,3.3V 81.0633ms,3.3
+ 81.0634ms,0.0V 81.0799ms,0.0
+ 81.0800ms,3.3V 81.0833ms,3.3
+ 81.0834ms,0.0V 81.0999ms,0.0
+ 81.1000ms,3.3V 81.1033ms,3.3
+ 81.1034ms,0.0V 81.1199ms,0.0
+ 81.1200ms,3.3V 81.1233ms,3.3
+ 81.1234ms,0.0V 81.1399ms,0.0
+ 81.1400ms,3.3V 81.1433ms,3.3
+ 81.1434ms,0.0V 81.1599ms,0.0
+ 81.1600ms,3.3V 81.1633ms,3.3
+ 81.1634ms,0.0V 81.1799ms,0.0
+ 81.1800ms,3.3V 81.1833ms,3.3
+ 81.1834ms,0.0V 81.1999ms,0.0
+ 81.2000ms,3.3V 81.2033ms,3.3
+ 81.2034ms,0.0V 81.2199ms,0.0
+ 81.2200ms,3.3V 81.2233ms,3.3
+ 81.2234ms,0.0V 81.2399ms,0.0
+ 81.2400ms,3.3V 81.2433ms,3.3
+ 81.2434ms,0.0V 81.2599ms,0.0
+ 81.2600ms,3.3V 81.2633ms,3.3
+ 81.2634ms,0.0V 81.2799ms,0.0
+ 81.2800ms,3.3V 81.2833ms,3.3
+ 81.2834ms,0.0V 81.2999ms,0.0
+ 81.3000ms,3.3V 81.3033ms,3.3
+ 81.3034ms,0.0V 81.3199ms,0.0
+ 81.3200ms,3.3V 81.3233ms,3.3
+ 81.3234ms,0.0V 81.3399ms,0.0
+ 81.3400ms,3.3V 81.3433ms,3.3
+ 81.3434ms,0.0V 81.3599ms,0.0
+ 81.3600ms,3.3V 81.3633ms,3.3
+ 81.3634ms,0.0V 81.3799ms,0.0
+ 81.3800ms,3.3V 81.3833ms,3.3
+ 81.3834ms,0.0V 81.3999ms,0.0
+ 81.4000ms,3.3V 81.4033ms,3.3
+ 81.4034ms,0.0V 81.4199ms,0.0
+ 81.4200ms,3.3V 81.4233ms,3.3
+ 81.4234ms,0.0V 81.4399ms,0.0
+ 81.4400ms,3.3V 81.4433ms,3.3
+ 81.4434ms,0.0V 81.4599ms,0.0
+ 81.4600ms,3.3V 81.4633ms,3.3
+ 81.4634ms,0.0V 81.4799ms,0.0
+ 81.4800ms,3.3V 81.4833ms,3.3
+ 81.4834ms,0.0V 81.4999ms,0.0
+ 81.5000ms,3.3V 81.5033ms,3.3
+ 81.5034ms,0.0V 81.5199ms,0.0
+ 81.5200ms,3.3V 81.5233ms,3.3
+ 81.5234ms,0.0V 81.5399ms,0.0
+ 81.5400ms,3.3V 81.5433ms,3.3
+ 81.5434ms,0.0V 81.5599ms,0.0
+ 81.5600ms,3.3V 81.5633ms,3.3
+ 81.5634ms,0.0V 81.5799ms,0.0
+ 81.5800ms,3.3V 81.5833ms,3.3
+ 81.5834ms,0.0V 81.5999ms,0.0
+ 81.6000ms,3.3V 81.6033ms,3.3
+ 81.6034ms,0.0V 81.6199ms,0.0
+ 81.6200ms,3.3V 81.6233ms,3.3
+ 81.6234ms,0.0V 81.6399ms,0.0
+ 81.6400ms,3.3V 81.6433ms,3.3
+ 81.6434ms,0.0V 81.6599ms,0.0
+ 81.6600ms,3.3V 81.6633ms,3.3
+ 81.6634ms,0.0V 81.6799ms,0.0
+ 81.6800ms,3.3V 81.6833ms,3.3
+ 81.6834ms,0.0V 81.6999ms,0.0
+ 81.7000ms,3.3V 81.7033ms,3.3
+ 81.7034ms,0.0V 81.7199ms,0.0
+ 81.7200ms,3.3V 81.7233ms,3.3
+ 81.7234ms,0.0V 81.7399ms,0.0
+ 81.7400ms,3.3V 81.7433ms,3.3
+ 81.7434ms,0.0V 81.7599ms,0.0
+ 81.7600ms,3.3V 81.7633ms,3.3
+ 81.7634ms,0.0V 81.7799ms,0.0
+ 81.7800ms,3.3V 81.7833ms,3.3
+ 81.7834ms,0.0V 81.7999ms,0.0
+ 81.8000ms,3.3V 81.8033ms,3.3
+ 81.8034ms,0.0V 81.8199ms,0.0
+ 81.8200ms,3.3V 81.8233ms,3.3
+ 81.8234ms,0.0V 81.8399ms,0.0
+ 81.8400ms,3.3V 81.8433ms,3.3
+ 81.8434ms,0.0V 81.8599ms,0.0
+ 81.8600ms,3.3V 81.8633ms,3.3
+ 81.8634ms,0.0V 81.8799ms,0.0
+ 81.8800ms,3.3V 81.8833ms,3.3
+ 81.8834ms,0.0V 81.8999ms,0.0
+ 81.9000ms,3.3V 81.9033ms,3.3
+ 81.9034ms,0.0V 81.9199ms,0.0
+ 81.9200ms,3.3V 81.9233ms,3.3
+ 81.9234ms,0.0V 81.9399ms,0.0
+ 81.9400ms,3.3V 81.9433ms,3.3
+ 81.9434ms,0.0V 81.9599ms,0.0
+ 81.9600ms,3.3V 81.9633ms,3.3
+ 81.9634ms,0.0V 81.9799ms,0.0
+ 81.9800ms,3.3V 81.9833ms,3.3
+ 81.9834ms,0.0V 81.9999ms,0.0
+ 82.0000ms,3.3V 82.0033ms,3.3
+ 82.0034ms,0.0V 82.0199ms,0.0
+ 82.0200ms,3.3V 82.0233ms,3.3
+ 82.0234ms,0.0V 82.0399ms,0.0
+ 82.0400ms,3.3V 82.0433ms,3.3
+ 82.0434ms,0.0V 82.0599ms,0.0
+ 82.0600ms,3.3V 82.0633ms,3.3
+ 82.0634ms,0.0V 82.0799ms,0.0
+ 82.0800ms,3.3V 82.0833ms,3.3
+ 82.0834ms,0.0V 82.0999ms,0.0
+ 82.1000ms,3.3V 82.1033ms,3.3
+ 82.1034ms,0.0V 82.1199ms,0.0
+ 82.1200ms,3.3V 82.1233ms,3.3
+ 82.1234ms,0.0V 82.1399ms,0.0
+ 82.1400ms,3.3V 82.1433ms,3.3
+ 82.1434ms,0.0V 82.1599ms,0.0
+ 82.1600ms,3.3V 82.1633ms,3.3
+ 82.1634ms,0.0V 82.1799ms,0.0
+ 82.1800ms,3.3V 82.1833ms,3.3
+ 82.1834ms,0.0V 82.1999ms,0.0
+ 82.2000ms,3.3V 82.2033ms,3.3
+ 82.2034ms,0.0V 82.2199ms,0.0
+ 82.2200ms,3.3V 82.2233ms,3.3
+ 82.2234ms,0.0V 82.2399ms,0.0
+ 82.2400ms,3.3V 82.2433ms,3.3
+ 82.2434ms,0.0V 82.2599ms,0.0
+ 82.2600ms,3.3V 82.2633ms,3.3
+ 82.2634ms,0.0V 82.2799ms,0.0
+ 82.2800ms,3.3V 82.2833ms,3.3
+ 82.2834ms,0.0V 82.2999ms,0.0
+ 82.3000ms,3.3V 82.3033ms,3.3
+ 82.3034ms,0.0V 82.3199ms,0.0
+ 82.3200ms,3.3V 82.3233ms,3.3
+ 82.3234ms,0.0V 82.3399ms,0.0
+ 82.3400ms,3.3V 82.3433ms,3.3
+ 82.3434ms,0.0V 82.3599ms,0.0
+ 82.3600ms,3.3V 82.3633ms,3.3
+ 82.3634ms,0.0V 82.3799ms,0.0
+ 82.3800ms,3.3V 82.3833ms,3.3
+ 82.3834ms,0.0V 82.3999ms,0.0
+ 82.4000ms,3.3V 82.4033ms,3.3
+ 82.4034ms,0.0V 82.4199ms,0.0
+ 82.4200ms,3.3V 82.4233ms,3.3
+ 82.4234ms,0.0V 82.4399ms,0.0
+ 82.4400ms,3.3V 82.4433ms,3.3
+ 82.4434ms,0.0V 82.4599ms,0.0
+ 82.4600ms,3.3V 82.4633ms,3.3
+ 82.4634ms,0.0V 82.4799ms,0.0
+ 82.4800ms,3.3V 82.4833ms,3.3
+ 82.4834ms,0.0V 82.4999ms,0.0
+ 82.5000ms,3.3V 82.5033ms,3.3
+ 82.5034ms,0.0V 82.5199ms,0.0
+ 82.5200ms,3.3V 82.5233ms,3.3
+ 82.5234ms,0.0V 82.5399ms,0.0
+ 82.5400ms,3.3V 82.5433ms,3.3
+ 82.5434ms,0.0V 82.5599ms,0.0
+ 82.5600ms,3.3V 82.5633ms,3.3
+ 82.5634ms,0.0V 82.5799ms,0.0
+ 82.5800ms,3.3V 82.5833ms,3.3
+ 82.5834ms,0.0V 82.5999ms,0.0
+ 82.6000ms,3.3V 82.6033ms,3.3
+ 82.6034ms,0.0V 82.6199ms,0.0
+ 82.6200ms,3.3V 82.6233ms,3.3
+ 82.6234ms,0.0V 82.6399ms,0.0
+ 82.6400ms,3.3V 82.6433ms,3.3
+ 82.6434ms,0.0V 82.6599ms,0.0
+ 82.6600ms,3.3V 82.6633ms,3.3
+ 82.6634ms,0.0V 82.6799ms,0.0
+ 82.6800ms,3.3V 82.6833ms,3.3
+ 82.6834ms,0.0V 82.6999ms,0.0
+ 82.7000ms,3.3V 82.7033ms,3.3
+ 82.7034ms,0.0V 82.7199ms,0.0
+ 82.7200ms,3.3V 82.7233ms,3.3
+ 82.7234ms,0.0V 82.7399ms,0.0
+ 82.7400ms,3.3V 82.7433ms,3.3
+ 82.7434ms,0.0V 82.7599ms,0.0
+ 82.7600ms,3.3V 82.7633ms,3.3
+ 82.7634ms,0.0V 82.7799ms,0.0
+ 82.7800ms,3.3V 82.7833ms,3.3
+ 82.7834ms,0.0V 82.7999ms,0.0
+ 82.8000ms,3.3V 82.8033ms,3.3
+ 82.8034ms,0.0V 82.8199ms,0.0
+ 82.8200ms,3.3V 82.8233ms,3.3
+ 82.8234ms,0.0V 82.8399ms,0.0
+ 82.8400ms,3.3V 82.8433ms,3.3
+ 82.8434ms,0.0V 82.8599ms,0.0
+ 82.8600ms,3.3V 82.8633ms,3.3
+ 82.8634ms,0.0V 82.8799ms,0.0
+ 82.8800ms,3.3V 82.8833ms,3.3
+ 82.8834ms,0.0V 82.8999ms,0.0
+ 82.9000ms,3.3V 82.9033ms,3.3
+ 82.9034ms,0.0V 82.9199ms,0.0
+ 82.9200ms,3.3V 82.9233ms,3.3
+ 82.9234ms,0.0V 82.9399ms,0.0
+ 82.9400ms,3.3V 82.9433ms,3.3
+ 82.9434ms,0.0V 82.9599ms,0.0
+ 82.9600ms,3.3V 82.9633ms,3.3
+ 82.9634ms,0.0V 82.9799ms,0.0
+ 82.9800ms,3.3V 82.9833ms,3.3
+ 82.9834ms,0.0V 82.9999ms,0.0
+ 83.0000ms,3.3V 83.0033ms,3.3
+ 83.0034ms,0.0V 83.0199ms,0.0
+ 83.0200ms,3.3V 83.0233ms,3.3
+ 83.0234ms,0.0V 83.0399ms,0.0
+ 83.0400ms,3.3V 83.0433ms,3.3
+ 83.0434ms,0.0V 83.0599ms,0.0
+ 83.0600ms,3.3V 83.0633ms,3.3
+ 83.0634ms,0.0V 83.0799ms,0.0
+ 83.0800ms,3.3V 83.0833ms,3.3
+ 83.0834ms,0.0V 83.0999ms,0.0
+ 83.1000ms,3.3V 83.1033ms,3.3
+ 83.1034ms,0.0V 83.1199ms,0.0
+ 83.1200ms,3.3V 83.1233ms,3.3
+ 83.1234ms,0.0V 83.1399ms,0.0
+ 83.1400ms,3.3V 83.1433ms,3.3
+ 83.1434ms,0.0V 83.1599ms,0.0
+ 83.1600ms,3.3V 83.1633ms,3.3
+ 83.1634ms,0.0V 83.1799ms,0.0
+ 83.1800ms,3.3V 83.1833ms,3.3
+ 83.1834ms,0.0V 83.1999ms,0.0
+ 83.2000ms,3.3V 83.2033ms,3.3
+ 83.2034ms,0.0V 83.2199ms,0.0
+ 83.2200ms,3.3V 83.2233ms,3.3
+ 83.2234ms,0.0V 83.2399ms,0.0
+ 83.2400ms,3.3V 83.2433ms,3.3
+ 83.2434ms,0.0V 83.2599ms,0.0
+ 83.2600ms,3.3V 83.2633ms,3.3
+ 83.2634ms,0.0V 83.2799ms,0.0
+ 83.2800ms,3.3V 83.2833ms,3.3
+ 83.2834ms,0.0V 83.2999ms,0.0
+ 83.3000ms,3.3V 83.3033ms,3.3
+ 83.3034ms,0.0V 83.3199ms,0.0
+ 83.3200ms,3.3V 83.3233ms,3.3
+ 83.3234ms,0.0V 83.3399ms,0.0
+ 83.3400ms,3.3V 83.3433ms,3.3
+ 83.3434ms,0.0V 83.3599ms,0.0
+ 83.3600ms,3.3V 83.3633ms,3.3
+ 83.3634ms,0.0V 83.3799ms,0.0
+ 83.3800ms,3.3V 83.3833ms,3.3
+ 83.3834ms,0.0V 83.3999ms,0.0
+ 83.4000ms,3.3V 83.4033ms,3.3
+ 83.4034ms,0.0V 83.4199ms,0.0
+ 83.4200ms,3.3V 83.4233ms,3.3
+ 83.4234ms,0.0V 83.4399ms,0.0
+ 83.4400ms,3.3V 83.4433ms,3.3
+ 83.4434ms,0.0V 83.4599ms,0.0
+ 83.4600ms,3.3V 83.4633ms,3.3
+ 83.4634ms,0.0V 83.4799ms,0.0
+ 83.4800ms,3.3V 83.4833ms,3.3
+ 83.4834ms,0.0V 83.4999ms,0.0
+ 83.5000ms,3.3V 83.5033ms,3.3
+ 83.5034ms,0.0V 83.5199ms,0.0
+ 83.5200ms,3.3V 83.5233ms,3.3
+ 83.5234ms,0.0V 83.5399ms,0.0
+ 83.5400ms,3.3V 83.5433ms,3.3
+ 83.5434ms,0.0V 83.5599ms,0.0
+ 83.5600ms,3.3V 83.5633ms,3.3
+ 83.5634ms,0.0V 83.5799ms,0.0
+ 83.5800ms,3.3V 83.5833ms,3.3
+ 83.5834ms,0.0V 83.5999ms,0.0
+ 83.6000ms,3.3V 83.6033ms,3.3
+ 83.6034ms,0.0V 83.6199ms,0.0
+ 83.6200ms,3.3V 83.6233ms,3.3
+ 83.6234ms,0.0V 83.6399ms,0.0
+ 83.6400ms,3.3V 83.6433ms,3.3
+ 83.6434ms,0.0V 83.6599ms,0.0
+ 83.6600ms,3.3V 83.6633ms,3.3
+ 83.6634ms,0.0V 83.6799ms,0.0
+ 83.6800ms,3.3V 83.6833ms,3.3
+ 83.6834ms,0.0V 83.6999ms,0.0
+ 83.7000ms,3.3V 83.7033ms,3.3
+ 83.7034ms,0.0V 83.7199ms,0.0
+ 83.7200ms,3.3V 83.7233ms,3.3
+ 83.7234ms,0.0V 83.7399ms,0.0
+ 83.7400ms,3.3V 83.7433ms,3.3
+ 83.7434ms,0.0V 83.7599ms,0.0
+ 83.7600ms,3.3V 83.7633ms,3.3
+ 83.7634ms,0.0V 83.7799ms,0.0
+ 83.7800ms,3.3V 83.7833ms,3.3
+ 83.7834ms,0.0V 83.7999ms,0.0
+ 83.8000ms,3.3V 83.8033ms,3.3
+ 83.8034ms,0.0V 83.8199ms,0.0
+ 83.8200ms,3.3V 83.8233ms,3.3
+ 83.8234ms,0.0V 83.8399ms,0.0
+ 83.8400ms,3.3V 83.8433ms,3.3
+ 83.8434ms,0.0V 83.8599ms,0.0
+ 83.8600ms,3.3V 83.8633ms,3.3
+ 83.8634ms,0.0V 83.8799ms,0.0
+ 83.8800ms,3.3V 83.8833ms,3.3
+ 83.8834ms,0.0V 83.8999ms,0.0
+ 83.9000ms,3.3V 83.9033ms,3.3
+ 83.9034ms,0.0V 83.9199ms,0.0
+ 83.9200ms,3.3V 83.9233ms,3.3
+ 83.9234ms,0.0V 83.9399ms,0.0
+ 83.9400ms,3.3V 83.9433ms,3.3
+ 83.9434ms,0.0V 83.9599ms,0.0
+ 83.9600ms,3.3V 83.9633ms,3.3
+ 83.9634ms,0.0V 83.9799ms,0.0
+ 83.9800ms,3.3V 83.9833ms,3.3
+ 83.9834ms,0.0V 83.9999ms,0.0
+ 84.0000ms,3.3V 84.0033ms,3.3
+ 84.0034ms,0.0V 84.0199ms,0.0
+ 84.0200ms,3.3V 84.0233ms,3.3
+ 84.0234ms,0.0V 84.0399ms,0.0
+ 84.0400ms,3.3V 84.0433ms,3.3
+ 84.0434ms,0.0V 84.0599ms,0.0
+ 84.0600ms,3.3V 84.0633ms,3.3
+ 84.0634ms,0.0V 84.0799ms,0.0
+ 84.0800ms,3.3V 84.0833ms,3.3
+ 84.0834ms,0.0V 84.0999ms,0.0
+ 84.1000ms,3.3V 84.1033ms,3.3
+ 84.1034ms,0.0V 84.1199ms,0.0
+ 84.1200ms,3.3V 84.1233ms,3.3
+ 84.1234ms,0.0V 84.1399ms,0.0
+ 84.1400ms,3.3V 84.1433ms,3.3
+ 84.1434ms,0.0V 84.1599ms,0.0
+ 84.1600ms,3.3V 84.1633ms,3.3
+ 84.1634ms,0.0V 84.1799ms,0.0
+ 84.1800ms,3.3V 84.1833ms,3.3
+ 84.1834ms,0.0V 84.1999ms,0.0
+ 84.2000ms,3.3V 84.2033ms,3.3
+ 84.2034ms,0.0V 84.2199ms,0.0
+ 84.2200ms,3.3V 84.2233ms,3.3
+ 84.2234ms,0.0V 84.2399ms,0.0
+ 84.2400ms,3.3V 84.2433ms,3.3
+ 84.2434ms,0.0V 84.2599ms,0.0
+ 84.2600ms,3.3V 84.2633ms,3.3
+ 84.2634ms,0.0V 84.2799ms,0.0
+ 84.2800ms,3.3V 84.2833ms,3.3
+ 84.2834ms,0.0V 84.2999ms,0.0
+ 84.3000ms,3.3V 84.3033ms,3.3
+ 84.3034ms,0.0V 84.3199ms,0.0
+ 84.3200ms,3.3V 84.3233ms,3.3
+ 84.3234ms,0.0V 84.3399ms,0.0
+ 84.3400ms,3.3V 84.3433ms,3.3
+ 84.3434ms,0.0V 84.3599ms,0.0
+ 84.3600ms,3.3V 84.3633ms,3.3
+ 84.3634ms,0.0V 84.3799ms,0.0
+ 84.3800ms,3.3V 84.3833ms,3.3
+ 84.3834ms,0.0V 84.3999ms,0.0
+ 84.4000ms,3.3V 84.4033ms,3.3
+ 84.4034ms,0.0V 84.4199ms,0.0
+ 84.4200ms,3.3V 84.4233ms,3.3
+ 84.4234ms,0.0V 84.4399ms,0.0
+ 84.4400ms,3.3V 84.4433ms,3.3
+ 84.4434ms,0.0V 84.4599ms,0.0
+ 84.4600ms,3.3V 84.4633ms,3.3
+ 84.4634ms,0.0V 84.4799ms,0.0
+ 84.4800ms,3.3V 84.4833ms,3.3
+ 84.4834ms,0.0V 84.4999ms,0.0
+ 84.5000ms,3.3V 84.5033ms,3.3
+ 84.5034ms,0.0V 84.5199ms,0.0
+ 84.5200ms,3.3V 84.5233ms,3.3
+ 84.5234ms,0.0V 84.5399ms,0.0
+ 84.5400ms,3.3V 84.5433ms,3.3
+ 84.5434ms,0.0V 84.5599ms,0.0
+ 84.5600ms,3.3V 84.5633ms,3.3
+ 84.5634ms,0.0V 84.5799ms,0.0
+ 84.5800ms,3.3V 84.5833ms,3.3
+ 84.5834ms,0.0V 84.5999ms,0.0
+ 84.6000ms,3.3V 84.6033ms,3.3
+ 84.6034ms,0.0V 84.6199ms,0.0
+ 84.6200ms,3.3V 84.6233ms,3.3
+ 84.6234ms,0.0V 84.6399ms,0.0
+ 84.6400ms,3.3V 84.6433ms,3.3
+ 84.6434ms,0.0V 84.6599ms,0.0
+ 84.6600ms,3.3V 84.6633ms,3.3
+ 84.6634ms,0.0V 84.6799ms,0.0
+ 84.6800ms,3.3V 84.6833ms,3.3
+ 84.6834ms,0.0V 84.6999ms,0.0
+ 84.7000ms,3.3V 84.7033ms,3.3
+ 84.7034ms,0.0V 84.7199ms,0.0
+ 84.7200ms,3.3V 84.7233ms,3.3
+ 84.7234ms,0.0V 84.7399ms,0.0
+ 84.7400ms,3.3V 84.7433ms,3.3
+ 84.7434ms,0.0V 84.7599ms,0.0
+ 84.7600ms,3.3V 84.7633ms,3.3
+ 84.7634ms,0.0V 84.7799ms,0.0
+ 84.7800ms,3.3V 84.7833ms,3.3
+ 84.7834ms,0.0V 84.7999ms,0.0
+ 84.8000ms,3.3V 84.8033ms,3.3
+ 84.8034ms,0.0V 84.8199ms,0.0
+ 84.8200ms,3.3V 84.8233ms,3.3
+ 84.8234ms,0.0V 84.8399ms,0.0
+ 84.8400ms,3.3V 84.8433ms,3.3
+ 84.8434ms,0.0V 84.8599ms,0.0
+ 84.8600ms,3.3V 84.8633ms,3.3
+ 84.8634ms,0.0V 84.8799ms,0.0
+ 84.8800ms,3.3V 84.8833ms,3.3
+ 84.8834ms,0.0V 84.8999ms,0.0
+ 84.9000ms,3.3V 84.9033ms,3.3
+ 84.9034ms,0.0V 84.9199ms,0.0
+ 84.9200ms,3.3V 84.9233ms,3.3
+ 84.9234ms,0.0V 84.9399ms,0.0
+ 84.9400ms,3.3V 84.9433ms,3.3
+ 84.9434ms,0.0V 84.9599ms,0.0
+ 84.9600ms,3.3V 84.9633ms,3.3
+ 84.9634ms,0.0V 84.9799ms,0.0
+ 84.9800ms,3.3V 84.9833ms,3.3
+ 84.9834ms,0.0V 84.9999ms,0.0
+ 85.0000ms,3.3V 85.0033ms,3.3
+ 85.0034ms,0.0V 85.0199ms,0.0
+ 85.0200ms,3.3V 85.0233ms,3.3
+ 85.0234ms,0.0V 85.0399ms,0.0
+ 85.0400ms,3.3V 85.0433ms,3.3
+ 85.0434ms,0.0V 85.0599ms,0.0
+ 85.0600ms,3.3V 85.0633ms,3.3
+ 85.0634ms,0.0V 85.0799ms,0.0
+ 85.0800ms,3.3V 85.0833ms,3.3
+ 85.0834ms,0.0V 85.0999ms,0.0
+ 85.1000ms,3.3V 85.1033ms,3.3
+ 85.1034ms,0.0V 85.1199ms,0.0
+ 85.1200ms,3.3V 85.1233ms,3.3
+ 85.1234ms,0.0V 85.1399ms,0.0
+ 85.1400ms,3.3V 85.1433ms,3.3
+ 85.1434ms,0.0V 85.1599ms,0.0
+ 85.1600ms,3.3V 85.1633ms,3.3
+ 85.1634ms,0.0V 85.1799ms,0.0
+ 85.1800ms,3.3V 85.1833ms,3.3
+ 85.1834ms,0.0V 85.1999ms,0.0
+ 85.2000ms,3.3V 85.2035ms,3.3
+ 85.2036ms,0.0V 85.2199ms,0.0
+ 85.2200ms,3.3V 85.2235ms,3.3
+ 85.2236ms,0.0V 85.2399ms,0.0
+ 85.2400ms,3.3V 85.2435ms,3.3
+ 85.2436ms,0.0V 85.2599ms,0.0
+ 85.2600ms,3.3V 85.2635ms,3.3
+ 85.2636ms,0.0V 85.2799ms,0.0
+ 85.2800ms,3.3V 85.2835ms,3.3
+ 85.2836ms,0.0V 85.2999ms,0.0
+ 85.3000ms,3.3V 85.3035ms,3.3
+ 85.3036ms,0.0V 85.3199ms,0.0
+ 85.3200ms,3.3V 85.3235ms,3.3
+ 85.3236ms,0.0V 85.3399ms,0.0
+ 85.3400ms,3.3V 85.3435ms,3.3
+ 85.3436ms,0.0V 85.3599ms,0.0
+ 85.3600ms,3.3V 85.3635ms,3.3
+ 85.3636ms,0.0V 85.3799ms,0.0
+ 85.3800ms,3.3V 85.3835ms,3.3
+ 85.3836ms,0.0V 85.3999ms,0.0
+ 85.4000ms,3.3V 85.4035ms,3.3
+ 85.4036ms,0.0V 85.4199ms,0.0
+ 85.4200ms,3.3V 85.4235ms,3.3
+ 85.4236ms,0.0V 85.4399ms,0.0
+ 85.4400ms,3.3V 85.4435ms,3.3
+ 85.4436ms,0.0V 85.4599ms,0.0
+ 85.4600ms,3.3V 85.4635ms,3.3
+ 85.4636ms,0.0V 85.4799ms,0.0
+ 85.4800ms,3.3V 85.4835ms,3.3
+ 85.4836ms,0.0V 85.4999ms,0.0
+ 85.5000ms,3.3V 85.5035ms,3.3
+ 85.5036ms,0.0V 85.5199ms,0.0
+ 85.5200ms,3.3V 85.5235ms,3.3
+ 85.5236ms,0.0V 85.5399ms,0.0
+ 85.5400ms,3.3V 85.5435ms,3.3
+ 85.5436ms,0.0V 85.5599ms,0.0
+ 85.5600ms,3.3V 85.5635ms,3.3
+ 85.5636ms,0.0V 85.5799ms,0.0
+ 85.5800ms,3.3V 85.5835ms,3.3
+ 85.5836ms,0.0V 85.5999ms,0.0
+ 85.6000ms,3.3V 85.6035ms,3.3
+ 85.6036ms,0.0V 85.6199ms,0.0
+ 85.6200ms,3.3V 85.6235ms,3.3
+ 85.6236ms,0.0V 85.6399ms,0.0
+ 85.6400ms,3.3V 85.6435ms,3.3
+ 85.6436ms,0.0V 85.6599ms,0.0
+ 85.6600ms,3.3V 85.6635ms,3.3
+ 85.6636ms,0.0V 85.6799ms,0.0
+ 85.6800ms,3.3V 85.6835ms,3.3
+ 85.6836ms,0.0V 85.6999ms,0.0
+ 85.7000ms,3.3V 85.7035ms,3.3
+ 85.7036ms,0.0V 85.7199ms,0.0
+ 85.7200ms,3.3V 85.7235ms,3.3
+ 85.7236ms,0.0V 85.7399ms,0.0
+ 85.7400ms,3.3V 85.7435ms,3.3
+ 85.7436ms,0.0V 85.7599ms,0.0
+ 85.7600ms,3.3V 85.7635ms,3.3
+ 85.7636ms,0.0V 85.7799ms,0.0
+ 85.7800ms,3.3V 85.7835ms,3.3
+ 85.7836ms,0.0V 85.7999ms,0.0
+ 85.8000ms,3.3V 85.8035ms,3.3
+ 85.8036ms,0.0V 85.8199ms,0.0
+ 85.8200ms,3.3V 85.8235ms,3.3
+ 85.8236ms,0.0V 85.8399ms,0.0
+ 85.8400ms,3.3V 85.8435ms,3.3
+ 85.8436ms,0.0V 85.8599ms,0.0
+ 85.8600ms,3.3V 85.8635ms,3.3
+ 85.8636ms,0.0V 85.8799ms,0.0
+ 85.8800ms,3.3V 85.8835ms,3.3
+ 85.8836ms,0.0V 85.8999ms,0.0
+ 85.9000ms,3.3V 85.9035ms,3.3
+ 85.9036ms,0.0V 85.9199ms,0.0
+ 85.9200ms,3.3V 85.9235ms,3.3
+ 85.9236ms,0.0V 85.9399ms,0.0
+ 85.9400ms,3.3V 85.9435ms,3.3
+ 85.9436ms,0.0V 85.9599ms,0.0
+ 85.9600ms,3.3V 85.9635ms,3.3
+ 85.9636ms,0.0V 85.9799ms,0.0
+ 85.9800ms,3.3V 85.9835ms,3.3
+ 85.9836ms,0.0V 85.9999ms,0.0
+ 86.0000ms,3.3V 86.0035ms,3.3
+ 86.0036ms,0.0V 86.0199ms,0.0
+ 86.0200ms,3.3V 86.0235ms,3.3
+ 86.0236ms,0.0V 86.0399ms,0.0
+ 86.0400ms,3.3V 86.0435ms,3.3
+ 86.0436ms,0.0V 86.0599ms,0.0
+ 86.0600ms,3.3V 86.0635ms,3.3
+ 86.0636ms,0.0V 86.0799ms,0.0
+ 86.0800ms,3.3V 86.0835ms,3.3
+ 86.0836ms,0.0V 86.0999ms,0.0
+ 86.1000ms,3.3V 86.1035ms,3.3
+ 86.1036ms,0.0V 86.1199ms,0.0
+ 86.1200ms,3.3V 86.1235ms,3.3
+ 86.1236ms,0.0V 86.1399ms,0.0
+ 86.1400ms,3.3V 86.1435ms,3.3
+ 86.1436ms,0.0V 86.1599ms,0.0
+ 86.1600ms,3.3V 86.1635ms,3.3
+ 86.1636ms,0.0V 86.1799ms,0.0
+ 86.1800ms,3.3V 86.1835ms,3.3
+ 86.1836ms,0.0V 86.1999ms,0.0
+ 86.2000ms,3.3V 86.2035ms,3.3
+ 86.2036ms,0.0V 86.2199ms,0.0
+ 86.2200ms,3.3V 86.2235ms,3.3
+ 86.2236ms,0.0V 86.2399ms,0.0
+ 86.2400ms,3.3V 86.2435ms,3.3
+ 86.2436ms,0.0V 86.2599ms,0.0
+ 86.2600ms,3.3V 86.2635ms,3.3
+ 86.2636ms,0.0V 86.2799ms,0.0
+ 86.2800ms,3.3V 86.2835ms,3.3
+ 86.2836ms,0.0V 86.2999ms,0.0
+ 86.3000ms,3.3V 86.3035ms,3.3
+ 86.3036ms,0.0V 86.3199ms,0.0
+ 86.3200ms,3.3V 86.3235ms,3.3
+ 86.3236ms,0.0V 86.3399ms,0.0
+ 86.3400ms,3.3V 86.3435ms,3.3
+ 86.3436ms,0.0V 86.3599ms,0.0
+ 86.3600ms,3.3V 86.3635ms,3.3
+ 86.3636ms,0.0V 86.3799ms,0.0
+ 86.3800ms,3.3V 86.3835ms,3.3
+ 86.3836ms,0.0V 86.3999ms,0.0
+ 86.4000ms,3.3V 86.4035ms,3.3
+ 86.4036ms,0.0V 86.4199ms,0.0
+ 86.4200ms,3.3V 86.4235ms,3.3
+ 86.4236ms,0.0V 86.4399ms,0.0
+ 86.4400ms,3.3V 86.4435ms,3.3
+ 86.4436ms,0.0V 86.4599ms,0.0
+ 86.4600ms,3.3V 86.4635ms,3.3
+ 86.4636ms,0.0V 86.4799ms,0.0
+ 86.4800ms,3.3V 86.4835ms,3.3
+ 86.4836ms,0.0V 86.4999ms,0.0
+ 86.5000ms,3.3V 86.5035ms,3.3
+ 86.5036ms,0.0V 86.5199ms,0.0
+ 86.5200ms,3.3V 86.5235ms,3.3
+ 86.5236ms,0.0V 86.5399ms,0.0
+ 86.5400ms,3.3V 86.5435ms,3.3
+ 86.5436ms,0.0V 86.5599ms,0.0
+ 86.5600ms,3.3V 86.5635ms,3.3
+ 86.5636ms,0.0V 86.5799ms,0.0
+ 86.5800ms,3.3V 86.5835ms,3.3
+ 86.5836ms,0.0V 86.5999ms,0.0
+ 86.6000ms,3.3V 86.6035ms,3.3
+ 86.6036ms,0.0V 86.6199ms,0.0
+ 86.6200ms,3.3V 86.6235ms,3.3
+ 86.6236ms,0.0V 86.6399ms,0.0
+ 86.6400ms,3.3V 86.6435ms,3.3
+ 86.6436ms,0.0V 86.6599ms,0.0
+ 86.6600ms,3.3V 86.6635ms,3.3
+ 86.6636ms,0.0V 86.6799ms,0.0
+ 86.6800ms,3.3V 86.6835ms,3.3
+ 86.6836ms,0.0V 86.6999ms,0.0
+ 86.7000ms,3.3V 86.7035ms,3.3
+ 86.7036ms,0.0V 86.7199ms,0.0
+ 86.7200ms,3.3V 86.7235ms,3.3
+ 86.7236ms,0.0V 86.7399ms,0.0
+ 86.7400ms,3.3V 86.7435ms,3.3
+ 86.7436ms,0.0V 86.7599ms,0.0
+ 86.7600ms,3.3V 86.7635ms,3.3
+ 86.7636ms,0.0V 86.7799ms,0.0
+ 86.7800ms,3.3V 86.7835ms,3.3
+ 86.7836ms,0.0V 86.7999ms,0.0
+ 86.8000ms,3.3V 86.8035ms,3.3
+ 86.8036ms,0.0V 86.8199ms,0.0
+ 86.8200ms,3.3V 86.8235ms,3.3
+ 86.8236ms,0.0V 86.8399ms,0.0
+ 86.8400ms,3.3V 86.8435ms,3.3
+ 86.8436ms,0.0V 86.8599ms,0.0
+ 86.8600ms,3.3V 86.8635ms,3.3
+ 86.8636ms,0.0V 86.8799ms,0.0
+ 86.8800ms,3.3V 86.8835ms,3.3
+ 86.8836ms,0.0V 86.8999ms,0.0
+ 86.9000ms,3.3V 86.9035ms,3.3
+ 86.9036ms,0.0V 86.9199ms,0.0
+ 86.9200ms,3.3V 86.9235ms,3.3
+ 86.9236ms,0.0V 86.9399ms,0.0
+ 86.9400ms,3.3V 86.9435ms,3.3
+ 86.9436ms,0.0V 86.9599ms,0.0
+ 86.9600ms,3.3V 86.9635ms,3.3
+ 86.9636ms,0.0V 86.9799ms,0.0
+ 86.9800ms,3.3V 86.9835ms,3.3
+ 86.9836ms,0.0V 86.9999ms,0.0
+ 87.0000ms,3.3V 87.0035ms,3.3
+ 87.0036ms,0.0V 87.0199ms,0.0
+ 87.0200ms,3.3V 87.0235ms,3.3
+ 87.0236ms,0.0V 87.0399ms,0.0
+ 87.0400ms,3.3V 87.0435ms,3.3
+ 87.0436ms,0.0V 87.0599ms,0.0
+ 87.0600ms,3.3V 87.0635ms,3.3
+ 87.0636ms,0.0V 87.0799ms,0.0
+ 87.0800ms,3.3V 87.0835ms,3.3
+ 87.0836ms,0.0V 87.0999ms,0.0
+ 87.1000ms,3.3V 87.1035ms,3.3
+ 87.1036ms,0.0V 87.1199ms,0.0
+ 87.1200ms,3.3V 87.1235ms,3.3
+ 87.1236ms,0.0V 87.1399ms,0.0
+ 87.1400ms,3.3V 87.1435ms,3.3
+ 87.1436ms,0.0V 87.1599ms,0.0
+ 87.1600ms,3.3V 87.1635ms,3.3
+ 87.1636ms,0.0V 87.1799ms,0.0
+ 87.1800ms,3.3V 87.1835ms,3.3
+ 87.1836ms,0.0V 87.1999ms,0.0
+ 87.2000ms,3.3V 87.2035ms,3.3
+ 87.2036ms,0.0V 87.2199ms,0.0
+ 87.2200ms,3.3V 87.2235ms,3.3
+ 87.2236ms,0.0V 87.2399ms,0.0
+ 87.2400ms,3.3V 87.2435ms,3.3
+ 87.2436ms,0.0V 87.2599ms,0.0
+ 87.2600ms,3.3V 87.2635ms,3.3
+ 87.2636ms,0.0V 87.2799ms,0.0
+ 87.2800ms,3.3V 87.2835ms,3.3
+ 87.2836ms,0.0V 87.2999ms,0.0
+ 87.3000ms,3.3V 87.3035ms,3.3
+ 87.3036ms,0.0V 87.3199ms,0.0
+ 87.3200ms,3.3V 87.3235ms,3.3
+ 87.3236ms,0.0V 87.3399ms,0.0
+ 87.3400ms,3.3V 87.3435ms,3.3
+ 87.3436ms,0.0V 87.3599ms,0.0
+ 87.3600ms,3.3V 87.3635ms,3.3
+ 87.3636ms,0.0V 87.3799ms,0.0
+ 87.3800ms,3.3V 87.3835ms,3.3
+ 87.3836ms,0.0V 87.3999ms,0.0
+ 87.4000ms,3.3V 87.4035ms,3.3
+ 87.4036ms,0.0V 87.4199ms,0.0
+ 87.4200ms,3.3V 87.4235ms,3.3
+ 87.4236ms,0.0V 87.4399ms,0.0
+ 87.4400ms,3.3V 87.4435ms,3.3
+ 87.4436ms,0.0V 87.4599ms,0.0
+ 87.4600ms,3.3V 87.4635ms,3.3
+ 87.4636ms,0.0V 87.4799ms,0.0
+ 87.4800ms,3.3V 87.4835ms,3.3
+ 87.4836ms,0.0V 87.4999ms,0.0
+ 87.5000ms,3.3V 87.5035ms,3.3
+ 87.5036ms,0.0V 87.5199ms,0.0
+ 87.5200ms,3.3V 87.5235ms,3.3
+ 87.5236ms,0.0V 87.5399ms,0.0
+ 87.5400ms,3.3V 87.5435ms,3.3
+ 87.5436ms,0.0V 87.5599ms,0.0
+ 87.5600ms,3.3V 87.5635ms,3.3
+ 87.5636ms,0.0V 87.5799ms,0.0
+ 87.5800ms,3.3V 87.5835ms,3.3
+ 87.5836ms,0.0V 87.5999ms,0.0
+ 87.6000ms,3.3V 87.6035ms,3.3
+ 87.6036ms,0.0V 87.6199ms,0.0
+ 87.6200ms,3.3V 87.6235ms,3.3
+ 87.6236ms,0.0V 87.6399ms,0.0
+ 87.6400ms,3.3V 87.6435ms,3.3
+ 87.6436ms,0.0V 87.6599ms,0.0
+ 87.6600ms,3.3V 87.6635ms,3.3
+ 87.6636ms,0.0V 87.6799ms,0.0
+ 87.6800ms,3.3V 87.6835ms,3.3
+ 87.6836ms,0.0V 87.6999ms,0.0
+ 87.7000ms,3.3V 87.7035ms,3.3
+ 87.7036ms,0.0V 87.7199ms,0.0
+ 87.7200ms,3.3V 87.7235ms,3.3
+ 87.7236ms,0.0V 87.7399ms,0.0
+ 87.7400ms,3.3V 87.7435ms,3.3
+ 87.7436ms,0.0V 87.7599ms,0.0
+ 87.7600ms,3.3V 87.7635ms,3.3
+ 87.7636ms,0.0V 87.7799ms,0.0
+ 87.7800ms,3.3V 87.7835ms,3.3
+ 87.7836ms,0.0V 87.7999ms,0.0
+ 87.8000ms,3.3V 87.8035ms,3.3
+ 87.8036ms,0.0V 87.8199ms,0.0
+ 87.8200ms,3.3V 87.8235ms,3.3
+ 87.8236ms,0.0V 87.8399ms,0.0
+ 87.8400ms,3.3V 87.8435ms,3.3
+ 87.8436ms,0.0V 87.8599ms,0.0
+ 87.8600ms,3.3V 87.8635ms,3.3
+ 87.8636ms,0.0V 87.8799ms,0.0
+ 87.8800ms,3.3V 87.8835ms,3.3
+ 87.8836ms,0.0V 87.8999ms,0.0
+ 87.9000ms,3.3V 87.9035ms,3.3
+ 87.9036ms,0.0V 87.9199ms,0.0
+ 87.9200ms,3.3V 87.9235ms,3.3
+ 87.9236ms,0.0V 87.9399ms,0.0
+ 87.9400ms,3.3V 87.9435ms,3.3
+ 87.9436ms,0.0V 87.9599ms,0.0
+ 87.9600ms,3.3V 87.9635ms,3.3
+ 87.9636ms,0.0V 87.9799ms,0.0
+ 87.9800ms,3.3V 87.9835ms,3.3
+ 87.9836ms,0.0V 87.9999ms,0.0
+ 88.0000ms,3.3V 88.0035ms,3.3
+ 88.0036ms,0.0V 88.0199ms,0.0
+ 88.0200ms,3.3V 88.0235ms,3.3
+ 88.0236ms,0.0V 88.0399ms,0.0
+ 88.0400ms,3.3V 88.0435ms,3.3
+ 88.0436ms,0.0V 88.0599ms,0.0
+ 88.0600ms,3.3V 88.0635ms,3.3
+ 88.0636ms,0.0V 88.0799ms,0.0
+ 88.0800ms,3.3V 88.0835ms,3.3
+ 88.0836ms,0.0V 88.0999ms,0.0
+ 88.1000ms,3.3V 88.1035ms,3.3
+ 88.1036ms,0.0V 88.1199ms,0.0
+ 88.1200ms,3.3V 88.1235ms,3.3
+ 88.1236ms,0.0V 88.1399ms,0.0
+ 88.1400ms,3.3V 88.1435ms,3.3
+ 88.1436ms,0.0V 88.1599ms,0.0
+ 88.1600ms,3.3V 88.1635ms,3.3
+ 88.1636ms,0.0V 88.1799ms,0.0
+ 88.1800ms,3.3V 88.1835ms,3.3
+ 88.1836ms,0.0V 88.1999ms,0.0
+ 88.2000ms,3.3V 88.2035ms,3.3
+ 88.2036ms,0.0V 88.2199ms,0.0
+ 88.2200ms,3.3V 88.2235ms,3.3
+ 88.2236ms,0.0V 88.2399ms,0.0
+ 88.2400ms,3.3V 88.2435ms,3.3
+ 88.2436ms,0.0V 88.2599ms,0.0
+ 88.2600ms,3.3V 88.2635ms,3.3
+ 88.2636ms,0.0V 88.2799ms,0.0
+ 88.2800ms,3.3V 88.2835ms,3.3
+ 88.2836ms,0.0V 88.2999ms,0.0
+ 88.3000ms,3.3V 88.3035ms,3.3
+ 88.3036ms,0.0V 88.3199ms,0.0
+ 88.3200ms,3.3V 88.3235ms,3.3
+ 88.3236ms,0.0V 88.3399ms,0.0
+ 88.3400ms,3.3V 88.3435ms,3.3
+ 88.3436ms,0.0V 88.3599ms,0.0
+ 88.3600ms,3.3V 88.3635ms,3.3
+ 88.3636ms,0.0V 88.3799ms,0.0
+ 88.3800ms,3.3V 88.3835ms,3.3
+ 88.3836ms,0.0V 88.3999ms,0.0
+ 88.4000ms,3.3V 88.4035ms,3.3
+ 88.4036ms,0.0V 88.4199ms,0.0
+ 88.4200ms,3.3V 88.4235ms,3.3
+ 88.4236ms,0.0V 88.4399ms,0.0
+ 88.4400ms,3.3V 88.4435ms,3.3
+ 88.4436ms,0.0V 88.4599ms,0.0
+ 88.4600ms,3.3V 88.4635ms,3.3
+ 88.4636ms,0.0V 88.4799ms,0.0
+ 88.4800ms,3.3V 88.4835ms,3.3
+ 88.4836ms,0.0V 88.4999ms,0.0
+ 88.5000ms,3.3V 88.5035ms,3.3
+ 88.5036ms,0.0V 88.5199ms,0.0
+ 88.5200ms,3.3V 88.5235ms,3.3
+ 88.5236ms,0.0V 88.5399ms,0.0
+ 88.5400ms,3.3V 88.5435ms,3.3
+ 88.5436ms,0.0V 88.5599ms,0.0
+ 88.5600ms,3.3V 88.5635ms,3.3
+ 88.5636ms,0.0V 88.5799ms,0.0
+ 88.5800ms,3.3V 88.5835ms,3.3
+ 88.5836ms,0.0V 88.5999ms,0.0
+ 88.6000ms,3.3V 88.6035ms,3.3
+ 88.6036ms,0.0V 88.6199ms,0.0
+ 88.6200ms,3.3V 88.6235ms,3.3
+ 88.6236ms,0.0V 88.6399ms,0.0
+ 88.6400ms,3.3V 88.6435ms,3.3
+ 88.6436ms,0.0V 88.6599ms,0.0
+ 88.6600ms,3.3V 88.6635ms,3.3
+ 88.6636ms,0.0V 88.6799ms,0.0
+ 88.6800ms,3.3V 88.6835ms,3.3
+ 88.6836ms,0.0V 88.6999ms,0.0
+ 88.7000ms,3.3V 88.7035ms,3.3
+ 88.7036ms,0.0V 88.7199ms,0.0
+ 88.7200ms,3.3V 88.7235ms,3.3
+ 88.7236ms,0.0V 88.7399ms,0.0
+ 88.7400ms,3.3V 88.7435ms,3.3
+ 88.7436ms,0.0V 88.7599ms,0.0
+ 88.7600ms,3.3V 88.7635ms,3.3
+ 88.7636ms,0.0V 88.7799ms,0.0
+ 88.7800ms,3.3V 88.7835ms,3.3
+ 88.7836ms,0.0V 88.7999ms,0.0
+ 88.8000ms,3.3V 88.8035ms,3.3
+ 88.8036ms,0.0V 88.8199ms,0.0
+ 88.8200ms,3.3V 88.8235ms,3.3
+ 88.8236ms,0.0V 88.8399ms,0.0
+ 88.8400ms,3.3V 88.8435ms,3.3
+ 88.8436ms,0.0V 88.8599ms,0.0
+ 88.8600ms,3.3V 88.8635ms,3.3
+ 88.8636ms,0.0V 88.8799ms,0.0
+ 88.8800ms,3.3V 88.8835ms,3.3
+ 88.8836ms,0.0V 88.8999ms,0.0
+ 88.9000ms,3.3V 88.9035ms,3.3
+ 88.9036ms,0.0V 88.9199ms,0.0
+ 88.9200ms,3.3V 88.9235ms,3.3
+ 88.9236ms,0.0V 88.9399ms,0.0
+ 88.9400ms,3.3V 88.9435ms,3.3
+ 88.9436ms,0.0V 88.9599ms,0.0
+ 88.9600ms,3.3V 88.9635ms,3.3
+ 88.9636ms,0.0V 88.9799ms,0.0
+ 88.9800ms,3.3V 88.9835ms,3.3
+ 88.9836ms,0.0V 88.9999ms,0.0
+ 89.0000ms,3.3V 89.0035ms,3.3
+ 89.0036ms,0.0V 89.0199ms,0.0
+ 89.0200ms,3.3V 89.0235ms,3.3
+ 89.0236ms,0.0V 89.0399ms,0.0
+ 89.0400ms,3.3V 89.0435ms,3.3
+ 89.0436ms,0.0V 89.0599ms,0.0
+ 89.0600ms,3.3V 89.0635ms,3.3
+ 89.0636ms,0.0V 89.0799ms,0.0
+ 89.0800ms,3.3V 89.0835ms,3.3
+ 89.0836ms,0.0V 89.0999ms,0.0
+ 89.1000ms,3.3V 89.1035ms,3.3
+ 89.1036ms,0.0V 89.1199ms,0.0
+ 89.1200ms,3.3V 89.1235ms,3.3
+ 89.1236ms,0.0V 89.1399ms,0.0
+ 89.1400ms,3.3V 89.1435ms,3.3
+ 89.1436ms,0.0V 89.1599ms,0.0
+ 89.1600ms,3.3V 89.1635ms,3.3
+ 89.1636ms,0.0V 89.1799ms,0.0
+ 89.1800ms,3.3V 89.1835ms,3.3
+ 89.1836ms,0.0V 89.1999ms,0.0
+ 89.2000ms,3.3V 89.2035ms,3.3
+ 89.2036ms,0.0V 89.2199ms,0.0
+ 89.2200ms,3.3V 89.2235ms,3.3
+ 89.2236ms,0.0V 89.2399ms,0.0
+ 89.2400ms,3.3V 89.2435ms,3.3
+ 89.2436ms,0.0V 89.2599ms,0.0
+ 89.2600ms,3.3V 89.2635ms,3.3
+ 89.2636ms,0.0V 89.2799ms,0.0
+ 89.2800ms,3.3V 89.2835ms,3.3
+ 89.2836ms,0.0V 89.2999ms,0.0
+ 89.3000ms,3.3V 89.3035ms,3.3
+ 89.3036ms,0.0V 89.3199ms,0.0
+ 89.3200ms,3.3V 89.3235ms,3.3
+ 89.3236ms,0.0V 89.3399ms,0.0
+ 89.3400ms,3.3V 89.3435ms,3.3
+ 89.3436ms,0.0V 89.3599ms,0.0
+ 89.3600ms,3.3V 89.3635ms,3.3
+ 89.3636ms,0.0V 89.3799ms,0.0
+ 89.3800ms,3.3V 89.3835ms,3.3
+ 89.3836ms,0.0V 89.3999ms,0.0
+ 89.4000ms,3.3V 89.4035ms,3.3
+ 89.4036ms,0.0V 89.4199ms,0.0
+ 89.4200ms,3.3V 89.4235ms,3.3
+ 89.4236ms,0.0V 89.4399ms,0.0
+ 89.4400ms,3.3V 89.4435ms,3.3
+ 89.4436ms,0.0V 89.4599ms,0.0
+ 89.4600ms,3.3V 89.4635ms,3.3
+ 89.4636ms,0.0V 89.4799ms,0.0
+ 89.4800ms,3.3V 89.4835ms,3.3
+ 89.4836ms,0.0V 89.4999ms,0.0
+ 89.5000ms,3.3V 89.5035ms,3.3
+ 89.5036ms,0.0V 89.5199ms,0.0
+ 89.5200ms,3.3V 89.5235ms,3.3
+ 89.5236ms,0.0V 89.5399ms,0.0
+ 89.5400ms,3.3V 89.5435ms,3.3
+ 89.5436ms,0.0V 89.5599ms,0.0
+ 89.5600ms,3.3V 89.5635ms,3.3
+ 89.5636ms,0.0V 89.5799ms,0.0
+ 89.5800ms,3.3V 89.5835ms,3.3
+ 89.5836ms,0.0V 89.5999ms,0.0
+ 89.6000ms,3.3V 89.6035ms,3.3
+ 89.6036ms,0.0V 89.6199ms,0.0
+ 89.6200ms,3.3V 89.6235ms,3.3
+ 89.6236ms,0.0V 89.6399ms,0.0
+ 89.6400ms,3.3V 89.6435ms,3.3
+ 89.6436ms,0.0V 89.6599ms,0.0
+ 89.6600ms,3.3V 89.6635ms,3.3
+ 89.6636ms,0.0V 89.6799ms,0.0
+ 89.6800ms,3.3V 89.6835ms,3.3
+ 89.6836ms,0.0V 89.6999ms,0.0
+ 89.7000ms,3.3V 89.7035ms,3.3
+ 89.7036ms,0.0V 89.7199ms,0.0
+ 89.7200ms,3.3V 89.7235ms,3.3
+ 89.7236ms,0.0V 89.7399ms,0.0
+ 89.7400ms,3.3V 89.7435ms,3.3
+ 89.7436ms,0.0V 89.7599ms,0.0
+ 89.7600ms,3.3V 89.7635ms,3.3
+ 89.7636ms,0.0V 89.7799ms,0.0
+ 89.7800ms,3.3V 89.7835ms,3.3
+ 89.7836ms,0.0V 89.7999ms,0.0
+ 89.8000ms,3.3V 89.8035ms,3.3
+ 89.8036ms,0.0V 89.8199ms,0.0
+ 89.8200ms,3.3V 89.8235ms,3.3
+ 89.8236ms,0.0V 89.8399ms,0.0
+ 89.8400ms,3.3V 89.8435ms,3.3
+ 89.8436ms,0.0V 89.8599ms,0.0
+ 89.8600ms,3.3V 89.8635ms,3.3
+ 89.8636ms,0.0V 89.8799ms,0.0
+ 89.8800ms,3.3V 89.8835ms,3.3
+ 89.8836ms,0.0V 89.8999ms,0.0
+ 89.9000ms,3.3V 89.9035ms,3.3
+ 89.9036ms,0.0V 89.9199ms,0.0
+ 89.9200ms,3.3V 89.9235ms,3.3
+ 89.9236ms,0.0V 89.9399ms,0.0
+ 89.9400ms,3.3V 89.9435ms,3.3
+ 89.9436ms,0.0V 89.9599ms,0.0
+ 89.9600ms,3.3V 89.9635ms,3.3
+ 89.9636ms,0.0V 89.9799ms,0.0
+ 89.9800ms,3.3V 89.9835ms,3.3
+ 89.9836ms,0.0V 89.9999ms,0.0
+ 90.0000ms,3.3V 90.0035ms,3.3
+ 90.0036ms,0.0V 90.0199ms,0.0
+ 90.0200ms,3.3V 90.0235ms,3.3
+ 90.0236ms,0.0V 90.0399ms,0.0
+ 90.0400ms,3.3V 90.0435ms,3.3
+ 90.0436ms,0.0V 90.0599ms,0.0
+ 90.0600ms,3.3V 90.0635ms,3.3
+ 90.0636ms,0.0V 90.0799ms,0.0
+ 90.0800ms,3.3V 90.0835ms,3.3
+ 90.0836ms,0.0V 90.0999ms,0.0
+ 90.1000ms,3.3V 90.1035ms,3.3
+ 90.1036ms,0.0V 90.1199ms,0.0
+ 90.1200ms,3.3V 90.1235ms,3.3
+ 90.1236ms,0.0V 90.1399ms,0.0
+ 90.1400ms,3.3V 90.1435ms,3.3
+ 90.1436ms,0.0V 90.1599ms,0.0
+ 90.1600ms,3.3V 90.1635ms,3.3
+ 90.1636ms,0.0V 90.1799ms,0.0
+ 90.1800ms,3.3V 90.1835ms,3.3
+ 90.1836ms,0.0V 90.1999ms,0.0
+ 90.2000ms,3.3V 90.2035ms,3.3
+ 90.2036ms,0.0V 90.2199ms,0.0
+ 90.2200ms,3.3V 90.2237ms,3.3
+ 90.2238ms,0.0V 90.2399ms,0.0
+ 90.2400ms,3.3V 90.2437ms,3.3
+ 90.2438ms,0.0V 90.2599ms,0.0
+ 90.2600ms,3.3V 90.2637ms,3.3
+ 90.2638ms,0.0V 90.2799ms,0.0
+ 90.2800ms,3.3V 90.2837ms,3.3
+ 90.2838ms,0.0V 90.2999ms,0.0
+ 90.3000ms,3.3V 90.3037ms,3.3
+ 90.3038ms,0.0V 90.3199ms,0.0
+ 90.3200ms,3.3V 90.3237ms,3.3
+ 90.3238ms,0.0V 90.3399ms,0.0
+ 90.3400ms,3.3V 90.3437ms,3.3
+ 90.3438ms,0.0V 90.3599ms,0.0
+ 90.3600ms,3.3V 90.3637ms,3.3
+ 90.3638ms,0.0V 90.3799ms,0.0
+ 90.3800ms,3.3V 90.3837ms,3.3
+ 90.3838ms,0.0V 90.3999ms,0.0
+ 90.4000ms,3.3V 90.4037ms,3.3
+ 90.4038ms,0.0V 90.4199ms,0.0
+ 90.4200ms,3.3V 90.4237ms,3.3
+ 90.4238ms,0.0V 90.4399ms,0.0
+ 90.4400ms,3.3V 90.4437ms,3.3
+ 90.4438ms,0.0V 90.4599ms,0.0
+ 90.4600ms,3.3V 90.4637ms,3.3
+ 90.4638ms,0.0V 90.4799ms,0.0
+ 90.4800ms,3.3V 90.4837ms,3.3
+ 90.4838ms,0.0V 90.4999ms,0.0
+ 90.5000ms,3.3V 90.5037ms,3.3
+ 90.5038ms,0.0V 90.5199ms,0.0
+ 90.5200ms,3.3V 90.5237ms,3.3
+ 90.5238ms,0.0V 90.5399ms,0.0
+ 90.5400ms,3.3V 90.5437ms,3.3
+ 90.5438ms,0.0V 90.5599ms,0.0
+ 90.5600ms,3.3V 90.5637ms,3.3
+ 90.5638ms,0.0V 90.5799ms,0.0
+ 90.5800ms,3.3V 90.5837ms,3.3
+ 90.5838ms,0.0V 90.5999ms,0.0
+ 90.6000ms,3.3V 90.6037ms,3.3
+ 90.6038ms,0.0V 90.6199ms,0.0
+ 90.6200ms,3.3V 90.6237ms,3.3
+ 90.6238ms,0.0V 90.6399ms,0.0
+ 90.6400ms,3.3V 90.6437ms,3.3
+ 90.6438ms,0.0V 90.6599ms,0.0
+ 90.6600ms,3.3V 90.6637ms,3.3
+ 90.6638ms,0.0V 90.6799ms,0.0
+ 90.6800ms,3.3V 90.6837ms,3.3
+ 90.6838ms,0.0V 90.6999ms,0.0
+ 90.7000ms,3.3V 90.7037ms,3.3
+ 90.7038ms,0.0V 90.7199ms,0.0
+ 90.7200ms,3.3V 90.7237ms,3.3
+ 90.7238ms,0.0V 90.7399ms,0.0
+ 90.7400ms,3.3V 90.7437ms,3.3
+ 90.7438ms,0.0V 90.7599ms,0.0
+ 90.7600ms,3.3V 90.7637ms,3.3
+ 90.7638ms,0.0V 90.7799ms,0.0
+ 90.7800ms,3.3V 90.7837ms,3.3
+ 90.7838ms,0.0V 90.7999ms,0.0
+ 90.8000ms,3.3V 90.8037ms,3.3
+ 90.8038ms,0.0V 90.8199ms,0.0
+ 90.8200ms,3.3V 90.8237ms,3.3
+ 90.8238ms,0.0V 90.8399ms,0.0
+ 90.8400ms,3.3V 90.8437ms,3.3
+ 90.8438ms,0.0V 90.8599ms,0.0
+ 90.8600ms,3.3V 90.8637ms,3.3
+ 90.8638ms,0.0V 90.8799ms,0.0
+ 90.8800ms,3.3V 90.8837ms,3.3
+ 90.8838ms,0.0V 90.8999ms,0.0
+ 90.9000ms,3.3V 90.9037ms,3.3
+ 90.9038ms,0.0V 90.9199ms,0.0
+ 90.9200ms,3.3V 90.9237ms,3.3
+ 90.9238ms,0.0V 90.9399ms,0.0
+ 90.9400ms,3.3V 90.9437ms,3.3
+ 90.9438ms,0.0V 90.9599ms,0.0
+ 90.9600ms,3.3V 90.9637ms,3.3
+ 90.9638ms,0.0V 90.9799ms,0.0
+ 90.9800ms,3.3V 90.9837ms,3.3
+ 90.9838ms,0.0V 90.9999ms,0.0
+ 91.0000ms,3.3V 91.0037ms,3.3
+ 91.0038ms,0.0V 91.0199ms,0.0
+ 91.0200ms,3.3V 91.0237ms,3.3
+ 91.0238ms,0.0V 91.0399ms,0.0
+ 91.0400ms,3.3V 91.0437ms,3.3
+ 91.0438ms,0.0V 91.0599ms,0.0
+ 91.0600ms,3.3V 91.0637ms,3.3
+ 91.0638ms,0.0V 91.0799ms,0.0
+ 91.0800ms,3.3V 91.0837ms,3.3
+ 91.0838ms,0.0V 91.0999ms,0.0
+ 91.1000ms,3.3V 91.1037ms,3.3
+ 91.1038ms,0.0V 91.1199ms,0.0
+ 91.1200ms,3.3V 91.1237ms,3.3
+ 91.1238ms,0.0V 91.1399ms,0.0
+ 91.1400ms,3.3V 91.1437ms,3.3
+ 91.1438ms,0.0V 91.1599ms,0.0
+ 91.1600ms,3.3V 91.1637ms,3.3
+ 91.1638ms,0.0V 91.1799ms,0.0
+ 91.1800ms,3.3V 91.1837ms,3.3
+ 91.1838ms,0.0V 91.1999ms,0.0
+ 91.2000ms,3.3V 91.2037ms,3.3
+ 91.2038ms,0.0V 91.2199ms,0.0
+ 91.2200ms,3.3V 91.2237ms,3.3
+ 91.2238ms,0.0V 91.2399ms,0.0
+ 91.2400ms,3.3V 91.2437ms,3.3
+ 91.2438ms,0.0V 91.2599ms,0.0
+ 91.2600ms,3.3V 91.2637ms,3.3
+ 91.2638ms,0.0V 91.2799ms,0.0
+ 91.2800ms,3.3V 91.2837ms,3.3
+ 91.2838ms,0.0V 91.2999ms,0.0
+ 91.3000ms,3.3V 91.3037ms,3.3
+ 91.3038ms,0.0V 91.3199ms,0.0
+ 91.3200ms,3.3V 91.3237ms,3.3
+ 91.3238ms,0.0V 91.3399ms,0.0
+ 91.3400ms,3.3V 91.3437ms,3.3
+ 91.3438ms,0.0V 91.3599ms,0.0
+ 91.3600ms,3.3V 91.3637ms,3.3
+ 91.3638ms,0.0V 91.3799ms,0.0
+ 91.3800ms,3.3V 91.3837ms,3.3
+ 91.3838ms,0.0V 91.3999ms,0.0
+ 91.4000ms,3.3V 91.4037ms,3.3
+ 91.4038ms,0.0V 91.4199ms,0.0
+ 91.4200ms,3.3V 91.4237ms,3.3
+ 91.4238ms,0.0V 91.4399ms,0.0
+ 91.4400ms,3.3V 91.4437ms,3.3
+ 91.4438ms,0.0V 91.4599ms,0.0
+ 91.4600ms,3.3V 91.4637ms,3.3
+ 91.4638ms,0.0V 91.4799ms,0.0
+ 91.4800ms,3.3V 91.4837ms,3.3
+ 91.4838ms,0.0V 91.4999ms,0.0
+ 91.5000ms,3.3V 91.5037ms,3.3
+ 91.5038ms,0.0V 91.5199ms,0.0
+ 91.5200ms,3.3V 91.5237ms,3.3
+ 91.5238ms,0.0V 91.5399ms,0.0
+ 91.5400ms,3.3V 91.5437ms,3.3
+ 91.5438ms,0.0V 91.5599ms,0.0
+ 91.5600ms,3.3V 91.5637ms,3.3
+ 91.5638ms,0.0V 91.5799ms,0.0
+ 91.5800ms,3.3V 91.5837ms,3.3
+ 91.5838ms,0.0V 91.5999ms,0.0
+ 91.6000ms,3.3V 91.6037ms,3.3
+ 91.6038ms,0.0V 91.6199ms,0.0
+ 91.6200ms,3.3V 91.6237ms,3.3
+ 91.6238ms,0.0V 91.6399ms,0.0
+ 91.6400ms,3.3V 91.6437ms,3.3
+ 91.6438ms,0.0V 91.6599ms,0.0
+ 91.6600ms,3.3V 91.6637ms,3.3
+ 91.6638ms,0.0V 91.6799ms,0.0
+ 91.6800ms,3.3V 91.6837ms,3.3
+ 91.6838ms,0.0V 91.6999ms,0.0
+ 91.7000ms,3.3V 91.7037ms,3.3
+ 91.7038ms,0.0V 91.7199ms,0.0
+ 91.7200ms,3.3V 91.7237ms,3.3
+ 91.7238ms,0.0V 91.7399ms,0.0
+ 91.7400ms,3.3V 91.7437ms,3.3
+ 91.7438ms,0.0V 91.7599ms,0.0
+ 91.7600ms,3.3V 91.7637ms,3.3
+ 91.7638ms,0.0V 91.7799ms,0.0
+ 91.7800ms,3.3V 91.7837ms,3.3
+ 91.7838ms,0.0V 91.7999ms,0.0
+ 91.8000ms,3.3V 91.8037ms,3.3
+ 91.8038ms,0.0V 91.8199ms,0.0
+ 91.8200ms,3.3V 91.8237ms,3.3
+ 91.8238ms,0.0V 91.8399ms,0.0
+ 91.8400ms,3.3V 91.8437ms,3.3
+ 91.8438ms,0.0V 91.8599ms,0.0
+ 91.8600ms,3.3V 91.8637ms,3.3
+ 91.8638ms,0.0V 91.8799ms,0.0
+ 91.8800ms,3.3V 91.8837ms,3.3
+ 91.8838ms,0.0V 91.8999ms,0.0
+ 91.9000ms,3.3V 91.9037ms,3.3
+ 91.9038ms,0.0V 91.9199ms,0.0
+ 91.9200ms,3.3V 91.9237ms,3.3
+ 91.9238ms,0.0V 91.9399ms,0.0
+ 91.9400ms,3.3V 91.9437ms,3.3
+ 91.9438ms,0.0V 91.9599ms,0.0
+ 91.9600ms,3.3V 91.9637ms,3.3
+ 91.9638ms,0.0V 91.9799ms,0.0
+ 91.9800ms,3.3V 91.9837ms,3.3
+ 91.9838ms,0.0V 91.9999ms,0.0
+ 92.0000ms,3.3V 92.0037ms,3.3
+ 92.0038ms,0.0V 92.0199ms,0.0
+ 92.0200ms,3.3V 92.0237ms,3.3
+ 92.0238ms,0.0V 92.0399ms,0.0
+ 92.0400ms,3.3V 92.0437ms,3.3
+ 92.0438ms,0.0V 92.0599ms,0.0
+ 92.0600ms,3.3V 92.0637ms,3.3
+ 92.0638ms,0.0V 92.0799ms,0.0
+ 92.0800ms,3.3V 92.0837ms,3.3
+ 92.0838ms,0.0V 92.0999ms,0.0
+ 92.1000ms,3.3V 92.1037ms,3.3
+ 92.1038ms,0.0V 92.1199ms,0.0
+ 92.1200ms,3.3V 92.1237ms,3.3
+ 92.1238ms,0.0V 92.1399ms,0.0
+ 92.1400ms,3.3V 92.1437ms,3.3
+ 92.1438ms,0.0V 92.1599ms,0.0
+ 92.1600ms,3.3V 92.1637ms,3.3
+ 92.1638ms,0.0V 92.1799ms,0.0
+ 92.1800ms,3.3V 92.1837ms,3.3
+ 92.1838ms,0.0V 92.1999ms,0.0
+ 92.2000ms,3.3V 92.2037ms,3.3
+ 92.2038ms,0.0V 92.2199ms,0.0
+ 92.2200ms,3.3V 92.2237ms,3.3
+ 92.2238ms,0.0V 92.2399ms,0.0
+ 92.2400ms,3.3V 92.2437ms,3.3
+ 92.2438ms,0.0V 92.2599ms,0.0
+ 92.2600ms,3.3V 92.2637ms,3.3
+ 92.2638ms,0.0V 92.2799ms,0.0
+ 92.2800ms,3.3V 92.2837ms,3.3
+ 92.2838ms,0.0V 92.2999ms,0.0
+ 92.3000ms,3.3V 92.3037ms,3.3
+ 92.3038ms,0.0V 92.3199ms,0.0
+ 92.3200ms,3.3V 92.3237ms,3.3
+ 92.3238ms,0.0V 92.3399ms,0.0
+ 92.3400ms,3.3V 92.3437ms,3.3
+ 92.3438ms,0.0V 92.3599ms,0.0
+ 92.3600ms,3.3V 92.3637ms,3.3
+ 92.3638ms,0.0V 92.3799ms,0.0
+ 92.3800ms,3.3V 92.3837ms,3.3
+ 92.3838ms,0.0V 92.3999ms,0.0
+ 92.4000ms,3.3V 92.4037ms,3.3
+ 92.4038ms,0.0V 92.4199ms,0.0
+ 92.4200ms,3.3V 92.4237ms,3.3
+ 92.4238ms,0.0V 92.4399ms,0.0
+ 92.4400ms,3.3V 92.4437ms,3.3
+ 92.4438ms,0.0V 92.4599ms,0.0
+ 92.4600ms,3.3V 92.4637ms,3.3
+ 92.4638ms,0.0V 92.4799ms,0.0
+ 92.4800ms,3.3V 92.4837ms,3.3
+ 92.4838ms,0.0V 92.4999ms,0.0
+ 92.5000ms,3.3V 92.5037ms,3.3
+ 92.5038ms,0.0V 92.5199ms,0.0
+ 92.5200ms,3.3V 92.5237ms,3.3
+ 92.5238ms,0.0V 92.5399ms,0.0
+ 92.5400ms,3.3V 92.5437ms,3.3
+ 92.5438ms,0.0V 92.5599ms,0.0
+ 92.5600ms,3.3V 92.5637ms,3.3
+ 92.5638ms,0.0V 92.5799ms,0.0
+ 92.5800ms,3.3V 92.5837ms,3.3
+ 92.5838ms,0.0V 92.5999ms,0.0
+ 92.6000ms,3.3V 92.6037ms,3.3
+ 92.6038ms,0.0V 92.6199ms,0.0
+ 92.6200ms,3.3V 92.6237ms,3.3
+ 92.6238ms,0.0V 92.6399ms,0.0
+ 92.6400ms,3.3V 92.6437ms,3.3
+ 92.6438ms,0.0V 92.6599ms,0.0
+ 92.6600ms,3.3V 92.6637ms,3.3
+ 92.6638ms,0.0V 92.6799ms,0.0
+ 92.6800ms,3.3V 92.6837ms,3.3
+ 92.6838ms,0.0V 92.6999ms,0.0
+ 92.7000ms,3.3V 92.7037ms,3.3
+ 92.7038ms,0.0V 92.7199ms,0.0
+ 92.7200ms,3.3V 92.7237ms,3.3
+ 92.7238ms,0.0V 92.7399ms,0.0
+ 92.7400ms,3.3V 92.7437ms,3.3
+ 92.7438ms,0.0V 92.7599ms,0.0
+ 92.7600ms,3.3V 92.7637ms,3.3
+ 92.7638ms,0.0V 92.7799ms,0.0
+ 92.7800ms,3.3V 92.7837ms,3.3
+ 92.7838ms,0.0V 92.7999ms,0.0
+ 92.8000ms,3.3V 92.8037ms,3.3
+ 92.8038ms,0.0V 92.8199ms,0.0
+ 92.8200ms,3.3V 92.8237ms,3.3
+ 92.8238ms,0.0V 92.8399ms,0.0
+ 92.8400ms,3.3V 92.8437ms,3.3
+ 92.8438ms,0.0V 92.8599ms,0.0
+ 92.8600ms,3.3V 92.8637ms,3.3
+ 92.8638ms,0.0V 92.8799ms,0.0
+ 92.8800ms,3.3V 92.8837ms,3.3
+ 92.8838ms,0.0V 92.8999ms,0.0
+ 92.9000ms,3.3V 92.9037ms,3.3
+ 92.9038ms,0.0V 92.9199ms,0.0
+ 92.9200ms,3.3V 92.9237ms,3.3
+ 92.9238ms,0.0V 92.9399ms,0.0
+ 92.9400ms,3.3V 92.9437ms,3.3
+ 92.9438ms,0.0V 92.9599ms,0.0
+ 92.9600ms,3.3V 92.9637ms,3.3
+ 92.9638ms,0.0V 92.9799ms,0.0
+ 92.9800ms,3.3V 92.9837ms,3.3
+ 92.9838ms,0.0V 92.9999ms,0.0
+ 93.0000ms,3.3V 93.0037ms,3.3
+ 93.0038ms,0.0V 93.0199ms,0.0
+ 93.0200ms,3.3V 93.0237ms,3.3
+ 93.0238ms,0.0V 93.0399ms,0.0
+ 93.0400ms,3.3V 93.0437ms,3.3
+ 93.0438ms,0.0V 93.0599ms,0.0
+ 93.0600ms,3.3V 93.0637ms,3.3
+ 93.0638ms,0.0V 93.0799ms,0.0
+ 93.0800ms,3.3V 93.0837ms,3.3
+ 93.0838ms,0.0V 93.0999ms,0.0
+ 93.1000ms,3.3V 93.1037ms,3.3
+ 93.1038ms,0.0V 93.1199ms,0.0
+ 93.1200ms,3.3V 93.1237ms,3.3
+ 93.1238ms,0.0V 93.1399ms,0.0
+ 93.1400ms,3.3V 93.1437ms,3.3
+ 93.1438ms,0.0V 93.1599ms,0.0
+ 93.1600ms,3.3V 93.1637ms,3.3
+ 93.1638ms,0.0V 93.1799ms,0.0
+ 93.1800ms,3.3V 93.1837ms,3.3
+ 93.1838ms,0.0V 93.1999ms,0.0
+ 93.2000ms,3.3V 93.2037ms,3.3
+ 93.2038ms,0.0V 93.2199ms,0.0
+ 93.2200ms,3.3V 93.2237ms,3.3
+ 93.2238ms,0.0V 93.2399ms,0.0
+ 93.2400ms,3.3V 93.2437ms,3.3
+ 93.2438ms,0.0V 93.2599ms,0.0
+ 93.2600ms,3.3V 93.2637ms,3.3
+ 93.2638ms,0.0V 93.2799ms,0.0
+ 93.2800ms,3.3V 93.2837ms,3.3
+ 93.2838ms,0.0V 93.2999ms,0.0
+ 93.3000ms,3.3V 93.3037ms,3.3
+ 93.3038ms,0.0V 93.3199ms,0.0
+ 93.3200ms,3.3V 93.3237ms,3.3
+ 93.3238ms,0.0V 93.3399ms,0.0
+ 93.3400ms,3.3V 93.3437ms,3.3
+ 93.3438ms,0.0V 93.3599ms,0.0
+ 93.3600ms,3.3V 93.3637ms,3.3
+ 93.3638ms,0.0V 93.3799ms,0.0
+ 93.3800ms,3.3V 93.3837ms,3.3
+ 93.3838ms,0.0V 93.3999ms,0.0
+ 93.4000ms,3.3V 93.4037ms,3.3
+ 93.4038ms,0.0V 93.4199ms,0.0
+ 93.4200ms,3.3V 93.4237ms,3.3
+ 93.4238ms,0.0V 93.4399ms,0.0
+ 93.4400ms,3.3V 93.4437ms,3.3
+ 93.4438ms,0.0V 93.4599ms,0.0
+ 93.4600ms,3.3V 93.4637ms,3.3
+ 93.4638ms,0.0V 93.4799ms,0.0
+ 93.4800ms,3.3V 93.4837ms,3.3
+ 93.4838ms,0.0V 93.4999ms,0.0
+ 93.5000ms,3.3V 93.5037ms,3.3
+ 93.5038ms,0.0V 93.5199ms,0.0
+ 93.5200ms,3.3V 93.5237ms,3.3
+ 93.5238ms,0.0V 93.5399ms,0.0
+ 93.5400ms,3.3V 93.5437ms,3.3
+ 93.5438ms,0.0V 93.5599ms,0.0
+ 93.5600ms,3.3V 93.5637ms,3.3
+ 93.5638ms,0.0V 93.5799ms,0.0
+ 93.5800ms,3.3V 93.5837ms,3.3
+ 93.5838ms,0.0V 93.5999ms,0.0
+ 93.6000ms,3.3V 93.6037ms,3.3
+ 93.6038ms,0.0V 93.6199ms,0.0
+ 93.6200ms,3.3V 93.6237ms,3.3
+ 93.6238ms,0.0V 93.6399ms,0.0
+ 93.6400ms,3.3V 93.6437ms,3.3
+ 93.6438ms,0.0V 93.6599ms,0.0
+ 93.6600ms,3.3V 93.6637ms,3.3
+ 93.6638ms,0.0V 93.6799ms,0.0
+ 93.6800ms,3.3V 93.6837ms,3.3
+ 93.6838ms,0.0V 93.6999ms,0.0
+ 93.7000ms,3.3V 93.7037ms,3.3
+ 93.7038ms,0.0V 93.7199ms,0.0
+ 93.7200ms,3.3V 93.7237ms,3.3
+ 93.7238ms,0.0V 93.7399ms,0.0
+ 93.7400ms,3.3V 93.7437ms,3.3
+ 93.7438ms,0.0V 93.7599ms,0.0
+ 93.7600ms,3.3V 93.7637ms,3.3
+ 93.7638ms,0.0V 93.7799ms,0.0
+ 93.7800ms,3.3V 93.7837ms,3.3
+ 93.7838ms,0.0V 93.7999ms,0.0
+ 93.8000ms,3.3V 93.8037ms,3.3
+ 93.8038ms,0.0V 93.8199ms,0.0
+ 93.8200ms,3.3V 93.8237ms,3.3
+ 93.8238ms,0.0V 93.8399ms,0.0
+ 93.8400ms,3.3V 93.8437ms,3.3
+ 93.8438ms,0.0V 93.8599ms,0.0
+ 93.8600ms,3.3V 93.8637ms,3.3
+ 93.8638ms,0.0V 93.8799ms,0.0
+ 93.8800ms,3.3V 93.8837ms,3.3
+ 93.8838ms,0.0V 93.8999ms,0.0
+ 93.9000ms,3.3V 93.9037ms,3.3
+ 93.9038ms,0.0V 93.9199ms,0.0
+ 93.9200ms,3.3V 93.9237ms,3.3
+ 93.9238ms,0.0V 93.9399ms,0.0
+ 93.9400ms,3.3V 93.9437ms,3.3
+ 93.9438ms,0.0V 93.9599ms,0.0
+ 93.9600ms,3.3V 93.9637ms,3.3
+ 93.9638ms,0.0V 93.9799ms,0.0
+ 93.9800ms,3.3V 93.9837ms,3.3
+ 93.9838ms,0.0V 93.9999ms,0.0
+ 94.0000ms,3.3V 94.0037ms,3.3
+ 94.0038ms,0.0V 94.0199ms,0.0
+ 94.0200ms,3.3V 94.0237ms,3.3
+ 94.0238ms,0.0V 94.0399ms,0.0
+ 94.0400ms,3.3V 94.0437ms,3.3
+ 94.0438ms,0.0V 94.0599ms,0.0
+ 94.0600ms,3.3V 94.0637ms,3.3
+ 94.0638ms,0.0V 94.0799ms,0.0
+ 94.0800ms,3.3V 94.0837ms,3.3
+ 94.0838ms,0.0V 94.0999ms,0.0
+ 94.1000ms,3.3V 94.1037ms,3.3
+ 94.1038ms,0.0V 94.1199ms,0.0
+ 94.1200ms,3.3V 94.1237ms,3.3
+ 94.1238ms,0.0V 94.1399ms,0.0
+ 94.1400ms,3.3V 94.1437ms,3.3
+ 94.1438ms,0.0V 94.1599ms,0.0
+ 94.1600ms,3.3V 94.1637ms,3.3
+ 94.1638ms,0.0V 94.1799ms,0.0
+ 94.1800ms,3.3V 94.1837ms,3.3
+ 94.1838ms,0.0V 94.1999ms,0.0
+ 94.2000ms,3.3V 94.2037ms,3.3
+ 94.2038ms,0.0V 94.2199ms,0.0
+ 94.2200ms,3.3V 94.2237ms,3.3
+ 94.2238ms,0.0V 94.2399ms,0.0
+ 94.2400ms,3.3V 94.2437ms,3.3
+ 94.2438ms,0.0V 94.2599ms,0.0
+ 94.2600ms,3.3V 94.2637ms,3.3
+ 94.2638ms,0.0V 94.2799ms,0.0
+ 94.2800ms,3.3V 94.2837ms,3.3
+ 94.2838ms,0.0V 94.2999ms,0.0
+ 94.3000ms,3.3V 94.3037ms,3.3
+ 94.3038ms,0.0V 94.3199ms,0.0
+ 94.3200ms,3.3V 94.3237ms,3.3
+ 94.3238ms,0.0V 94.3399ms,0.0
+ 94.3400ms,3.3V 94.3437ms,3.3
+ 94.3438ms,0.0V 94.3599ms,0.0
+ 94.3600ms,3.3V 94.3637ms,3.3
+ 94.3638ms,0.0V 94.3799ms,0.0
+ 94.3800ms,3.3V 94.3837ms,3.3
+ 94.3838ms,0.0V 94.3999ms,0.0
+ 94.4000ms,3.3V 94.4037ms,3.3
+ 94.4038ms,0.0V 94.4199ms,0.0
+ 94.4200ms,3.3V 94.4237ms,3.3
+ 94.4238ms,0.0V 94.4399ms,0.0
+ 94.4400ms,3.3V 94.4437ms,3.3
+ 94.4438ms,0.0V 94.4599ms,0.0
+ 94.4600ms,3.3V 94.4637ms,3.3
+ 94.4638ms,0.0V 94.4799ms,0.0
+ 94.4800ms,3.3V 94.4837ms,3.3
+ 94.4838ms,0.0V 94.4999ms,0.0
+ 94.5000ms,3.3V 94.5037ms,3.3
+ 94.5038ms,0.0V 94.5199ms,0.0
+ 94.5200ms,3.3V 94.5237ms,3.3
+ 94.5238ms,0.0V 94.5399ms,0.0
+ 94.5400ms,3.3V 94.5437ms,3.3
+ 94.5438ms,0.0V 94.5599ms,0.0
+ 94.5600ms,3.3V 94.5637ms,3.3
+ 94.5638ms,0.0V 94.5799ms,0.0
+ 94.5800ms,3.3V 94.5837ms,3.3
+ 94.5838ms,0.0V 94.5999ms,0.0
+ 94.6000ms,3.3V 94.6037ms,3.3
+ 94.6038ms,0.0V 94.6199ms,0.0
+ 94.6200ms,3.3V 94.6237ms,3.3
+ 94.6238ms,0.0V 94.6399ms,0.0
+ 94.6400ms,3.3V 94.6437ms,3.3
+ 94.6438ms,0.0V 94.6599ms,0.0
+ 94.6600ms,3.3V 94.6637ms,3.3
+ 94.6638ms,0.0V 94.6799ms,0.0
+ 94.6800ms,3.3V 94.6837ms,3.3
+ 94.6838ms,0.0V 94.6999ms,0.0
+ 94.7000ms,3.3V 94.7037ms,3.3
+ 94.7038ms,0.0V 94.7199ms,0.0
+ 94.7200ms,3.3V 94.7237ms,3.3
+ 94.7238ms,0.0V 94.7399ms,0.0
+ 94.7400ms,3.3V 94.7437ms,3.3
+ 94.7438ms,0.0V 94.7599ms,0.0
+ 94.7600ms,3.3V 94.7637ms,3.3
+ 94.7638ms,0.0V 94.7799ms,0.0
+ 94.7800ms,3.3V 94.7837ms,3.3
+ 94.7838ms,0.0V 94.7999ms,0.0
+ 94.8000ms,3.3V 94.8037ms,3.3
+ 94.8038ms,0.0V 94.8199ms,0.0
+ 94.8200ms,3.3V 94.8237ms,3.3
+ 94.8238ms,0.0V 94.8399ms,0.0
+ 94.8400ms,3.3V 94.8437ms,3.3
+ 94.8438ms,0.0V 94.8599ms,0.0
+ 94.8600ms,3.3V 94.8637ms,3.3
+ 94.8638ms,0.0V 94.8799ms,0.0
+ 94.8800ms,3.3V 94.8837ms,3.3
+ 94.8838ms,0.0V 94.8999ms,0.0
+ 94.9000ms,3.3V 94.9037ms,3.3
+ 94.9038ms,0.0V 94.9199ms,0.0
+ 94.9200ms,3.3V 94.9237ms,3.3
+ 94.9238ms,0.0V 94.9399ms,0.0
+ 94.9400ms,3.3V 94.9437ms,3.3
+ 94.9438ms,0.0V 94.9599ms,0.0
+ 94.9600ms,3.3V 94.9637ms,3.3
+ 94.9638ms,0.0V 94.9799ms,0.0
+ 94.9800ms,3.3V 94.9837ms,3.3
+ 94.9838ms,0.0V 94.9999ms,0.0
+ 95.0000ms,3.3V 95.0037ms,3.3
+ 95.0038ms,0.0V 95.0199ms,0.0
+ 95.0200ms,3.3V 95.0237ms,3.3
+ 95.0238ms,0.0V 95.0399ms,0.0
+ 95.0400ms,3.3V 95.0437ms,3.3
+ 95.0438ms,0.0V 95.0599ms,0.0
+ 95.0600ms,3.3V 95.0637ms,3.3
+ 95.0638ms,0.0V 95.0799ms,0.0
+ 95.0800ms,3.3V 95.0837ms,3.3
+ 95.0838ms,0.0V 95.0999ms,0.0
+ 95.1000ms,3.3V 95.1037ms,3.3
+ 95.1038ms,0.0V 95.1199ms,0.0
+ 95.1200ms,3.3V 95.1237ms,3.3
+ 95.1238ms,0.0V 95.1399ms,0.0
+ 95.1400ms,3.3V 95.1437ms,3.3
+ 95.1438ms,0.0V 95.1599ms,0.0
+ 95.1600ms,3.3V 95.1637ms,3.3
+ 95.1638ms,0.0V 95.1799ms,0.0
+ 95.1800ms,3.3V 95.1837ms,3.3
+ 95.1838ms,0.0V 95.1999ms,0.0
+ 95.2000ms,3.3V 95.2037ms,3.3
+ 95.2038ms,0.0V 95.2199ms,0.0
+ 95.2200ms,3.3V 95.2237ms,3.3
+ 95.2238ms,0.0V 95.2399ms,0.0
+ 95.2400ms,3.3V 95.2439ms,3.3
+ 95.2440ms,0.0V 95.2599ms,0.0
+ 95.2600ms,3.3V 95.2639ms,3.3
+ 95.2640ms,0.0V 95.2799ms,0.0
+ 95.2800ms,3.3V 95.2839ms,3.3
+ 95.2840ms,0.0V 95.2999ms,0.0
+ 95.3000ms,3.3V 95.3039ms,3.3
+ 95.3040ms,0.0V 95.3199ms,0.0
+ 95.3200ms,3.3V 95.3239ms,3.3
+ 95.3240ms,0.0V 95.3399ms,0.0
+ 95.3400ms,3.3V 95.3439ms,3.3
+ 95.3440ms,0.0V 95.3599ms,0.0
+ 95.3600ms,3.3V 95.3639ms,3.3
+ 95.3640ms,0.0V 95.3799ms,0.0
+ 95.3800ms,3.3V 95.3839ms,3.3
+ 95.3840ms,0.0V 95.3999ms,0.0
+ 95.4000ms,3.3V 95.4039ms,3.3
+ 95.4040ms,0.0V 95.4199ms,0.0
+ 95.4200ms,3.3V 95.4239ms,3.3
+ 95.4240ms,0.0V 95.4399ms,0.0
+ 95.4400ms,3.3V 95.4439ms,3.3
+ 95.4440ms,0.0V 95.4599ms,0.0
+ 95.4600ms,3.3V 95.4639ms,3.3
+ 95.4640ms,0.0V 95.4799ms,0.0
+ 95.4800ms,3.3V 95.4839ms,3.3
+ 95.4840ms,0.0V 95.4999ms,0.0
+ 95.5000ms,3.3V 95.5039ms,3.3
+ 95.5040ms,0.0V 95.5199ms,0.0
+ 95.5200ms,3.3V 95.5239ms,3.3
+ 95.5240ms,0.0V 95.5399ms,0.0
+ 95.5400ms,3.3V 95.5439ms,3.3
+ 95.5440ms,0.0V 95.5599ms,0.0
+ 95.5600ms,3.3V 95.5639ms,3.3
+ 95.5640ms,0.0V 95.5799ms,0.0
+ 95.5800ms,3.3V 95.5839ms,3.3
+ 95.5840ms,0.0V 95.5999ms,0.0
+ 95.6000ms,3.3V 95.6039ms,3.3
+ 95.6040ms,0.0V 95.6199ms,0.0
+ 95.6200ms,3.3V 95.6239ms,3.3
+ 95.6240ms,0.0V 95.6399ms,0.0
+ 95.6400ms,3.3V 95.6439ms,3.3
+ 95.6440ms,0.0V 95.6599ms,0.0
+ 95.6600ms,3.3V 95.6639ms,3.3
+ 95.6640ms,0.0V 95.6799ms,0.0
+ 95.6800ms,3.3V 95.6839ms,3.3
+ 95.6840ms,0.0V 95.6999ms,0.0
+ 95.7000ms,3.3V 95.7039ms,3.3
+ 95.7040ms,0.0V 95.7199ms,0.0
+ 95.7200ms,3.3V 95.7239ms,3.3
+ 95.7240ms,0.0V 95.7399ms,0.0
+ 95.7400ms,3.3V 95.7439ms,3.3
+ 95.7440ms,0.0V 95.7599ms,0.0
+ 95.7600ms,3.3V 95.7639ms,3.3
+ 95.7640ms,0.0V 95.7799ms,0.0
+ 95.7800ms,3.3V 95.7839ms,3.3
+ 95.7840ms,0.0V 95.7999ms,0.0
+ 95.8000ms,3.3V 95.8039ms,3.3
+ 95.8040ms,0.0V 95.8199ms,0.0
+ 95.8200ms,3.3V 95.8239ms,3.3
+ 95.8240ms,0.0V 95.8399ms,0.0
+ 95.8400ms,3.3V 95.8439ms,3.3
+ 95.8440ms,0.0V 95.8599ms,0.0
+ 95.8600ms,3.3V 95.8639ms,3.3
+ 95.8640ms,0.0V 95.8799ms,0.0
+ 95.8800ms,3.3V 95.8839ms,3.3
+ 95.8840ms,0.0V 95.8999ms,0.0
+ 95.9000ms,3.3V 95.9039ms,3.3
+ 95.9040ms,0.0V 95.9199ms,0.0
+ 95.9200ms,3.3V 95.9239ms,3.3
+ 95.9240ms,0.0V 95.9399ms,0.0
+ 95.9400ms,3.3V 95.9439ms,3.3
+ 95.9440ms,0.0V 95.9599ms,0.0
+ 95.9600ms,3.3V 95.9639ms,3.3
+ 95.9640ms,0.0V 95.9799ms,0.0
+ 95.9800ms,3.3V 95.9839ms,3.3
+ 95.9840ms,0.0V 95.9999ms,0.0
+ 96.0000ms,3.3V 96.0039ms,3.3
+ 96.0040ms,0.0V 96.0199ms,0.0
+ 96.0200ms,3.3V 96.0239ms,3.3
+ 96.0240ms,0.0V 96.0399ms,0.0
+ 96.0400ms,3.3V 96.0439ms,3.3
+ 96.0440ms,0.0V 96.0599ms,0.0
+ 96.0600ms,3.3V 96.0639ms,3.3
+ 96.0640ms,0.0V 96.0799ms,0.0
+ 96.0800ms,3.3V 96.0839ms,3.3
+ 96.0840ms,0.0V 96.0999ms,0.0
+ 96.1000ms,3.3V 96.1039ms,3.3
+ 96.1040ms,0.0V 96.1199ms,0.0
+ 96.1200ms,3.3V 96.1239ms,3.3
+ 96.1240ms,0.0V 96.1399ms,0.0
+ 96.1400ms,3.3V 96.1439ms,3.3
+ 96.1440ms,0.0V 96.1599ms,0.0
+ 96.1600ms,3.3V 96.1639ms,3.3
+ 96.1640ms,0.0V 96.1799ms,0.0
+ 96.1800ms,3.3V 96.1839ms,3.3
+ 96.1840ms,0.0V 96.1999ms,0.0
+ 96.2000ms,3.3V 96.2039ms,3.3
+ 96.2040ms,0.0V 96.2199ms,0.0
+ 96.2200ms,3.3V 96.2239ms,3.3
+ 96.2240ms,0.0V 96.2399ms,0.0
+ 96.2400ms,3.3V 96.2439ms,3.3
+ 96.2440ms,0.0V 96.2599ms,0.0
+ 96.2600ms,3.3V 96.2639ms,3.3
+ 96.2640ms,0.0V 96.2799ms,0.0
+ 96.2800ms,3.3V 96.2839ms,3.3
+ 96.2840ms,0.0V 96.2999ms,0.0
+ 96.3000ms,3.3V 96.3039ms,3.3
+ 96.3040ms,0.0V 96.3199ms,0.0
+ 96.3200ms,3.3V 96.3239ms,3.3
+ 96.3240ms,0.0V 96.3399ms,0.0
+ 96.3400ms,3.3V 96.3439ms,3.3
+ 96.3440ms,0.0V 96.3599ms,0.0
+ 96.3600ms,3.3V 96.3639ms,3.3
+ 96.3640ms,0.0V 96.3799ms,0.0
+ 96.3800ms,3.3V 96.3839ms,3.3
+ 96.3840ms,0.0V 96.3999ms,0.0
+ 96.4000ms,3.3V 96.4039ms,3.3
+ 96.4040ms,0.0V 96.4199ms,0.0
+ 96.4200ms,3.3V 96.4239ms,3.3
+ 96.4240ms,0.0V 96.4399ms,0.0
+ 96.4400ms,3.3V 96.4439ms,3.3
+ 96.4440ms,0.0V 96.4599ms,0.0
+ 96.4600ms,3.3V 96.4639ms,3.3
+ 96.4640ms,0.0V 96.4799ms,0.0
+ 96.4800ms,3.3V 96.4839ms,3.3
+ 96.4840ms,0.0V 96.4999ms,0.0
+ 96.5000ms,3.3V 96.5039ms,3.3
+ 96.5040ms,0.0V 96.5199ms,0.0
+ 96.5200ms,3.3V 96.5239ms,3.3
+ 96.5240ms,0.0V 96.5399ms,0.0
+ 96.5400ms,3.3V 96.5439ms,3.3
+ 96.5440ms,0.0V 96.5599ms,0.0
+ 96.5600ms,3.3V 96.5639ms,3.3
+ 96.5640ms,0.0V 96.5799ms,0.0
+ 96.5800ms,3.3V 96.5839ms,3.3
+ 96.5840ms,0.0V 96.5999ms,0.0
+ 96.6000ms,3.3V 96.6039ms,3.3
+ 96.6040ms,0.0V 96.6199ms,0.0
+ 96.6200ms,3.3V 96.6239ms,3.3
+ 96.6240ms,0.0V 96.6399ms,0.0
+ 96.6400ms,3.3V 96.6439ms,3.3
+ 96.6440ms,0.0V 96.6599ms,0.0
+ 96.6600ms,3.3V 96.6639ms,3.3
+ 96.6640ms,0.0V 96.6799ms,0.0
+ 96.6800ms,3.3V 96.6839ms,3.3
+ 96.6840ms,0.0V 96.6999ms,0.0
+ 96.7000ms,3.3V 96.7039ms,3.3
+ 96.7040ms,0.0V 96.7199ms,0.0
+ 96.7200ms,3.3V 96.7239ms,3.3
+ 96.7240ms,0.0V 96.7399ms,0.0
+ 96.7400ms,3.3V 96.7439ms,3.3
+ 96.7440ms,0.0V 96.7599ms,0.0
+ 96.7600ms,3.3V 96.7639ms,3.3
+ 96.7640ms,0.0V 96.7799ms,0.0
+ 96.7800ms,3.3V 96.7839ms,3.3
+ 96.7840ms,0.0V 96.7999ms,0.0
+ 96.8000ms,3.3V 96.8039ms,3.3
+ 96.8040ms,0.0V 96.8199ms,0.0
+ 96.8200ms,3.3V 96.8239ms,3.3
+ 96.8240ms,0.0V 96.8399ms,0.0
+ 96.8400ms,3.3V 96.8439ms,3.3
+ 96.8440ms,0.0V 96.8599ms,0.0
+ 96.8600ms,3.3V 96.8639ms,3.3
+ 96.8640ms,0.0V 96.8799ms,0.0
+ 96.8800ms,3.3V 96.8839ms,3.3
+ 96.8840ms,0.0V 96.8999ms,0.0
+ 96.9000ms,3.3V 96.9039ms,3.3
+ 96.9040ms,0.0V 96.9199ms,0.0
+ 96.9200ms,3.3V 96.9239ms,3.3
+ 96.9240ms,0.0V 96.9399ms,0.0
+ 96.9400ms,3.3V 96.9439ms,3.3
+ 96.9440ms,0.0V 96.9599ms,0.0
+ 96.9600ms,3.3V 96.9639ms,3.3
+ 96.9640ms,0.0V 96.9799ms,0.0
+ 96.9800ms,3.3V 96.9839ms,3.3
+ 96.9840ms,0.0V 96.9999ms,0.0
+ 97.0000ms,3.3V 97.0039ms,3.3
+ 97.0040ms,0.0V 97.0199ms,0.0
+ 97.0200ms,3.3V 97.0239ms,3.3
+ 97.0240ms,0.0V 97.0399ms,0.0
+ 97.0400ms,3.3V 97.0439ms,3.3
+ 97.0440ms,0.0V 97.0599ms,0.0
+ 97.0600ms,3.3V 97.0639ms,3.3
+ 97.0640ms,0.0V 97.0799ms,0.0
+ 97.0800ms,3.3V 97.0839ms,3.3
+ 97.0840ms,0.0V 97.0999ms,0.0
+ 97.1000ms,3.3V 97.1039ms,3.3
+ 97.1040ms,0.0V 97.1199ms,0.0
+ 97.1200ms,3.3V 97.1239ms,3.3
+ 97.1240ms,0.0V 97.1399ms,0.0
+ 97.1400ms,3.3V 97.1439ms,3.3
+ 97.1440ms,0.0V 97.1599ms,0.0
+ 97.1600ms,3.3V 97.1639ms,3.3
+ 97.1640ms,0.0V 97.1799ms,0.0
+ 97.1800ms,3.3V 97.1839ms,3.3
+ 97.1840ms,0.0V 97.1999ms,0.0
+ 97.2000ms,3.3V 97.2039ms,3.3
+ 97.2040ms,0.0V 97.2199ms,0.0
+ 97.2200ms,3.3V 97.2239ms,3.3
+ 97.2240ms,0.0V 97.2399ms,0.0
+ 97.2400ms,3.3V 97.2439ms,3.3
+ 97.2440ms,0.0V 97.2599ms,0.0
+ 97.2600ms,3.3V 97.2639ms,3.3
+ 97.2640ms,0.0V 97.2799ms,0.0
+ 97.2800ms,3.3V 97.2839ms,3.3
+ 97.2840ms,0.0V 97.2999ms,0.0
+ 97.3000ms,3.3V 97.3039ms,3.3
+ 97.3040ms,0.0V 97.3199ms,0.0
+ 97.3200ms,3.3V 97.3239ms,3.3
+ 97.3240ms,0.0V 97.3399ms,0.0
+ 97.3400ms,3.3V 97.3439ms,3.3
+ 97.3440ms,0.0V 97.3599ms,0.0
+ 97.3600ms,3.3V 97.3639ms,3.3
+ 97.3640ms,0.0V 97.3799ms,0.0
+ 97.3800ms,3.3V 97.3839ms,3.3
+ 97.3840ms,0.0V 97.3999ms,0.0
+ 97.4000ms,3.3V 97.4039ms,3.3
+ 97.4040ms,0.0V 97.4199ms,0.0
+ 97.4200ms,3.3V 97.4239ms,3.3
+ 97.4240ms,0.0V 97.4399ms,0.0
+ 97.4400ms,3.3V 97.4439ms,3.3
+ 97.4440ms,0.0V 97.4599ms,0.0
+ 97.4600ms,3.3V 97.4639ms,3.3
+ 97.4640ms,0.0V 97.4799ms,0.0
+ 97.4800ms,3.3V 97.4839ms,3.3
+ 97.4840ms,0.0V 97.4999ms,0.0
+ 97.5000ms,3.3V 97.5039ms,3.3
+ 97.5040ms,0.0V 97.5199ms,0.0
+ 97.5200ms,3.3V 97.5239ms,3.3
+ 97.5240ms,0.0V 97.5399ms,0.0
+ 97.5400ms,3.3V 97.5439ms,3.3
+ 97.5440ms,0.0V 97.5599ms,0.0
+ 97.5600ms,3.3V 97.5639ms,3.3
+ 97.5640ms,0.0V 97.5799ms,0.0
+ 97.5800ms,3.3V 97.5839ms,3.3
+ 97.5840ms,0.0V 97.5999ms,0.0
+ 97.6000ms,3.3V 97.6039ms,3.3
+ 97.6040ms,0.0V 97.6199ms,0.0
+ 97.6200ms,3.3V 97.6239ms,3.3
+ 97.6240ms,0.0V 97.6399ms,0.0
+ 97.6400ms,3.3V 97.6439ms,3.3
+ 97.6440ms,0.0V 97.6599ms,0.0
+ 97.6600ms,3.3V 97.6639ms,3.3
+ 97.6640ms,0.0V 97.6799ms,0.0
+ 97.6800ms,3.3V 97.6839ms,3.3
+ 97.6840ms,0.0V 97.6999ms,0.0
+ 97.7000ms,3.3V 97.7039ms,3.3
+ 97.7040ms,0.0V 97.7199ms,0.0
+ 97.7200ms,3.3V 97.7239ms,3.3
+ 97.7240ms,0.0V 97.7399ms,0.0
+ 97.7400ms,3.3V 97.7439ms,3.3
+ 97.7440ms,0.0V 97.7599ms,0.0
+ 97.7600ms,3.3V 97.7639ms,3.3
+ 97.7640ms,0.0V 97.7799ms,0.0
+ 97.7800ms,3.3V 97.7839ms,3.3
+ 97.7840ms,0.0V 97.7999ms,0.0
+ 97.8000ms,3.3V 97.8039ms,3.3
+ 97.8040ms,0.0V 97.8199ms,0.0
+ 97.8200ms,3.3V 97.8239ms,3.3
+ 97.8240ms,0.0V 97.8399ms,0.0
+ 97.8400ms,3.3V 97.8439ms,3.3
+ 97.8440ms,0.0V 97.8599ms,0.0
+ 97.8600ms,3.3V 97.8639ms,3.3
+ 97.8640ms,0.0V 97.8799ms,0.0
+ 97.8800ms,3.3V 97.8839ms,3.3
+ 97.8840ms,0.0V 97.8999ms,0.0
+ 97.9000ms,3.3V 97.9039ms,3.3
+ 97.9040ms,0.0V 97.9199ms,0.0
+ 97.9200ms,3.3V 97.9239ms,3.3
+ 97.9240ms,0.0V 97.9399ms,0.0
+ 97.9400ms,3.3V 97.9439ms,3.3
+ 97.9440ms,0.0V 97.9599ms,0.0
+ 97.9600ms,3.3V 97.9639ms,3.3
+ 97.9640ms,0.0V 97.9799ms,0.0
+ 97.9800ms,3.3V 97.9839ms,3.3
+ 97.9840ms,0.0V 97.9999ms,0.0
+ 98.0000ms,3.3V 98.0039ms,3.3
+ 98.0040ms,0.0V 98.0199ms,0.0
+ 98.0200ms,3.3V 98.0239ms,3.3
+ 98.0240ms,0.0V 98.0399ms,0.0
+ 98.0400ms,3.3V 98.0439ms,3.3
+ 98.0440ms,0.0V 98.0599ms,0.0
+ 98.0600ms,3.3V 98.0639ms,3.3
+ 98.0640ms,0.0V 98.0799ms,0.0
+ 98.0800ms,3.3V 98.0839ms,3.3
+ 98.0840ms,0.0V 98.0999ms,0.0
+ 98.1000ms,3.3V 98.1039ms,3.3
+ 98.1040ms,0.0V 98.1199ms,0.0
+ 98.1200ms,3.3V 98.1239ms,3.3
+ 98.1240ms,0.0V 98.1399ms,0.0
+ 98.1400ms,3.3V 98.1439ms,3.3
+ 98.1440ms,0.0V 98.1599ms,0.0
+ 98.1600ms,3.3V 98.1639ms,3.3
+ 98.1640ms,0.0V 98.1799ms,0.0
+ 98.1800ms,3.3V 98.1839ms,3.3
+ 98.1840ms,0.0V 98.1999ms,0.0
+ 98.2000ms,3.3V 98.2039ms,3.3
+ 98.2040ms,0.0V 98.2199ms,0.0
+ 98.2200ms,3.3V 98.2239ms,3.3
+ 98.2240ms,0.0V 98.2399ms,0.0
+ 98.2400ms,3.3V 98.2439ms,3.3
+ 98.2440ms,0.0V 98.2599ms,0.0
+ 98.2600ms,3.3V 98.2639ms,3.3
+ 98.2640ms,0.0V 98.2799ms,0.0
+ 98.2800ms,3.3V 98.2839ms,3.3
+ 98.2840ms,0.0V 98.2999ms,0.0
+ 98.3000ms,3.3V 98.3039ms,3.3
+ 98.3040ms,0.0V 98.3199ms,0.0
+ 98.3200ms,3.3V 98.3239ms,3.3
+ 98.3240ms,0.0V 98.3399ms,0.0
+ 98.3400ms,3.3V 98.3439ms,3.3
+ 98.3440ms,0.0V 98.3599ms,0.0
+ 98.3600ms,3.3V 98.3639ms,3.3
+ 98.3640ms,0.0V 98.3799ms,0.0
+ 98.3800ms,3.3V 98.3839ms,3.3
+ 98.3840ms,0.0V 98.3999ms,0.0
+ 98.4000ms,3.3V 98.4039ms,3.3
+ 98.4040ms,0.0V 98.4199ms,0.0
+ 98.4200ms,3.3V 98.4239ms,3.3
+ 98.4240ms,0.0V 98.4399ms,0.0
+ 98.4400ms,3.3V 98.4439ms,3.3
+ 98.4440ms,0.0V 98.4599ms,0.0
+ 98.4600ms,3.3V 98.4639ms,3.3
+ 98.4640ms,0.0V 98.4799ms,0.0
+ 98.4800ms,3.3V 98.4839ms,3.3
+ 98.4840ms,0.0V 98.4999ms,0.0
+ 98.5000ms,3.3V 98.5039ms,3.3
+ 98.5040ms,0.0V 98.5199ms,0.0
+ 98.5200ms,3.3V 98.5239ms,3.3
+ 98.5240ms,0.0V 98.5399ms,0.0
+ 98.5400ms,3.3V 98.5439ms,3.3
+ 98.5440ms,0.0V 98.5599ms,0.0
+ 98.5600ms,3.3V 98.5639ms,3.3
+ 98.5640ms,0.0V 98.5799ms,0.0
+ 98.5800ms,3.3V 98.5839ms,3.3
+ 98.5840ms,0.0V 98.5999ms,0.0
+ 98.6000ms,3.3V 98.6039ms,3.3
+ 98.6040ms,0.0V 98.6199ms,0.0
+ 98.6200ms,3.3V 98.6239ms,3.3
+ 98.6240ms,0.0V 98.6399ms,0.0
+ 98.6400ms,3.3V 98.6439ms,3.3
+ 98.6440ms,0.0V 98.6599ms,0.0
+ 98.6600ms,3.3V 98.6639ms,3.3
+ 98.6640ms,0.0V 98.6799ms,0.0
+ 98.6800ms,3.3V 98.6839ms,3.3
+ 98.6840ms,0.0V 98.6999ms,0.0
+ 98.7000ms,3.3V 98.7039ms,3.3
+ 98.7040ms,0.0V 98.7199ms,0.0
+ 98.7200ms,3.3V 98.7239ms,3.3
+ 98.7240ms,0.0V 98.7399ms,0.0
+ 98.7400ms,3.3V 98.7439ms,3.3
+ 98.7440ms,0.0V 98.7599ms,0.0
+ 98.7600ms,3.3V 98.7639ms,3.3
+ 98.7640ms,0.0V 98.7799ms,0.0
+ 98.7800ms,3.3V 98.7839ms,3.3
+ 98.7840ms,0.0V 98.7999ms,0.0
+ 98.8000ms,3.3V 98.8039ms,3.3
+ 98.8040ms,0.0V 98.8199ms,0.0
+ 98.8200ms,3.3V 98.8239ms,3.3
+ 98.8240ms,0.0V 98.8399ms,0.0
+ 98.8400ms,3.3V 98.8439ms,3.3
+ 98.8440ms,0.0V 98.8599ms,0.0
+ 98.8600ms,3.3V 98.8639ms,3.3
+ 98.8640ms,0.0V 98.8799ms,0.0
+ 98.8800ms,3.3V 98.8839ms,3.3
+ 98.8840ms,0.0V 98.8999ms,0.0
+ 98.9000ms,3.3V 98.9039ms,3.3
+ 98.9040ms,0.0V 98.9199ms,0.0
+ 98.9200ms,3.3V 98.9239ms,3.3
+ 98.9240ms,0.0V 98.9399ms,0.0
+ 98.9400ms,3.3V 98.9439ms,3.3
+ 98.9440ms,0.0V 98.9599ms,0.0
+ 98.9600ms,3.3V 98.9639ms,3.3
+ 98.9640ms,0.0V 98.9799ms,0.0
+ 98.9800ms,3.3V 98.9839ms,3.3
+ 98.9840ms,0.0V 98.9999ms,0.0
+ 99.0000ms,3.3V 99.0039ms,3.3
+ 99.0040ms,0.0V 99.0199ms,0.0
+ 99.0200ms,3.3V 99.0239ms,3.3
+ 99.0240ms,0.0V 99.0399ms,0.0
+ 99.0400ms,3.3V 99.0439ms,3.3
+ 99.0440ms,0.0V 99.0599ms,0.0
+ 99.0600ms,3.3V 99.0639ms,3.3
+ 99.0640ms,0.0V 99.0799ms,0.0
+ 99.0800ms,3.3V 99.0839ms,3.3
+ 99.0840ms,0.0V 99.0999ms,0.0
+ 99.1000ms,3.3V 99.1039ms,3.3
+ 99.1040ms,0.0V 99.1199ms,0.0
+ 99.1200ms,3.3V 99.1239ms,3.3
+ 99.1240ms,0.0V 99.1399ms,0.0
+ 99.1400ms,3.3V 99.1439ms,3.3
+ 99.1440ms,0.0V 99.1599ms,0.0
+ 99.1600ms,3.3V 99.1639ms,3.3
+ 99.1640ms,0.0V 99.1799ms,0.0
+ 99.1800ms,3.3V 99.1839ms,3.3
+ 99.1840ms,0.0V 99.1999ms,0.0
+ 99.2000ms,3.3V 99.2039ms,3.3
+ 99.2040ms,0.0V 99.2199ms,0.0
+ 99.2200ms,3.3V 99.2239ms,3.3
+ 99.2240ms,0.0V 99.2399ms,0.0
+ 99.2400ms,3.3V 99.2439ms,3.3
+ 99.2440ms,0.0V 99.2599ms,0.0
+ 99.2600ms,3.3V 99.2639ms,3.3
+ 99.2640ms,0.0V 99.2799ms,0.0
+ 99.2800ms,3.3V 99.2839ms,3.3
+ 99.2840ms,0.0V 99.2999ms,0.0
+ 99.3000ms,3.3V 99.3039ms,3.3
+ 99.3040ms,0.0V 99.3199ms,0.0
+ 99.3200ms,3.3V 99.3239ms,3.3
+ 99.3240ms,0.0V 99.3399ms,0.0
+ 99.3400ms,3.3V 99.3439ms,3.3
+ 99.3440ms,0.0V 99.3599ms,0.0
+ 99.3600ms,3.3V 99.3639ms,3.3
+ 99.3640ms,0.0V 99.3799ms,0.0
+ 99.3800ms,3.3V 99.3839ms,3.3
+ 99.3840ms,0.0V 99.3999ms,0.0
+ 99.4000ms,3.3V 99.4039ms,3.3
+ 99.4040ms,0.0V 99.4199ms,0.0
+ 99.4200ms,3.3V 99.4239ms,3.3
+ 99.4240ms,0.0V 99.4399ms,0.0
+ 99.4400ms,3.3V 99.4439ms,3.3
+ 99.4440ms,0.0V 99.4599ms,0.0
+ 99.4600ms,3.3V 99.4639ms,3.3
+ 99.4640ms,0.0V 99.4799ms,0.0
+ 99.4800ms,3.3V 99.4839ms,3.3
+ 99.4840ms,0.0V 99.4999ms,0.0
+ 99.5000ms,3.3V 99.5039ms,3.3
+ 99.5040ms,0.0V 99.5199ms,0.0
+ 99.5200ms,3.3V 99.5239ms,3.3
+ 99.5240ms,0.0V 99.5399ms,0.0
+ 99.5400ms,3.3V 99.5439ms,3.3
+ 99.5440ms,0.0V 99.5599ms,0.0
+ 99.5600ms,3.3V 99.5639ms,3.3
+ 99.5640ms,0.0V 99.5799ms,0.0
+ 99.5800ms,3.3V 99.5839ms,3.3
+ 99.5840ms,0.0V 99.5999ms,0.0
+ 99.6000ms,3.3V 99.6039ms,3.3
+ 99.6040ms,0.0V 99.6199ms,0.0
+ 99.6200ms,3.3V 99.6239ms,3.3
+ 99.6240ms,0.0V 99.6399ms,0.0
+ 99.6400ms,3.3V 99.6439ms,3.3
+ 99.6440ms,0.0V 99.6599ms,0.0
+ 99.6600ms,3.3V 99.6639ms,3.3
+ 99.6640ms,0.0V 99.6799ms,0.0
+ 99.6800ms,3.3V 99.6839ms,3.3
+ 99.6840ms,0.0V 99.6999ms,0.0
+ 99.7000ms,3.3V 99.7039ms,3.3
+ 99.7040ms,0.0V 99.7199ms,0.0
+ 99.7200ms,3.3V 99.7239ms,3.3
+ 99.7240ms,0.0V 99.7399ms,0.0
+ 99.7400ms,3.3V 99.7439ms,3.3
+ 99.7440ms,0.0V 99.7599ms,0.0
+ 99.7600ms,3.3V 99.7639ms,3.3
+ 99.7640ms,0.0V 99.7799ms,0.0
+ 99.7800ms,3.3V 99.7839ms,3.3
+ 99.7840ms,0.0V 99.7999ms,0.0
+ 99.8000ms,3.3V 99.8039ms,3.3
+ 99.8040ms,0.0V 99.8199ms,0.0
+ 99.8200ms,3.3V 99.8239ms,3.3
+ 99.8240ms,0.0V 99.8399ms,0.0
+ 99.8400ms,3.3V 99.8439ms,3.3
+ 99.8440ms,0.0V 99.8599ms,0.0
+ 99.8600ms,3.3V 99.8639ms,3.3
+ 99.8640ms,0.0V 99.8799ms,0.0
+ 99.8800ms,3.3V 99.8839ms,3.3
+ 99.8840ms,0.0V 99.8999ms,0.0
+ 99.9000ms,3.3V 99.9039ms,3.3
+ 99.9040ms,0.0V 99.9199ms,0.0
+ 99.9200ms,3.3V 99.9239ms,3.3
+ 99.9240ms,0.0V 99.9399ms,0.0
+ 99.9400ms,3.3V 99.9439ms,3.3
+ 99.9440ms,0.0V 99.9599ms,0.0
+ 99.9600ms,3.3V 99.9639ms,3.3
+ 99.9640ms,0.0V 99.9799ms,0.0
+ 99.9800ms,3.3V 99.9839ms,3.3
+ 99.9840ms,0.0V 99.9999ms,0.0
+ 100.0000ms,3.3V 100.0039ms,3.3
+ 100.0040ms,0.0V 100.0199ms,0.0
+ 100.0200ms,3.3V 100.0239ms,3.3
+ 100.0240ms,0.0V 100.0399ms,0.0
+ 100.0400ms,3.3V 100.0439ms,3.3
+ 100.0440ms,0.0V 100.0599ms,0.0
+ 100.0600ms,3.3V 100.0639ms,3.3
+ 100.0640ms,0.0V 100.0799ms,0.0
+ 100.0800ms,3.3V 100.0839ms,3.3
+ 100.0840ms,0.0V 100.0999ms,0.0
+ 100.1000ms,3.3V 100.1039ms,3.3
+ 100.1040ms,0.0V 100.1199ms,0.0
+ 100.1200ms,3.3V 100.1239ms,3.3
+ 100.1240ms,0.0V 100.1399ms,0.0
+ 100.1400ms,3.3V 100.1439ms,3.3
+ 100.1440ms,0.0V 100.1599ms,0.0
+ 100.1600ms,3.3V 100.1639ms,3.3
+ 100.1640ms,0.0V 100.1799ms,0.0
+ 100.1800ms,3.3V 100.1839ms,3.3
+ 100.1840ms,0.0V 100.1999ms,0.0
+ 100.2000ms,3.3V 100.2039ms,3.3
+ 100.2040ms,0.0V 100.2199ms,0.0
+ 100.2200ms,3.3V 100.2239ms,3.3
+ 100.2240ms,0.0V 100.2399ms,0.0
+ 100.2400ms,3.3V 100.2439ms,3.3
+ 100.2440ms,0.0V 100.2599ms,0.0
+ 100.2600ms,3.3V 100.2641ms,3.3
+ 100.2642ms,0.0V 100.2799ms,0.0
+ 100.2800ms,3.3V 100.2841ms,3.3
+ 100.2842ms,0.0V 100.2999ms,0.0
+ 100.3000ms,3.3V 100.3041ms,3.3
+ 100.3042ms,0.0V 100.3199ms,0.0
+ 100.3200ms,3.3V 100.3241ms,3.3
+ 100.3242ms,0.0V 100.3399ms,0.0
+ 100.3400ms,3.3V 100.3441ms,3.3
+ 100.3442ms,0.0V 100.3599ms,0.0
+ 100.3600ms,3.3V 100.3641ms,3.3
+ 100.3642ms,0.0V 100.3799ms,0.0
+ 100.3800ms,3.3V 100.3841ms,3.3
+ 100.3842ms,0.0V 100.3999ms,0.0
+ 100.4000ms,3.3V 100.4041ms,3.3
+ 100.4042ms,0.0V 100.4199ms,0.0
+ 100.4200ms,3.3V 100.4241ms,3.3
+ 100.4242ms,0.0V 100.4399ms,0.0
+ 100.4400ms,3.3V 100.4441ms,3.3
+ 100.4442ms,0.0V 100.4599ms,0.0
+ 100.4600ms,3.3V 100.4641ms,3.3
+ 100.4642ms,0.0V 100.4799ms,0.0
+ 100.4800ms,3.3V 100.4841ms,3.3
+ 100.4842ms,0.0V 100.4999ms,0.0
+ 100.5000ms,3.3V 100.5041ms,3.3
+ 100.5042ms,0.0V 100.5199ms,0.0
+ 100.5200ms,3.3V 100.5241ms,3.3
+ 100.5242ms,0.0V 100.5399ms,0.0
+ 100.5400ms,3.3V 100.5441ms,3.3
+ 100.5442ms,0.0V 100.5599ms,0.0
+ 100.5600ms,3.3V 100.5641ms,3.3
+ 100.5642ms,0.0V 100.5799ms,0.0
+ 100.5800ms,3.3V 100.5841ms,3.3
+ 100.5842ms,0.0V 100.5999ms,0.0
+ 100.6000ms,3.3V 100.6041ms,3.3
+ 100.6042ms,0.0V 100.6199ms,0.0
+ 100.6200ms,3.3V 100.6241ms,3.3
+ 100.6242ms,0.0V 100.6399ms,0.0
+ 100.6400ms,3.3V 100.6441ms,3.3
+ 100.6442ms,0.0V 100.6599ms,0.0
+ 100.6600ms,3.3V 100.6641ms,3.3
+ 100.6642ms,0.0V 100.6799ms,0.0
+ 100.6800ms,3.3V 100.6841ms,3.3
+ 100.6842ms,0.0V 100.6999ms,0.0
+ 100.7000ms,3.3V 100.7041ms,3.3
+ 100.7042ms,0.0V 100.7199ms,0.0
+ 100.7200ms,3.3V 100.7241ms,3.3
+ 100.7242ms,0.0V 100.7399ms,0.0
+ 100.7400ms,3.3V 100.7441ms,3.3
+ 100.7442ms,0.0V 100.7599ms,0.0
+ 100.7600ms,3.3V 100.7641ms,3.3
+ 100.7642ms,0.0V 100.7799ms,0.0
+ 100.7800ms,3.3V 100.7841ms,3.3
+ 100.7842ms,0.0V 100.7999ms,0.0
+ 100.8000ms,3.3V 100.8041ms,3.3
+ 100.8042ms,0.0V 100.8199ms,0.0
+ 100.8200ms,3.3V 100.8241ms,3.3
+ 100.8242ms,0.0V 100.8399ms,0.0
+ 100.8400ms,3.3V 100.8441ms,3.3
+ 100.8442ms,0.0V 100.8599ms,0.0
+ 100.8600ms,3.3V 100.8641ms,3.3
+ 100.8642ms,0.0V 100.8799ms,0.0
+ 100.8800ms,3.3V 100.8841ms,3.3
+ 100.8842ms,0.0V 100.8999ms,0.0
+ 100.9000ms,3.3V 100.9041ms,3.3
+ 100.9042ms,0.0V 100.9199ms,0.0
+ 100.9200ms,3.3V 100.9241ms,3.3
+ 100.9242ms,0.0V 100.9399ms,0.0
+ 100.9400ms,3.3V 100.9441ms,3.3
+ 100.9442ms,0.0V 100.9599ms,0.0
+ 100.9600ms,3.3V 100.9641ms,3.3
+ 100.9642ms,0.0V 100.9799ms,0.0
+ 100.9800ms,3.3V 100.9841ms,3.3
+ 100.9842ms,0.0V 100.9999ms,0.0
+ 101.0000ms,3.3V 101.0041ms,3.3
+ 101.0042ms,0.0V 101.0199ms,0.0
+ 101.0200ms,3.3V 101.0241ms,3.3
+ 101.0242ms,0.0V 101.0399ms,0.0
+ 101.0400ms,3.3V 101.0441ms,3.3
+ 101.0442ms,0.0V 101.0599ms,0.0
+ 101.0600ms,3.3V 101.0641ms,3.3
+ 101.0642ms,0.0V 101.0799ms,0.0
+ 101.0800ms,3.3V 101.0841ms,3.3
+ 101.0842ms,0.0V 101.0999ms,0.0
+ 101.1000ms,3.3V 101.1041ms,3.3
+ 101.1042ms,0.0V 101.1199ms,0.0
+ 101.1200ms,3.3V 101.1241ms,3.3
+ 101.1242ms,0.0V 101.1399ms,0.0
+ 101.1400ms,3.3V 101.1441ms,3.3
+ 101.1442ms,0.0V 101.1599ms,0.0
+ 101.1600ms,3.3V 101.1641ms,3.3
+ 101.1642ms,0.0V 101.1799ms,0.0
+ 101.1800ms,3.3V 101.1841ms,3.3
+ 101.1842ms,0.0V 101.1999ms,0.0
+ 101.2000ms,3.3V 101.2041ms,3.3
+ 101.2042ms,0.0V 101.2199ms,0.0
+ 101.2200ms,3.3V 101.2241ms,3.3
+ 101.2242ms,0.0V 101.2399ms,0.0
+ 101.2400ms,3.3V 101.2441ms,3.3
+ 101.2442ms,0.0V 101.2599ms,0.0
+ 101.2600ms,3.3V 101.2641ms,3.3
+ 101.2642ms,0.0V 101.2799ms,0.0
+ 101.2800ms,3.3V 101.2841ms,3.3
+ 101.2842ms,0.0V 101.2999ms,0.0
+ 101.3000ms,3.3V 101.3041ms,3.3
+ 101.3042ms,0.0V 101.3199ms,0.0
+ 101.3200ms,3.3V 101.3241ms,3.3
+ 101.3242ms,0.0V 101.3399ms,0.0
+ 101.3400ms,3.3V 101.3441ms,3.3
+ 101.3442ms,0.0V 101.3599ms,0.0
+ 101.3600ms,3.3V 101.3641ms,3.3
+ 101.3642ms,0.0V 101.3799ms,0.0
+ 101.3800ms,3.3V 101.3841ms,3.3
+ 101.3842ms,0.0V 101.3999ms,0.0
+ 101.4000ms,3.3V 101.4041ms,3.3
+ 101.4042ms,0.0V 101.4199ms,0.0
+ 101.4200ms,3.3V 101.4241ms,3.3
+ 101.4242ms,0.0V 101.4399ms,0.0
+ 101.4400ms,3.3V 101.4441ms,3.3
+ 101.4442ms,0.0V 101.4599ms,0.0
+ 101.4600ms,3.3V 101.4641ms,3.3
+ 101.4642ms,0.0V 101.4799ms,0.0
+ 101.4800ms,3.3V 101.4841ms,3.3
+ 101.4842ms,0.0V 101.4999ms,0.0
+ 101.5000ms,3.3V 101.5041ms,3.3
+ 101.5042ms,0.0V 101.5199ms,0.0
+ 101.5200ms,3.3V 101.5241ms,3.3
+ 101.5242ms,0.0V 101.5399ms,0.0
+ 101.5400ms,3.3V 101.5441ms,3.3
+ 101.5442ms,0.0V 101.5599ms,0.0
+ 101.5600ms,3.3V 101.5641ms,3.3
+ 101.5642ms,0.0V 101.5799ms,0.0
+ 101.5800ms,3.3V 101.5841ms,3.3
+ 101.5842ms,0.0V 101.5999ms,0.0
+ 101.6000ms,3.3V 101.6041ms,3.3
+ 101.6042ms,0.0V 101.6199ms,0.0
+ 101.6200ms,3.3V 101.6241ms,3.3
+ 101.6242ms,0.0V 101.6399ms,0.0
+ 101.6400ms,3.3V 101.6441ms,3.3
+ 101.6442ms,0.0V 101.6599ms,0.0
+ 101.6600ms,3.3V 101.6641ms,3.3
+ 101.6642ms,0.0V 101.6799ms,0.0
+ 101.6800ms,3.3V 101.6841ms,3.3
+ 101.6842ms,0.0V 101.6999ms,0.0
+ 101.7000ms,3.3V 101.7041ms,3.3
+ 101.7042ms,0.0V 101.7199ms,0.0
+ 101.7200ms,3.3V 101.7241ms,3.3
+ 101.7242ms,0.0V 101.7399ms,0.0
+ 101.7400ms,3.3V 101.7441ms,3.3
+ 101.7442ms,0.0V 101.7599ms,0.0
+ 101.7600ms,3.3V 101.7641ms,3.3
+ 101.7642ms,0.0V 101.7799ms,0.0
+ 101.7800ms,3.3V 101.7841ms,3.3
+ 101.7842ms,0.0V 101.7999ms,0.0
+ 101.8000ms,3.3V 101.8041ms,3.3
+ 101.8042ms,0.0V 101.8199ms,0.0
+ 101.8200ms,3.3V 101.8241ms,3.3
+ 101.8242ms,0.0V 101.8399ms,0.0
+ 101.8400ms,3.3V 101.8441ms,3.3
+ 101.8442ms,0.0V 101.8599ms,0.0
+ 101.8600ms,3.3V 101.8641ms,3.3
+ 101.8642ms,0.0V 101.8799ms,0.0
+ 101.8800ms,3.3V 101.8841ms,3.3
+ 101.8842ms,0.0V 101.8999ms,0.0
+ 101.9000ms,3.3V 101.9041ms,3.3
+ 101.9042ms,0.0V 101.9199ms,0.0
+ 101.9200ms,3.3V 101.9241ms,3.3
+ 101.9242ms,0.0V 101.9399ms,0.0
+ 101.9400ms,3.3V 101.9441ms,3.3
+ 101.9442ms,0.0V 101.9599ms,0.0
+ 101.9600ms,3.3V 101.9641ms,3.3
+ 101.9642ms,0.0V 101.9799ms,0.0
+ 101.9800ms,3.3V 101.9841ms,3.3
+ 101.9842ms,0.0V 101.9999ms,0.0
+ 102.0000ms,3.3V 102.0041ms,3.3
+ 102.0042ms,0.0V 102.0199ms,0.0
+ 102.0200ms,3.3V 102.0241ms,3.3
+ 102.0242ms,0.0V 102.0399ms,0.0
+ 102.0400ms,3.3V 102.0441ms,3.3
+ 102.0442ms,0.0V 102.0599ms,0.0
+ 102.0600ms,3.3V 102.0641ms,3.3
+ 102.0642ms,0.0V 102.0799ms,0.0
+ 102.0800ms,3.3V 102.0841ms,3.3
+ 102.0842ms,0.0V 102.0999ms,0.0
+ 102.1000ms,3.3V 102.1041ms,3.3
+ 102.1042ms,0.0V 102.1199ms,0.0
+ 102.1200ms,3.3V 102.1241ms,3.3
+ 102.1242ms,0.0V 102.1399ms,0.0
+ 102.1400ms,3.3V 102.1441ms,3.3
+ 102.1442ms,0.0V 102.1599ms,0.0
+ 102.1600ms,3.3V 102.1641ms,3.3
+ 102.1642ms,0.0V 102.1799ms,0.0
+ 102.1800ms,3.3V 102.1841ms,3.3
+ 102.1842ms,0.0V 102.1999ms,0.0
+ 102.2000ms,3.3V 102.2041ms,3.3
+ 102.2042ms,0.0V 102.2199ms,0.0
+ 102.2200ms,3.3V 102.2241ms,3.3
+ 102.2242ms,0.0V 102.2399ms,0.0
+ 102.2400ms,3.3V 102.2441ms,3.3
+ 102.2442ms,0.0V 102.2599ms,0.0
+ 102.2600ms,3.3V 102.2641ms,3.3
+ 102.2642ms,0.0V 102.2799ms,0.0
+ 102.2800ms,3.3V 102.2841ms,3.3
+ 102.2842ms,0.0V 102.2999ms,0.0
+ 102.3000ms,3.3V 102.3041ms,3.3
+ 102.3042ms,0.0V 102.3199ms,0.0
+ 102.3200ms,3.3V 102.3241ms,3.3
+ 102.3242ms,0.0V 102.3399ms,0.0
+ 102.3400ms,3.3V 102.3441ms,3.3
+ 102.3442ms,0.0V 102.3599ms,0.0
+ 102.3600ms,3.3V 102.3641ms,3.3
+ 102.3642ms,0.0V 102.3799ms,0.0
+ 102.3800ms,3.3V 102.3841ms,3.3
+ 102.3842ms,0.0V 102.3999ms,0.0
+ 102.4000ms,3.3V 102.4041ms,3.3
+ 102.4042ms,0.0V 102.4199ms,0.0
+ 102.4200ms,3.3V 102.4241ms,3.3
+ 102.4242ms,0.0V 102.4399ms,0.0
+ 102.4400ms,3.3V 102.4441ms,3.3
+ 102.4442ms,0.0V 102.4599ms,0.0
+ 102.4600ms,3.3V 102.4641ms,3.3
+ 102.4642ms,0.0V 102.4799ms,0.0
+ 102.4800ms,3.3V 102.4841ms,3.3
+ 102.4842ms,0.0V 102.4999ms,0.0
+ 102.5000ms,3.3V 102.5041ms,3.3
+ 102.5042ms,0.0V 102.5199ms,0.0
+ 102.5200ms,3.3V 102.5241ms,3.3
+ 102.5242ms,0.0V 102.5399ms,0.0
+ 102.5400ms,3.3V 102.5441ms,3.3
+ 102.5442ms,0.0V 102.5599ms,0.0
+ 102.5600ms,3.3V 102.5641ms,3.3
+ 102.5642ms,0.0V 102.5799ms,0.0
+ 102.5800ms,3.3V 102.5841ms,3.3
+ 102.5842ms,0.0V 102.5999ms,0.0
+ 102.6000ms,3.3V 102.6041ms,3.3
+ 102.6042ms,0.0V 102.6199ms,0.0
+ 102.6200ms,3.3V 102.6241ms,3.3
+ 102.6242ms,0.0V 102.6399ms,0.0
+ 102.6400ms,3.3V 102.6441ms,3.3
+ 102.6442ms,0.0V 102.6599ms,0.0
+ 102.6600ms,3.3V 102.6641ms,3.3
+ 102.6642ms,0.0V 102.6799ms,0.0
+ 102.6800ms,3.3V 102.6841ms,3.3
+ 102.6842ms,0.0V 102.6999ms,0.0
+ 102.7000ms,3.3V 102.7041ms,3.3
+ 102.7042ms,0.0V 102.7199ms,0.0
+ 102.7200ms,3.3V 102.7241ms,3.3
+ 102.7242ms,0.0V 102.7399ms,0.0
+ 102.7400ms,3.3V 102.7441ms,3.3
+ 102.7442ms,0.0V 102.7599ms,0.0
+ 102.7600ms,3.3V 102.7641ms,3.3
+ 102.7642ms,0.0V 102.7799ms,0.0
+ 102.7800ms,3.3V 102.7841ms,3.3
+ 102.7842ms,0.0V 102.7999ms,0.0
+ 102.8000ms,3.3V 102.8041ms,3.3
+ 102.8042ms,0.0V 102.8199ms,0.0
+ 102.8200ms,3.3V 102.8241ms,3.3
+ 102.8242ms,0.0V 102.8399ms,0.0
+ 102.8400ms,3.3V 102.8441ms,3.3
+ 102.8442ms,0.0V 102.8599ms,0.0
+ 102.8600ms,3.3V 102.8641ms,3.3
+ 102.8642ms,0.0V 102.8799ms,0.0
+ 102.8800ms,3.3V 102.8841ms,3.3
+ 102.8842ms,0.0V 102.8999ms,0.0
+ 102.9000ms,3.3V 102.9041ms,3.3
+ 102.9042ms,0.0V 102.9199ms,0.0
+ 102.9200ms,3.3V 102.9241ms,3.3
+ 102.9242ms,0.0V 102.9399ms,0.0
+ 102.9400ms,3.3V 102.9441ms,3.3
+ 102.9442ms,0.0V 102.9599ms,0.0
+ 102.9600ms,3.3V 102.9641ms,3.3
+ 102.9642ms,0.0V 102.9799ms,0.0
+ 102.9800ms,3.3V 102.9841ms,3.3
+ 102.9842ms,0.0V 102.9999ms,0.0
+ 103.0000ms,3.3V 103.0041ms,3.3
+ 103.0042ms,0.0V 103.0199ms,0.0
+ 103.0200ms,3.3V 103.0241ms,3.3
+ 103.0242ms,0.0V 103.0399ms,0.0
+ 103.0400ms,3.3V 103.0441ms,3.3
+ 103.0442ms,0.0V 103.0599ms,0.0
+ 103.0600ms,3.3V 103.0641ms,3.3
+ 103.0642ms,0.0V 103.0799ms,0.0
+ 103.0800ms,3.3V 103.0841ms,3.3
+ 103.0842ms,0.0V 103.0999ms,0.0
+ 103.1000ms,3.3V 103.1041ms,3.3
+ 103.1042ms,0.0V 103.1199ms,0.0
+ 103.1200ms,3.3V 103.1241ms,3.3
+ 103.1242ms,0.0V 103.1399ms,0.0
+ 103.1400ms,3.3V 103.1441ms,3.3
+ 103.1442ms,0.0V 103.1599ms,0.0
+ 103.1600ms,3.3V 103.1641ms,3.3
+ 103.1642ms,0.0V 103.1799ms,0.0
+ 103.1800ms,3.3V 103.1841ms,3.3
+ 103.1842ms,0.0V 103.1999ms,0.0
+ 103.2000ms,3.3V 103.2041ms,3.3
+ 103.2042ms,0.0V 103.2199ms,0.0
+ 103.2200ms,3.3V 103.2241ms,3.3
+ 103.2242ms,0.0V 103.2399ms,0.0
+ 103.2400ms,3.3V 103.2441ms,3.3
+ 103.2442ms,0.0V 103.2599ms,0.0
+ 103.2600ms,3.3V 103.2641ms,3.3
+ 103.2642ms,0.0V 103.2799ms,0.0
+ 103.2800ms,3.3V 103.2841ms,3.3
+ 103.2842ms,0.0V 103.2999ms,0.0
+ 103.3000ms,3.3V 103.3041ms,3.3
+ 103.3042ms,0.0V 103.3199ms,0.0
+ 103.3200ms,3.3V 103.3241ms,3.3
+ 103.3242ms,0.0V 103.3399ms,0.0
+ 103.3400ms,3.3V 103.3441ms,3.3
+ 103.3442ms,0.0V 103.3599ms,0.0
+ 103.3600ms,3.3V 103.3641ms,3.3
+ 103.3642ms,0.0V 103.3799ms,0.0
+ 103.3800ms,3.3V 103.3841ms,3.3
+ 103.3842ms,0.0V 103.3999ms,0.0
+ 103.4000ms,3.3V 103.4041ms,3.3
+ 103.4042ms,0.0V 103.4199ms,0.0
+ 103.4200ms,3.3V 103.4241ms,3.3
+ 103.4242ms,0.0V 103.4399ms,0.0
+ 103.4400ms,3.3V 103.4441ms,3.3
+ 103.4442ms,0.0V 103.4599ms,0.0
+ 103.4600ms,3.3V 103.4641ms,3.3
+ 103.4642ms,0.0V 103.4799ms,0.0
+ 103.4800ms,3.3V 103.4841ms,3.3
+ 103.4842ms,0.0V 103.4999ms,0.0
+ 103.5000ms,3.3V 103.5041ms,3.3
+ 103.5042ms,0.0V 103.5199ms,0.0
+ 103.5200ms,3.3V 103.5241ms,3.3
+ 103.5242ms,0.0V 103.5399ms,0.0
+ 103.5400ms,3.3V 103.5441ms,3.3
+ 103.5442ms,0.0V 103.5599ms,0.0
+ 103.5600ms,3.3V 103.5641ms,3.3
+ 103.5642ms,0.0V 103.5799ms,0.0
+ 103.5800ms,3.3V 103.5841ms,3.3
+ 103.5842ms,0.0V 103.5999ms,0.0
+ 103.6000ms,3.3V 103.6041ms,3.3
+ 103.6042ms,0.0V 103.6199ms,0.0
+ 103.6200ms,3.3V 103.6241ms,3.3
+ 103.6242ms,0.0V 103.6399ms,0.0
+ 103.6400ms,3.3V 103.6441ms,3.3
+ 103.6442ms,0.0V 103.6599ms,0.0
+ 103.6600ms,3.3V 103.6641ms,3.3
+ 103.6642ms,0.0V 103.6799ms,0.0
+ 103.6800ms,3.3V 103.6841ms,3.3
+ 103.6842ms,0.0V 103.6999ms,0.0
+ 103.7000ms,3.3V 103.7041ms,3.3
+ 103.7042ms,0.0V 103.7199ms,0.0
+ 103.7200ms,3.3V 103.7241ms,3.3
+ 103.7242ms,0.0V 103.7399ms,0.0
+ 103.7400ms,3.3V 103.7441ms,3.3
+ 103.7442ms,0.0V 103.7599ms,0.0
+ 103.7600ms,3.3V 103.7641ms,3.3
+ 103.7642ms,0.0V 103.7799ms,0.0
+ 103.7800ms,3.3V 103.7841ms,3.3
+ 103.7842ms,0.0V 103.7999ms,0.0
+ 103.8000ms,3.3V 103.8041ms,3.3
+ 103.8042ms,0.0V 103.8199ms,0.0
+ 103.8200ms,3.3V 103.8241ms,3.3
+ 103.8242ms,0.0V 103.8399ms,0.0
+ 103.8400ms,3.3V 103.8441ms,3.3
+ 103.8442ms,0.0V 103.8599ms,0.0
+ 103.8600ms,3.3V 103.8641ms,3.3
+ 103.8642ms,0.0V 103.8799ms,0.0
+ 103.8800ms,3.3V 103.8841ms,3.3
+ 103.8842ms,0.0V 103.8999ms,0.0
+ 103.9000ms,3.3V 103.9041ms,3.3
+ 103.9042ms,0.0V 103.9199ms,0.0
+ 103.9200ms,3.3V 103.9241ms,3.3
+ 103.9242ms,0.0V 103.9399ms,0.0
+ 103.9400ms,3.3V 103.9441ms,3.3
+ 103.9442ms,0.0V 103.9599ms,0.0
+ 103.9600ms,3.3V 103.9641ms,3.3
+ 103.9642ms,0.0V 103.9799ms,0.0
+ 103.9800ms,3.3V 103.9841ms,3.3
+ 103.9842ms,0.0V 103.9999ms,0.0
+ 104.0000ms,3.3V 104.0041ms,3.3
+ 104.0042ms,0.0V 104.0199ms,0.0
+ 104.0200ms,3.3V 104.0241ms,3.3
+ 104.0242ms,0.0V 104.0399ms,0.0
+ 104.0400ms,3.3V 104.0441ms,3.3
+ 104.0442ms,0.0V 104.0599ms,0.0
+ 104.0600ms,3.3V 104.0641ms,3.3
+ 104.0642ms,0.0V 104.0799ms,0.0
+ 104.0800ms,3.3V 104.0841ms,3.3
+ 104.0842ms,0.0V 104.0999ms,0.0
+ 104.1000ms,3.3V 104.1041ms,3.3
+ 104.1042ms,0.0V 104.1199ms,0.0
+ 104.1200ms,3.3V 104.1241ms,3.3
+ 104.1242ms,0.0V 104.1399ms,0.0
+ 104.1400ms,3.3V 104.1441ms,3.3
+ 104.1442ms,0.0V 104.1599ms,0.0
+ 104.1600ms,3.3V 104.1641ms,3.3
+ 104.1642ms,0.0V 104.1799ms,0.0
+ 104.1800ms,3.3V 104.1841ms,3.3
+ 104.1842ms,0.0V 104.1999ms,0.0
+ 104.2000ms,3.3V 104.2041ms,3.3
+ 104.2042ms,0.0V 104.2199ms,0.0
+ 104.2200ms,3.3V 104.2241ms,3.3
+ 104.2242ms,0.0V 104.2399ms,0.0
+ 104.2400ms,3.3V 104.2441ms,3.3
+ 104.2442ms,0.0V 104.2599ms,0.0
+ 104.2600ms,3.3V 104.2641ms,3.3
+ 104.2642ms,0.0V 104.2799ms,0.0
+ 104.2800ms,3.3V 104.2841ms,3.3
+ 104.2842ms,0.0V 104.2999ms,0.0
+ 104.3000ms,3.3V 104.3041ms,3.3
+ 104.3042ms,0.0V 104.3199ms,0.0
+ 104.3200ms,3.3V 104.3241ms,3.3
+ 104.3242ms,0.0V 104.3399ms,0.0
+ 104.3400ms,3.3V 104.3441ms,3.3
+ 104.3442ms,0.0V 104.3599ms,0.0
+ 104.3600ms,3.3V 104.3641ms,3.3
+ 104.3642ms,0.0V 104.3799ms,0.0
+ 104.3800ms,3.3V 104.3841ms,3.3
+ 104.3842ms,0.0V 104.3999ms,0.0
+ 104.4000ms,3.3V 104.4041ms,3.3
+ 104.4042ms,0.0V 104.4199ms,0.0
+ 104.4200ms,3.3V 104.4241ms,3.3
+ 104.4242ms,0.0V 104.4399ms,0.0
+ 104.4400ms,3.3V 104.4441ms,3.3
+ 104.4442ms,0.0V 104.4599ms,0.0
+ 104.4600ms,3.3V 104.4641ms,3.3
+ 104.4642ms,0.0V 104.4799ms,0.0
+ 104.4800ms,3.3V 104.4841ms,3.3
+ 104.4842ms,0.0V 104.4999ms,0.0
+ 104.5000ms,3.3V 104.5041ms,3.3
+ 104.5042ms,0.0V 104.5199ms,0.0
+ 104.5200ms,3.3V 104.5241ms,3.3
+ 104.5242ms,0.0V 104.5399ms,0.0
+ 104.5400ms,3.3V 104.5441ms,3.3
+ 104.5442ms,0.0V 104.5599ms,0.0
+ 104.5600ms,3.3V 104.5641ms,3.3
+ 104.5642ms,0.0V 104.5799ms,0.0
+ 104.5800ms,3.3V 104.5841ms,3.3
+ 104.5842ms,0.0V 104.5999ms,0.0
+ 104.6000ms,3.3V 104.6041ms,3.3
+ 104.6042ms,0.0V 104.6199ms,0.0
+ 104.6200ms,3.3V 104.6241ms,3.3
+ 104.6242ms,0.0V 104.6399ms,0.0
+ 104.6400ms,3.3V 104.6441ms,3.3
+ 104.6442ms,0.0V 104.6599ms,0.0
+ 104.6600ms,3.3V 104.6641ms,3.3
+ 104.6642ms,0.0V 104.6799ms,0.0
+ 104.6800ms,3.3V 104.6841ms,3.3
+ 104.6842ms,0.0V 104.6999ms,0.0
+ 104.7000ms,3.3V 104.7041ms,3.3
+ 104.7042ms,0.0V 104.7199ms,0.0
+ 104.7200ms,3.3V 104.7241ms,3.3
+ 104.7242ms,0.0V 104.7399ms,0.0
+ 104.7400ms,3.3V 104.7441ms,3.3
+ 104.7442ms,0.0V 104.7599ms,0.0
+ 104.7600ms,3.3V 104.7641ms,3.3
+ 104.7642ms,0.0V 104.7799ms,0.0
+ 104.7800ms,3.3V 104.7841ms,3.3
+ 104.7842ms,0.0V 104.7999ms,0.0
+ 104.8000ms,3.3V 104.8041ms,3.3
+ 104.8042ms,0.0V 104.8199ms,0.0
+ 104.8200ms,3.3V 104.8241ms,3.3
+ 104.8242ms,0.0V 104.8399ms,0.0
+ 104.8400ms,3.3V 104.8441ms,3.3
+ 104.8442ms,0.0V 104.8599ms,0.0
+ 104.8600ms,3.3V 104.8641ms,3.3
+ 104.8642ms,0.0V 104.8799ms,0.0
+ 104.8800ms,3.3V 104.8841ms,3.3
+ 104.8842ms,0.0V 104.8999ms,0.0
+ 104.9000ms,3.3V 104.9041ms,3.3
+ 104.9042ms,0.0V 104.9199ms,0.0
+ 104.9200ms,3.3V 104.9241ms,3.3
+ 104.9242ms,0.0V 104.9399ms,0.0
+ 104.9400ms,3.3V 104.9441ms,3.3
+ 104.9442ms,0.0V 104.9599ms,0.0
+ 104.9600ms,3.3V 104.9641ms,3.3
+ 104.9642ms,0.0V 104.9799ms,0.0
+ 104.9800ms,3.3V 104.9841ms,3.3
+ 104.9842ms,0.0V 104.9999ms,0.0
+ 105.0000ms,3.3V 105.0041ms,3.3
+ 105.0042ms,0.0V 105.0199ms,0.0
+ 105.0200ms,3.3V 105.0241ms,3.3
+ 105.0242ms,0.0V 105.0399ms,0.0
+ 105.0400ms,3.3V 105.0441ms,3.3
+ 105.0442ms,0.0V 105.0599ms,0.0
+ 105.0600ms,3.3V 105.0641ms,3.3
+ 105.0642ms,0.0V 105.0799ms,0.0
+ 105.0800ms,3.3V 105.0841ms,3.3
+ 105.0842ms,0.0V 105.0999ms,0.0
+ 105.1000ms,3.3V 105.1041ms,3.3
+ 105.1042ms,0.0V 105.1199ms,0.0
+ 105.1200ms,3.3V 105.1241ms,3.3
+ 105.1242ms,0.0V 105.1399ms,0.0
+ 105.1400ms,3.3V 105.1441ms,3.3
+ 105.1442ms,0.0V 105.1599ms,0.0
+ 105.1600ms,3.3V 105.1641ms,3.3
+ 105.1642ms,0.0V 105.1799ms,0.0
+ 105.1800ms,3.3V 105.1841ms,3.3
+ 105.1842ms,0.0V 105.1999ms,0.0
+ 105.2000ms,3.3V 105.2041ms,3.3
+ 105.2042ms,0.0V 105.2199ms,0.0
+ 105.2200ms,3.3V 105.2241ms,3.3
+ 105.2242ms,0.0V 105.2399ms,0.0
+ 105.2400ms,3.3V 105.2441ms,3.3
+ 105.2442ms,0.0V 105.2599ms,0.0
+ 105.2600ms,3.3V 105.2641ms,3.3
+ 105.2642ms,0.0V 105.2799ms,0.0
+ 105.2800ms,3.3V 105.2843ms,3.3
+ 105.2844ms,0.0V 105.2999ms,0.0
+ 105.3000ms,3.3V 105.3043ms,3.3
+ 105.3044ms,0.0V 105.3199ms,0.0
+ 105.3200ms,3.3V 105.3243ms,3.3
+ 105.3244ms,0.0V 105.3399ms,0.0
+ 105.3400ms,3.3V 105.3443ms,3.3
+ 105.3444ms,0.0V 105.3599ms,0.0
+ 105.3600ms,3.3V 105.3643ms,3.3
+ 105.3644ms,0.0V 105.3799ms,0.0
+ 105.3800ms,3.3V 105.3843ms,3.3
+ 105.3844ms,0.0V 105.3999ms,0.0
+ 105.4000ms,3.3V 105.4043ms,3.3
+ 105.4044ms,0.0V 105.4199ms,0.0
+ 105.4200ms,3.3V 105.4243ms,3.3
+ 105.4244ms,0.0V 105.4399ms,0.0
+ 105.4400ms,3.3V 105.4443ms,3.3
+ 105.4444ms,0.0V 105.4599ms,0.0
+ 105.4600ms,3.3V 105.4643ms,3.3
+ 105.4644ms,0.0V 105.4799ms,0.0
+ 105.4800ms,3.3V 105.4843ms,3.3
+ 105.4844ms,0.0V 105.4999ms,0.0
+ 105.5000ms,3.3V 105.5043ms,3.3
+ 105.5044ms,0.0V 105.5199ms,0.0
+ 105.5200ms,3.3V 105.5243ms,3.3
+ 105.5244ms,0.0V 105.5399ms,0.0
+ 105.5400ms,3.3V 105.5443ms,3.3
+ 105.5444ms,0.0V 105.5599ms,0.0
+ 105.5600ms,3.3V 105.5643ms,3.3
+ 105.5644ms,0.0V 105.5799ms,0.0
+ 105.5800ms,3.3V 105.5843ms,3.3
+ 105.5844ms,0.0V 105.5999ms,0.0
+ 105.6000ms,3.3V 105.6043ms,3.3
+ 105.6044ms,0.0V 105.6199ms,0.0
+ 105.6200ms,3.3V 105.6243ms,3.3
+ 105.6244ms,0.0V 105.6399ms,0.0
+ 105.6400ms,3.3V 105.6443ms,3.3
+ 105.6444ms,0.0V 105.6599ms,0.0
+ 105.6600ms,3.3V 105.6643ms,3.3
+ 105.6644ms,0.0V 105.6799ms,0.0
+ 105.6800ms,3.3V 105.6843ms,3.3
+ 105.6844ms,0.0V 105.6999ms,0.0
+ 105.7000ms,3.3V 105.7043ms,3.3
+ 105.7044ms,0.0V 105.7199ms,0.0
+ 105.7200ms,3.3V 105.7243ms,3.3
+ 105.7244ms,0.0V 105.7399ms,0.0
+ 105.7400ms,3.3V 105.7443ms,3.3
+ 105.7444ms,0.0V 105.7599ms,0.0
+ 105.7600ms,3.3V 105.7643ms,3.3
+ 105.7644ms,0.0V 105.7799ms,0.0
+ 105.7800ms,3.3V 105.7843ms,3.3
+ 105.7844ms,0.0V 105.7999ms,0.0
+ 105.8000ms,3.3V 105.8043ms,3.3
+ 105.8044ms,0.0V 105.8199ms,0.0
+ 105.8200ms,3.3V 105.8243ms,3.3
+ 105.8244ms,0.0V 105.8399ms,0.0
+ 105.8400ms,3.3V 105.8443ms,3.3
+ 105.8444ms,0.0V 105.8599ms,0.0
+ 105.8600ms,3.3V 105.8643ms,3.3
+ 105.8644ms,0.0V 105.8799ms,0.0
+ 105.8800ms,3.3V 105.8843ms,3.3
+ 105.8844ms,0.0V 105.8999ms,0.0
+ 105.9000ms,3.3V 105.9043ms,3.3
+ 105.9044ms,0.0V 105.9199ms,0.0
+ 105.9200ms,3.3V 105.9243ms,3.3
+ 105.9244ms,0.0V 105.9399ms,0.0
+ 105.9400ms,3.3V 105.9443ms,3.3
+ 105.9444ms,0.0V 105.9599ms,0.0
+ 105.9600ms,3.3V 105.9643ms,3.3
+ 105.9644ms,0.0V 105.9799ms,0.0
+ 105.9800ms,3.3V 105.9843ms,3.3
+ 105.9844ms,0.0V 105.9999ms,0.0
+ 106.0000ms,3.3V 106.0043ms,3.3
+ 106.0044ms,0.0V 106.0199ms,0.0
+ 106.0200ms,3.3V 106.0243ms,3.3
+ 106.0244ms,0.0V 106.0399ms,0.0
+ 106.0400ms,3.3V 106.0443ms,3.3
+ 106.0444ms,0.0V 106.0599ms,0.0
+ 106.0600ms,3.3V 106.0643ms,3.3
+ 106.0644ms,0.0V 106.0799ms,0.0
+ 106.0800ms,3.3V 106.0843ms,3.3
+ 106.0844ms,0.0V 106.0999ms,0.0
+ 106.1000ms,3.3V 106.1043ms,3.3
+ 106.1044ms,0.0V 106.1199ms,0.0
+ 106.1200ms,3.3V 106.1243ms,3.3
+ 106.1244ms,0.0V 106.1399ms,0.0
+ 106.1400ms,3.3V 106.1443ms,3.3
+ 106.1444ms,0.0V 106.1599ms,0.0
+ 106.1600ms,3.3V 106.1643ms,3.3
+ 106.1644ms,0.0V 106.1799ms,0.0
+ 106.1800ms,3.3V 106.1843ms,3.3
+ 106.1844ms,0.0V 106.1999ms,0.0
+ 106.2000ms,3.3V 106.2043ms,3.3
+ 106.2044ms,0.0V 106.2199ms,0.0
+ 106.2200ms,3.3V 106.2243ms,3.3
+ 106.2244ms,0.0V 106.2399ms,0.0
+ 106.2400ms,3.3V 106.2443ms,3.3
+ 106.2444ms,0.0V 106.2599ms,0.0
+ 106.2600ms,3.3V 106.2643ms,3.3
+ 106.2644ms,0.0V 106.2799ms,0.0
+ 106.2800ms,3.3V 106.2843ms,3.3
+ 106.2844ms,0.0V 106.2999ms,0.0
+ 106.3000ms,3.3V 106.3043ms,3.3
+ 106.3044ms,0.0V 106.3199ms,0.0
+ 106.3200ms,3.3V 106.3243ms,3.3
+ 106.3244ms,0.0V 106.3399ms,0.0
+ 106.3400ms,3.3V 106.3443ms,3.3
+ 106.3444ms,0.0V 106.3599ms,0.0
+ 106.3600ms,3.3V 106.3643ms,3.3
+ 106.3644ms,0.0V 106.3799ms,0.0
+ 106.3800ms,3.3V 106.3843ms,3.3
+ 106.3844ms,0.0V 106.3999ms,0.0
+ 106.4000ms,3.3V 106.4043ms,3.3
+ 106.4044ms,0.0V 106.4199ms,0.0
+ 106.4200ms,3.3V 106.4243ms,3.3
+ 106.4244ms,0.0V 106.4399ms,0.0
+ 106.4400ms,3.3V 106.4443ms,3.3
+ 106.4444ms,0.0V 106.4599ms,0.0
+ 106.4600ms,3.3V 106.4643ms,3.3
+ 106.4644ms,0.0V 106.4799ms,0.0
+ 106.4800ms,3.3V 106.4843ms,3.3
+ 106.4844ms,0.0V 106.4999ms,0.0
+ 106.5000ms,3.3V 106.5043ms,3.3
+ 106.5044ms,0.0V 106.5199ms,0.0
+ 106.5200ms,3.3V 106.5243ms,3.3
+ 106.5244ms,0.0V 106.5399ms,0.0
+ 106.5400ms,3.3V 106.5443ms,3.3
+ 106.5444ms,0.0V 106.5599ms,0.0
+ 106.5600ms,3.3V 106.5643ms,3.3
+ 106.5644ms,0.0V 106.5799ms,0.0
+ 106.5800ms,3.3V 106.5843ms,3.3
+ 106.5844ms,0.0V 106.5999ms,0.0
+ 106.6000ms,3.3V 106.6043ms,3.3
+ 106.6044ms,0.0V 106.6199ms,0.0
+ 106.6200ms,3.3V 106.6243ms,3.3
+ 106.6244ms,0.0V 106.6399ms,0.0
+ 106.6400ms,3.3V 106.6443ms,3.3
+ 106.6444ms,0.0V 106.6599ms,0.0
+ 106.6600ms,3.3V 106.6643ms,3.3
+ 106.6644ms,0.0V 106.6799ms,0.0
+ 106.6800ms,3.3V 106.6843ms,3.3
+ 106.6844ms,0.0V 106.6999ms,0.0
+ 106.7000ms,3.3V 106.7043ms,3.3
+ 106.7044ms,0.0V 106.7199ms,0.0
+ 106.7200ms,3.3V 106.7243ms,3.3
+ 106.7244ms,0.0V 106.7399ms,0.0
+ 106.7400ms,3.3V 106.7443ms,3.3
+ 106.7444ms,0.0V 106.7599ms,0.0
+ 106.7600ms,3.3V 106.7643ms,3.3
+ 106.7644ms,0.0V 106.7799ms,0.0
+ 106.7800ms,3.3V 106.7843ms,3.3
+ 106.7844ms,0.0V 106.7999ms,0.0
+ 106.8000ms,3.3V 106.8043ms,3.3
+ 106.8044ms,0.0V 106.8199ms,0.0
+ 106.8200ms,3.3V 106.8243ms,3.3
+ 106.8244ms,0.0V 106.8399ms,0.0
+ 106.8400ms,3.3V 106.8443ms,3.3
+ 106.8444ms,0.0V 106.8599ms,0.0
+ 106.8600ms,3.3V 106.8643ms,3.3
+ 106.8644ms,0.0V 106.8799ms,0.0
+ 106.8800ms,3.3V 106.8843ms,3.3
+ 106.8844ms,0.0V 106.8999ms,0.0
+ 106.9000ms,3.3V 106.9043ms,3.3
+ 106.9044ms,0.0V 106.9199ms,0.0
+ 106.9200ms,3.3V 106.9243ms,3.3
+ 106.9244ms,0.0V 106.9399ms,0.0
+ 106.9400ms,3.3V 106.9443ms,3.3
+ 106.9444ms,0.0V 106.9599ms,0.0
+ 106.9600ms,3.3V 106.9643ms,3.3
+ 106.9644ms,0.0V 106.9799ms,0.0
+ 106.9800ms,3.3V 106.9843ms,3.3
+ 106.9844ms,0.0V 106.9999ms,0.0
+ 107.0000ms,3.3V 107.0043ms,3.3
+ 107.0044ms,0.0V 107.0199ms,0.0
+ 107.0200ms,3.3V 107.0243ms,3.3
+ 107.0244ms,0.0V 107.0399ms,0.0
+ 107.0400ms,3.3V 107.0443ms,3.3
+ 107.0444ms,0.0V 107.0599ms,0.0
+ 107.0600ms,3.3V 107.0643ms,3.3
+ 107.0644ms,0.0V 107.0799ms,0.0
+ 107.0800ms,3.3V 107.0843ms,3.3
+ 107.0844ms,0.0V 107.0999ms,0.0
+ 107.1000ms,3.3V 107.1043ms,3.3
+ 107.1044ms,0.0V 107.1199ms,0.0
+ 107.1200ms,3.3V 107.1243ms,3.3
+ 107.1244ms,0.0V 107.1399ms,0.0
+ 107.1400ms,3.3V 107.1443ms,3.3
+ 107.1444ms,0.0V 107.1599ms,0.0
+ 107.1600ms,3.3V 107.1643ms,3.3
+ 107.1644ms,0.0V 107.1799ms,0.0
+ 107.1800ms,3.3V 107.1843ms,3.3
+ 107.1844ms,0.0V 107.1999ms,0.0
+ 107.2000ms,3.3V 107.2043ms,3.3
+ 107.2044ms,0.0V 107.2199ms,0.0
+ 107.2200ms,3.3V 107.2243ms,3.3
+ 107.2244ms,0.0V 107.2399ms,0.0
+ 107.2400ms,3.3V 107.2443ms,3.3
+ 107.2444ms,0.0V 107.2599ms,0.0
+ 107.2600ms,3.3V 107.2643ms,3.3
+ 107.2644ms,0.0V 107.2799ms,0.0
+ 107.2800ms,3.3V 107.2843ms,3.3
+ 107.2844ms,0.0V 107.2999ms,0.0
+ 107.3000ms,3.3V 107.3043ms,3.3
+ 107.3044ms,0.0V 107.3199ms,0.0
+ 107.3200ms,3.3V 107.3243ms,3.3
+ 107.3244ms,0.0V 107.3399ms,0.0
+ 107.3400ms,3.3V 107.3443ms,3.3
+ 107.3444ms,0.0V 107.3599ms,0.0
+ 107.3600ms,3.3V 107.3643ms,3.3
+ 107.3644ms,0.0V 107.3799ms,0.0
+ 107.3800ms,3.3V 107.3843ms,3.3
+ 107.3844ms,0.0V 107.3999ms,0.0
+ 107.4000ms,3.3V 107.4043ms,3.3
+ 107.4044ms,0.0V 107.4199ms,0.0
+ 107.4200ms,3.3V 107.4243ms,3.3
+ 107.4244ms,0.0V 107.4399ms,0.0
+ 107.4400ms,3.3V 107.4443ms,3.3
+ 107.4444ms,0.0V 107.4599ms,0.0
+ 107.4600ms,3.3V 107.4643ms,3.3
+ 107.4644ms,0.0V 107.4799ms,0.0
+ 107.4800ms,3.3V 107.4843ms,3.3
+ 107.4844ms,0.0V 107.4999ms,0.0
+ 107.5000ms,3.3V 107.5043ms,3.3
+ 107.5044ms,0.0V 107.5199ms,0.0
+ 107.5200ms,3.3V 107.5243ms,3.3
+ 107.5244ms,0.0V 107.5399ms,0.0
+ 107.5400ms,3.3V 107.5443ms,3.3
+ 107.5444ms,0.0V 107.5599ms,0.0
+ 107.5600ms,3.3V 107.5643ms,3.3
+ 107.5644ms,0.0V 107.5799ms,0.0
+ 107.5800ms,3.3V 107.5843ms,3.3
+ 107.5844ms,0.0V 107.5999ms,0.0
+ 107.6000ms,3.3V 107.6043ms,3.3
+ 107.6044ms,0.0V 107.6199ms,0.0
+ 107.6200ms,3.3V 107.6243ms,3.3
+ 107.6244ms,0.0V 107.6399ms,0.0
+ 107.6400ms,3.3V 107.6443ms,3.3
+ 107.6444ms,0.0V 107.6599ms,0.0
+ 107.6600ms,3.3V 107.6643ms,3.3
+ 107.6644ms,0.0V 107.6799ms,0.0
+ 107.6800ms,3.3V 107.6843ms,3.3
+ 107.6844ms,0.0V 107.6999ms,0.0
+ 107.7000ms,3.3V 107.7043ms,3.3
+ 107.7044ms,0.0V 107.7199ms,0.0
+ 107.7200ms,3.3V 107.7243ms,3.3
+ 107.7244ms,0.0V 107.7399ms,0.0
+ 107.7400ms,3.3V 107.7443ms,3.3
+ 107.7444ms,0.0V 107.7599ms,0.0
+ 107.7600ms,3.3V 107.7643ms,3.3
+ 107.7644ms,0.0V 107.7799ms,0.0
+ 107.7800ms,3.3V 107.7843ms,3.3
+ 107.7844ms,0.0V 107.7999ms,0.0
+ 107.8000ms,3.3V 107.8043ms,3.3
+ 107.8044ms,0.0V 107.8199ms,0.0
+ 107.8200ms,3.3V 107.8243ms,3.3
+ 107.8244ms,0.0V 107.8399ms,0.0
+ 107.8400ms,3.3V 107.8443ms,3.3
+ 107.8444ms,0.0V 107.8599ms,0.0
+ 107.8600ms,3.3V 107.8643ms,3.3
+ 107.8644ms,0.0V 107.8799ms,0.0
+ 107.8800ms,3.3V 107.8843ms,3.3
+ 107.8844ms,0.0V 107.8999ms,0.0
+ 107.9000ms,3.3V 107.9043ms,3.3
+ 107.9044ms,0.0V 107.9199ms,0.0
+ 107.9200ms,3.3V 107.9243ms,3.3
+ 107.9244ms,0.0V 107.9399ms,0.0
+ 107.9400ms,3.3V 107.9443ms,3.3
+ 107.9444ms,0.0V 107.9599ms,0.0
+ 107.9600ms,3.3V 107.9643ms,3.3
+ 107.9644ms,0.0V 107.9799ms,0.0
+ 107.9800ms,3.3V 107.9843ms,3.3
+ 107.9844ms,0.0V 107.9999ms,0.0
+ 108.0000ms,3.3V 108.0043ms,3.3
+ 108.0044ms,0.0V 108.0199ms,0.0
+ 108.0200ms,3.3V 108.0243ms,3.3
+ 108.0244ms,0.0V 108.0399ms,0.0
+ 108.0400ms,3.3V 108.0443ms,3.3
+ 108.0444ms,0.0V 108.0599ms,0.0
+ 108.0600ms,3.3V 108.0643ms,3.3
+ 108.0644ms,0.0V 108.0799ms,0.0
+ 108.0800ms,3.3V 108.0843ms,3.3
+ 108.0844ms,0.0V 108.0999ms,0.0
+ 108.1000ms,3.3V 108.1043ms,3.3
+ 108.1044ms,0.0V 108.1199ms,0.0
+ 108.1200ms,3.3V 108.1243ms,3.3
+ 108.1244ms,0.0V 108.1399ms,0.0
+ 108.1400ms,3.3V 108.1443ms,3.3
+ 108.1444ms,0.0V 108.1599ms,0.0
+ 108.1600ms,3.3V 108.1643ms,3.3
+ 108.1644ms,0.0V 108.1799ms,0.0
+ 108.1800ms,3.3V 108.1843ms,3.3
+ 108.1844ms,0.0V 108.1999ms,0.0
+ 108.2000ms,3.3V 108.2043ms,3.3
+ 108.2044ms,0.0V 108.2199ms,0.0
+ 108.2200ms,3.3V 108.2243ms,3.3
+ 108.2244ms,0.0V 108.2399ms,0.0
+ 108.2400ms,3.3V 108.2443ms,3.3
+ 108.2444ms,0.0V 108.2599ms,0.0
+ 108.2600ms,3.3V 108.2643ms,3.3
+ 108.2644ms,0.0V 108.2799ms,0.0
+ 108.2800ms,3.3V 108.2843ms,3.3
+ 108.2844ms,0.0V 108.2999ms,0.0
+ 108.3000ms,3.3V 108.3043ms,3.3
+ 108.3044ms,0.0V 108.3199ms,0.0
+ 108.3200ms,3.3V 108.3243ms,3.3
+ 108.3244ms,0.0V 108.3399ms,0.0
+ 108.3400ms,3.3V 108.3443ms,3.3
+ 108.3444ms,0.0V 108.3599ms,0.0
+ 108.3600ms,3.3V 108.3643ms,3.3
+ 108.3644ms,0.0V 108.3799ms,0.0
+ 108.3800ms,3.3V 108.3843ms,3.3
+ 108.3844ms,0.0V 108.3999ms,0.0
+ 108.4000ms,3.3V 108.4043ms,3.3
+ 108.4044ms,0.0V 108.4199ms,0.0
+ 108.4200ms,3.3V 108.4243ms,3.3
+ 108.4244ms,0.0V 108.4399ms,0.0
+ 108.4400ms,3.3V 108.4443ms,3.3
+ 108.4444ms,0.0V 108.4599ms,0.0
+ 108.4600ms,3.3V 108.4643ms,3.3
+ 108.4644ms,0.0V 108.4799ms,0.0
+ 108.4800ms,3.3V 108.4843ms,3.3
+ 108.4844ms,0.0V 108.4999ms,0.0
+ 108.5000ms,3.3V 108.5043ms,3.3
+ 108.5044ms,0.0V 108.5199ms,0.0
+ 108.5200ms,3.3V 108.5243ms,3.3
+ 108.5244ms,0.0V 108.5399ms,0.0
+ 108.5400ms,3.3V 108.5443ms,3.3
+ 108.5444ms,0.0V 108.5599ms,0.0
+ 108.5600ms,3.3V 108.5643ms,3.3
+ 108.5644ms,0.0V 108.5799ms,0.0
+ 108.5800ms,3.3V 108.5843ms,3.3
+ 108.5844ms,0.0V 108.5999ms,0.0
+ 108.6000ms,3.3V 108.6043ms,3.3
+ 108.6044ms,0.0V 108.6199ms,0.0
+ 108.6200ms,3.3V 108.6243ms,3.3
+ 108.6244ms,0.0V 108.6399ms,0.0
+ 108.6400ms,3.3V 108.6443ms,3.3
+ 108.6444ms,0.0V 108.6599ms,0.0
+ 108.6600ms,3.3V 108.6643ms,3.3
+ 108.6644ms,0.0V 108.6799ms,0.0
+ 108.6800ms,3.3V 108.6843ms,3.3
+ 108.6844ms,0.0V 108.6999ms,0.0
+ 108.7000ms,3.3V 108.7043ms,3.3
+ 108.7044ms,0.0V 108.7199ms,0.0
+ 108.7200ms,3.3V 108.7243ms,3.3
+ 108.7244ms,0.0V 108.7399ms,0.0
+ 108.7400ms,3.3V 108.7443ms,3.3
+ 108.7444ms,0.0V 108.7599ms,0.0
+ 108.7600ms,3.3V 108.7643ms,3.3
+ 108.7644ms,0.0V 108.7799ms,0.0
+ 108.7800ms,3.3V 108.7843ms,3.3
+ 108.7844ms,0.0V 108.7999ms,0.0
+ 108.8000ms,3.3V 108.8043ms,3.3
+ 108.8044ms,0.0V 108.8199ms,0.0
+ 108.8200ms,3.3V 108.8243ms,3.3
+ 108.8244ms,0.0V 108.8399ms,0.0
+ 108.8400ms,3.3V 108.8443ms,3.3
+ 108.8444ms,0.0V 108.8599ms,0.0
+ 108.8600ms,3.3V 108.8643ms,3.3
+ 108.8644ms,0.0V 108.8799ms,0.0
+ 108.8800ms,3.3V 108.8843ms,3.3
+ 108.8844ms,0.0V 108.8999ms,0.0
+ 108.9000ms,3.3V 108.9043ms,3.3
+ 108.9044ms,0.0V 108.9199ms,0.0
+ 108.9200ms,3.3V 108.9243ms,3.3
+ 108.9244ms,0.0V 108.9399ms,0.0
+ 108.9400ms,3.3V 108.9443ms,3.3
+ 108.9444ms,0.0V 108.9599ms,0.0
+ 108.9600ms,3.3V 108.9643ms,3.3
+ 108.9644ms,0.0V 108.9799ms,0.0
+ 108.9800ms,3.3V 108.9843ms,3.3
+ 108.9844ms,0.0V 108.9999ms,0.0
+ 109.0000ms,3.3V 109.0043ms,3.3
+ 109.0044ms,0.0V 109.0199ms,0.0
+ 109.0200ms,3.3V 109.0243ms,3.3
+ 109.0244ms,0.0V 109.0399ms,0.0
+ 109.0400ms,3.3V 109.0443ms,3.3
+ 109.0444ms,0.0V 109.0599ms,0.0
+ 109.0600ms,3.3V 109.0643ms,3.3
+ 109.0644ms,0.0V 109.0799ms,0.0
+ 109.0800ms,3.3V 109.0843ms,3.3
+ 109.0844ms,0.0V 109.0999ms,0.0
+ 109.1000ms,3.3V 109.1043ms,3.3
+ 109.1044ms,0.0V 109.1199ms,0.0
+ 109.1200ms,3.3V 109.1243ms,3.3
+ 109.1244ms,0.0V 109.1399ms,0.0
+ 109.1400ms,3.3V 109.1443ms,3.3
+ 109.1444ms,0.0V 109.1599ms,0.0
+ 109.1600ms,3.3V 109.1643ms,3.3
+ 109.1644ms,0.0V 109.1799ms,0.0
+ 109.1800ms,3.3V 109.1843ms,3.3
+ 109.1844ms,0.0V 109.1999ms,0.0
+ 109.2000ms,3.3V 109.2043ms,3.3
+ 109.2044ms,0.0V 109.2199ms,0.0
+ 109.2200ms,3.3V 109.2243ms,3.3
+ 109.2244ms,0.0V 109.2399ms,0.0
+ 109.2400ms,3.3V 109.2443ms,3.3
+ 109.2444ms,0.0V 109.2599ms,0.0
+ 109.2600ms,3.3V 109.2643ms,3.3
+ 109.2644ms,0.0V 109.2799ms,0.0
+ 109.2800ms,3.3V 109.2843ms,3.3
+ 109.2844ms,0.0V 109.2999ms,0.0
+ 109.3000ms,3.3V 109.3043ms,3.3
+ 109.3044ms,0.0V 109.3199ms,0.0
+ 109.3200ms,3.3V 109.3243ms,3.3
+ 109.3244ms,0.0V 109.3399ms,0.0
+ 109.3400ms,3.3V 109.3443ms,3.3
+ 109.3444ms,0.0V 109.3599ms,0.0
+ 109.3600ms,3.3V 109.3643ms,3.3
+ 109.3644ms,0.0V 109.3799ms,0.0
+ 109.3800ms,3.3V 109.3843ms,3.3
+ 109.3844ms,0.0V 109.3999ms,0.0
+ 109.4000ms,3.3V 109.4043ms,3.3
+ 109.4044ms,0.0V 109.4199ms,0.0
+ 109.4200ms,3.3V 109.4243ms,3.3
+ 109.4244ms,0.0V 109.4399ms,0.0
+ 109.4400ms,3.3V 109.4443ms,3.3
+ 109.4444ms,0.0V 109.4599ms,0.0
+ 109.4600ms,3.3V 109.4643ms,3.3
+ 109.4644ms,0.0V 109.4799ms,0.0
+ 109.4800ms,3.3V 109.4843ms,3.3
+ 109.4844ms,0.0V 109.4999ms,0.0
+ 109.5000ms,3.3V 109.5043ms,3.3
+ 109.5044ms,0.0V 109.5199ms,0.0
+ 109.5200ms,3.3V 109.5243ms,3.3
+ 109.5244ms,0.0V 109.5399ms,0.0
+ 109.5400ms,3.3V 109.5443ms,3.3
+ 109.5444ms,0.0V 109.5599ms,0.0
+ 109.5600ms,3.3V 109.5643ms,3.3
+ 109.5644ms,0.0V 109.5799ms,0.0
+ 109.5800ms,3.3V 109.5843ms,3.3
+ 109.5844ms,0.0V 109.5999ms,0.0
+ 109.6000ms,3.3V 109.6043ms,3.3
+ 109.6044ms,0.0V 109.6199ms,0.0
+ 109.6200ms,3.3V 109.6243ms,3.3
+ 109.6244ms,0.0V 109.6399ms,0.0
+ 109.6400ms,3.3V 109.6443ms,3.3
+ 109.6444ms,0.0V 109.6599ms,0.0
+ 109.6600ms,3.3V 109.6643ms,3.3
+ 109.6644ms,0.0V 109.6799ms,0.0
+ 109.6800ms,3.3V 109.6843ms,3.3
+ 109.6844ms,0.0V 109.6999ms,0.0
+ 109.7000ms,3.3V 109.7043ms,3.3
+ 109.7044ms,0.0V 109.7199ms,0.0
+ 109.7200ms,3.3V 109.7243ms,3.3
+ 109.7244ms,0.0V 109.7399ms,0.0
+ 109.7400ms,3.3V 109.7443ms,3.3
+ 109.7444ms,0.0V 109.7599ms,0.0
+ 109.7600ms,3.3V 109.7643ms,3.3
+ 109.7644ms,0.0V 109.7799ms,0.0
+ 109.7800ms,3.3V 109.7843ms,3.3
+ 109.7844ms,0.0V 109.7999ms,0.0
+ 109.8000ms,3.3V 109.8043ms,3.3
+ 109.8044ms,0.0V 109.8199ms,0.0
+ 109.8200ms,3.3V 109.8243ms,3.3
+ 109.8244ms,0.0V 109.8399ms,0.0
+ 109.8400ms,3.3V 109.8443ms,3.3
+ 109.8444ms,0.0V 109.8599ms,0.0
+ 109.8600ms,3.3V 109.8643ms,3.3
+ 109.8644ms,0.0V 109.8799ms,0.0
+ 109.8800ms,3.3V 109.8843ms,3.3
+ 109.8844ms,0.0V 109.8999ms,0.0
+ 109.9000ms,3.3V 109.9043ms,3.3
+ 109.9044ms,0.0V 109.9199ms,0.0
+ 109.9200ms,3.3V 109.9243ms,3.3
+ 109.9244ms,0.0V 109.9399ms,0.0
+ 109.9400ms,3.3V 109.9443ms,3.3
+ 109.9444ms,0.0V 109.9599ms,0.0
+ 109.9600ms,3.3V 109.9643ms,3.3
+ 109.9644ms,0.0V 109.9799ms,0.0
+ 109.9800ms,3.3V 109.9843ms,3.3
+ 109.9844ms,0.0V 109.9999ms,0.0
+ 110.0000ms,3.3V 110.0043ms,3.3
+ 110.0044ms,0.0V 110.0199ms,0.0
+ 110.0200ms,3.3V 110.0243ms,3.3
+ 110.0244ms,0.0V 110.0399ms,0.0
+ 110.0400ms,3.3V 110.0443ms,3.3
+ 110.0444ms,0.0V 110.0599ms,0.0
+ 110.0600ms,3.3V 110.0643ms,3.3
+ 110.0644ms,0.0V 110.0799ms,0.0
+ 110.0800ms,3.3V 110.0843ms,3.3
+ 110.0844ms,0.0V 110.0999ms,0.0
+ 110.1000ms,3.3V 110.1043ms,3.3
+ 110.1044ms,0.0V 110.1199ms,0.0
+ 110.1200ms,3.3V 110.1243ms,3.3
+ 110.1244ms,0.0V 110.1399ms,0.0
+ 110.1400ms,3.3V 110.1443ms,3.3
+ 110.1444ms,0.0V 110.1599ms,0.0
+ 110.1600ms,3.3V 110.1643ms,3.3
+ 110.1644ms,0.0V 110.1799ms,0.0
+ 110.1800ms,3.3V 110.1843ms,3.3
+ 110.1844ms,0.0V 110.1999ms,0.0
+ 110.2000ms,3.3V 110.2043ms,3.3
+ 110.2044ms,0.0V 110.2199ms,0.0
+ 110.2200ms,3.3V 110.2243ms,3.3
+ 110.2244ms,0.0V 110.2399ms,0.0
+ 110.2400ms,3.3V 110.2443ms,3.3
+ 110.2444ms,0.0V 110.2599ms,0.0
+ 110.2600ms,3.3V 110.2643ms,3.3
+ 110.2644ms,0.0V 110.2799ms,0.0
+ 110.2800ms,3.3V 110.2843ms,3.3
+ 110.2844ms,0.0V 110.2999ms,0.0
+ 110.3000ms,3.3V 110.3045ms,3.3
+ 110.3046ms,0.0V 110.3199ms,0.0
+ 110.3200ms,3.3V 110.3245ms,3.3
+ 110.3246ms,0.0V 110.3399ms,0.0
+ 110.3400ms,3.3V 110.3445ms,3.3
+ 110.3446ms,0.0V 110.3599ms,0.0
+ 110.3600ms,3.3V 110.3645ms,3.3
+ 110.3646ms,0.0V 110.3799ms,0.0
+ 110.3800ms,3.3V 110.3845ms,3.3
+ 110.3846ms,0.0V 110.3999ms,0.0
+ 110.4000ms,3.3V 110.4045ms,3.3
+ 110.4046ms,0.0V 110.4199ms,0.0
+ 110.4200ms,3.3V 110.4245ms,3.3
+ 110.4246ms,0.0V 110.4399ms,0.0
+ 110.4400ms,3.3V 110.4445ms,3.3
+ 110.4446ms,0.0V 110.4599ms,0.0
+ 110.4600ms,3.3V 110.4645ms,3.3
+ 110.4646ms,0.0V 110.4799ms,0.0
+ 110.4800ms,3.3V 110.4845ms,3.3
+ 110.4846ms,0.0V 110.4999ms,0.0
+ 110.5000ms,3.3V 110.5045ms,3.3
+ 110.5046ms,0.0V 110.5199ms,0.0
+ 110.5200ms,3.3V 110.5245ms,3.3
+ 110.5246ms,0.0V 110.5399ms,0.0
+ 110.5400ms,3.3V 110.5445ms,3.3
+ 110.5446ms,0.0V 110.5599ms,0.0
+ 110.5600ms,3.3V 110.5645ms,3.3
+ 110.5646ms,0.0V 110.5799ms,0.0
+ 110.5800ms,3.3V 110.5845ms,3.3
+ 110.5846ms,0.0V 110.5999ms,0.0
+ 110.6000ms,3.3V 110.6045ms,3.3
+ 110.6046ms,0.0V 110.6199ms,0.0
+ 110.6200ms,3.3V 110.6245ms,3.3
+ 110.6246ms,0.0V 110.6399ms,0.0
+ 110.6400ms,3.3V 110.6445ms,3.3
+ 110.6446ms,0.0V 110.6599ms,0.0
+ 110.6600ms,3.3V 110.6645ms,3.3
+ 110.6646ms,0.0V 110.6799ms,0.0
+ 110.6800ms,3.3V 110.6845ms,3.3
+ 110.6846ms,0.0V 110.6999ms,0.0
+ 110.7000ms,3.3V 110.7045ms,3.3
+ 110.7046ms,0.0V 110.7199ms,0.0
+ 110.7200ms,3.3V 110.7245ms,3.3
+ 110.7246ms,0.0V 110.7399ms,0.0
+ 110.7400ms,3.3V 110.7445ms,3.3
+ 110.7446ms,0.0V 110.7599ms,0.0
+ 110.7600ms,3.3V 110.7645ms,3.3
+ 110.7646ms,0.0V 110.7799ms,0.0
+ 110.7800ms,3.3V 110.7845ms,3.3
+ 110.7846ms,0.0V 110.7999ms,0.0
+ 110.8000ms,3.3V 110.8045ms,3.3
+ 110.8046ms,0.0V 110.8199ms,0.0
+ 110.8200ms,3.3V 110.8245ms,3.3
+ 110.8246ms,0.0V 110.8399ms,0.0
+ 110.8400ms,3.3V 110.8445ms,3.3
+ 110.8446ms,0.0V 110.8599ms,0.0
+ 110.8600ms,3.3V 110.8645ms,3.3
+ 110.8646ms,0.0V 110.8799ms,0.0
+ 110.8800ms,3.3V 110.8845ms,3.3
+ 110.8846ms,0.0V 110.8999ms,0.0
+ 110.9000ms,3.3V 110.9045ms,3.3
+ 110.9046ms,0.0V 110.9199ms,0.0
+ 110.9200ms,3.3V 110.9245ms,3.3
+ 110.9246ms,0.0V 110.9399ms,0.0
+ 110.9400ms,3.3V 110.9445ms,3.3
+ 110.9446ms,0.0V 110.9599ms,0.0
+ 110.9600ms,3.3V 110.9645ms,3.3
+ 110.9646ms,0.0V 110.9799ms,0.0
+ 110.9800ms,3.3V 110.9845ms,3.3
+ 110.9846ms,0.0V 110.9999ms,0.0
+ 111.0000ms,3.3V 111.0045ms,3.3
+ 111.0046ms,0.0V 111.0199ms,0.0
+ 111.0200ms,3.3V 111.0245ms,3.3
+ 111.0246ms,0.0V 111.0399ms,0.0
+ 111.0400ms,3.3V 111.0445ms,3.3
+ 111.0446ms,0.0V 111.0599ms,0.0
+ 111.0600ms,3.3V 111.0645ms,3.3
+ 111.0646ms,0.0V 111.0799ms,0.0
+ 111.0800ms,3.3V 111.0845ms,3.3
+ 111.0846ms,0.0V 111.0999ms,0.0
+ 111.1000ms,3.3V 111.1045ms,3.3
+ 111.1046ms,0.0V 111.1199ms,0.0
+ 111.1200ms,3.3V 111.1245ms,3.3
+ 111.1246ms,0.0V 111.1399ms,0.0
+ 111.1400ms,3.3V 111.1445ms,3.3
+ 111.1446ms,0.0V 111.1599ms,0.0
+ 111.1600ms,3.3V 111.1645ms,3.3
+ 111.1646ms,0.0V 111.1799ms,0.0
+ 111.1800ms,3.3V 111.1845ms,3.3
+ 111.1846ms,0.0V 111.1999ms,0.0
+ 111.2000ms,3.3V 111.2045ms,3.3
+ 111.2046ms,0.0V 111.2199ms,0.0
+ 111.2200ms,3.3V 111.2245ms,3.3
+ 111.2246ms,0.0V 111.2399ms,0.0
+ 111.2400ms,3.3V 111.2445ms,3.3
+ 111.2446ms,0.0V 111.2599ms,0.0
+ 111.2600ms,3.3V 111.2645ms,3.3
+ 111.2646ms,0.0V 111.2799ms,0.0
+ 111.2800ms,3.3V 111.2845ms,3.3
+ 111.2846ms,0.0V 111.2999ms,0.0
+ 111.3000ms,3.3V 111.3045ms,3.3
+ 111.3046ms,0.0V 111.3199ms,0.0
+ 111.3200ms,3.3V 111.3245ms,3.3
+ 111.3246ms,0.0V 111.3399ms,0.0
+ 111.3400ms,3.3V 111.3445ms,3.3
+ 111.3446ms,0.0V 111.3599ms,0.0
+ 111.3600ms,3.3V 111.3645ms,3.3
+ 111.3646ms,0.0V 111.3799ms,0.0
+ 111.3800ms,3.3V 111.3845ms,3.3
+ 111.3846ms,0.0V 111.3999ms,0.0
+ 111.4000ms,3.3V 111.4045ms,3.3
+ 111.4046ms,0.0V 111.4199ms,0.0
+ 111.4200ms,3.3V 111.4245ms,3.3
+ 111.4246ms,0.0V 111.4399ms,0.0
+ 111.4400ms,3.3V 111.4445ms,3.3
+ 111.4446ms,0.0V 111.4599ms,0.0
+ 111.4600ms,3.3V 111.4645ms,3.3
+ 111.4646ms,0.0V 111.4799ms,0.0
+ 111.4800ms,3.3V 111.4845ms,3.3
+ 111.4846ms,0.0V 111.4999ms,0.0
+ 111.5000ms,3.3V 111.5045ms,3.3
+ 111.5046ms,0.0V 111.5199ms,0.0
+ 111.5200ms,3.3V 111.5245ms,3.3
+ 111.5246ms,0.0V 111.5399ms,0.0
+ 111.5400ms,3.3V 111.5445ms,3.3
+ 111.5446ms,0.0V 111.5599ms,0.0
+ 111.5600ms,3.3V 111.5645ms,3.3
+ 111.5646ms,0.0V 111.5799ms,0.0
+ 111.5800ms,3.3V 111.5845ms,3.3
+ 111.5846ms,0.0V 111.5999ms,0.0
+ 111.6000ms,3.3V 111.6045ms,3.3
+ 111.6046ms,0.0V 111.6199ms,0.0
+ 111.6200ms,3.3V 111.6245ms,3.3
+ 111.6246ms,0.0V 111.6399ms,0.0
+ 111.6400ms,3.3V 111.6445ms,3.3
+ 111.6446ms,0.0V 111.6599ms,0.0
+ 111.6600ms,3.3V 111.6645ms,3.3
+ 111.6646ms,0.0V 111.6799ms,0.0
+ 111.6800ms,3.3V 111.6845ms,3.3
+ 111.6846ms,0.0V 111.6999ms,0.0
+ 111.7000ms,3.3V 111.7045ms,3.3
+ 111.7046ms,0.0V 111.7199ms,0.0
+ 111.7200ms,3.3V 111.7245ms,3.3
+ 111.7246ms,0.0V 111.7399ms,0.0
+ 111.7400ms,3.3V 111.7445ms,3.3
+ 111.7446ms,0.0V 111.7599ms,0.0
+ 111.7600ms,3.3V 111.7645ms,3.3
+ 111.7646ms,0.0V 111.7799ms,0.0
+ 111.7800ms,3.3V 111.7845ms,3.3
+ 111.7846ms,0.0V 111.7999ms,0.0
+ 111.8000ms,3.3V 111.8045ms,3.3
+ 111.8046ms,0.0V 111.8199ms,0.0
+ 111.8200ms,3.3V 111.8245ms,3.3
+ 111.8246ms,0.0V 111.8399ms,0.0
+ 111.8400ms,3.3V 111.8445ms,3.3
+ 111.8446ms,0.0V 111.8599ms,0.0
+ 111.8600ms,3.3V 111.8645ms,3.3
+ 111.8646ms,0.0V 111.8799ms,0.0
+ 111.8800ms,3.3V 111.8845ms,3.3
+ 111.8846ms,0.0V 111.8999ms,0.0
+ 111.9000ms,3.3V 111.9045ms,3.3
+ 111.9046ms,0.0V 111.9199ms,0.0
+ 111.9200ms,3.3V 111.9245ms,3.3
+ 111.9246ms,0.0V 111.9399ms,0.0
+ 111.9400ms,3.3V 111.9445ms,3.3
+ 111.9446ms,0.0V 111.9599ms,0.0
+ 111.9600ms,3.3V 111.9645ms,3.3
+ 111.9646ms,0.0V 111.9799ms,0.0
+ 111.9800ms,3.3V 111.9845ms,3.3
+ 111.9846ms,0.0V 111.9999ms,0.0
+ 112.0000ms,3.3V 112.0045ms,3.3
+ 112.0046ms,0.0V 112.0199ms,0.0
+ 112.0200ms,3.3V 112.0245ms,3.3
+ 112.0246ms,0.0V 112.0399ms,0.0
+ 112.0400ms,3.3V 112.0445ms,3.3
+ 112.0446ms,0.0V 112.0599ms,0.0
+ 112.0600ms,3.3V 112.0645ms,3.3
+ 112.0646ms,0.0V 112.0799ms,0.0
+ 112.0800ms,3.3V 112.0845ms,3.3
+ 112.0846ms,0.0V 112.0999ms,0.0
+ 112.1000ms,3.3V 112.1045ms,3.3
+ 112.1046ms,0.0V 112.1199ms,0.0
+ 112.1200ms,3.3V 112.1245ms,3.3
+ 112.1246ms,0.0V 112.1399ms,0.0
+ 112.1400ms,3.3V 112.1445ms,3.3
+ 112.1446ms,0.0V 112.1599ms,0.0
+ 112.1600ms,3.3V 112.1645ms,3.3
+ 112.1646ms,0.0V 112.1799ms,0.0
+ 112.1800ms,3.3V 112.1845ms,3.3
+ 112.1846ms,0.0V 112.1999ms,0.0
+ 112.2000ms,3.3V 112.2045ms,3.3
+ 112.2046ms,0.0V 112.2199ms,0.0
+ 112.2200ms,3.3V 112.2245ms,3.3
+ 112.2246ms,0.0V 112.2399ms,0.0
+ 112.2400ms,3.3V 112.2445ms,3.3
+ 112.2446ms,0.0V 112.2599ms,0.0
+ 112.2600ms,3.3V 112.2645ms,3.3
+ 112.2646ms,0.0V 112.2799ms,0.0
+ 112.2800ms,3.3V 112.2845ms,3.3
+ 112.2846ms,0.0V 112.2999ms,0.0
+ 112.3000ms,3.3V 112.3045ms,3.3
+ 112.3046ms,0.0V 112.3199ms,0.0
+ 112.3200ms,3.3V 112.3245ms,3.3
+ 112.3246ms,0.0V 112.3399ms,0.0
+ 112.3400ms,3.3V 112.3445ms,3.3
+ 112.3446ms,0.0V 112.3599ms,0.0
+ 112.3600ms,3.3V 112.3645ms,3.3
+ 112.3646ms,0.0V 112.3799ms,0.0
+ 112.3800ms,3.3V 112.3845ms,3.3
+ 112.3846ms,0.0V 112.3999ms,0.0
+ 112.4000ms,3.3V 112.4045ms,3.3
+ 112.4046ms,0.0V 112.4199ms,0.0
+ 112.4200ms,3.3V 112.4245ms,3.3
+ 112.4246ms,0.0V 112.4399ms,0.0
+ 112.4400ms,3.3V 112.4445ms,3.3
+ 112.4446ms,0.0V 112.4599ms,0.0
+ 112.4600ms,3.3V 112.4645ms,3.3
+ 112.4646ms,0.0V 112.4799ms,0.0
+ 112.4800ms,3.3V 112.4845ms,3.3
+ 112.4846ms,0.0V 112.4999ms,0.0
+ 112.5000ms,3.3V 112.5045ms,3.3
+ 112.5046ms,0.0V 112.5199ms,0.0
+ 112.5200ms,3.3V 112.5245ms,3.3
+ 112.5246ms,0.0V 112.5399ms,0.0
+ 112.5400ms,3.3V 112.5445ms,3.3
+ 112.5446ms,0.0V 112.5599ms,0.0
+ 112.5600ms,3.3V 112.5645ms,3.3
+ 112.5646ms,0.0V 112.5799ms,0.0
+ 112.5800ms,3.3V 112.5845ms,3.3
+ 112.5846ms,0.0V 112.5999ms,0.0
+ 112.6000ms,3.3V 112.6045ms,3.3
+ 112.6046ms,0.0V 112.6199ms,0.0
+ 112.6200ms,3.3V 112.6245ms,3.3
+ 112.6246ms,0.0V 112.6399ms,0.0
+ 112.6400ms,3.3V 112.6445ms,3.3
+ 112.6446ms,0.0V 112.6599ms,0.0
+ 112.6600ms,3.3V 112.6645ms,3.3
+ 112.6646ms,0.0V 112.6799ms,0.0
+ 112.6800ms,3.3V 112.6845ms,3.3
+ 112.6846ms,0.0V 112.6999ms,0.0
+ 112.7000ms,3.3V 112.7045ms,3.3
+ 112.7046ms,0.0V 112.7199ms,0.0
+ 112.7200ms,3.3V 112.7245ms,3.3
+ 112.7246ms,0.0V 112.7399ms,0.0
+ 112.7400ms,3.3V 112.7445ms,3.3
+ 112.7446ms,0.0V 112.7599ms,0.0
+ 112.7600ms,3.3V 112.7645ms,3.3
+ 112.7646ms,0.0V 112.7799ms,0.0
+ 112.7800ms,3.3V 112.7845ms,3.3
+ 112.7846ms,0.0V 112.7999ms,0.0
+ 112.8000ms,3.3V 112.8045ms,3.3
+ 112.8046ms,0.0V 112.8199ms,0.0
+ 112.8200ms,3.3V 112.8245ms,3.3
+ 112.8246ms,0.0V 112.8399ms,0.0
+ 112.8400ms,3.3V 112.8445ms,3.3
+ 112.8446ms,0.0V 112.8599ms,0.0
+ 112.8600ms,3.3V 112.8645ms,3.3
+ 112.8646ms,0.0V 112.8799ms,0.0
+ 112.8800ms,3.3V 112.8845ms,3.3
+ 112.8846ms,0.0V 112.8999ms,0.0
+ 112.9000ms,3.3V 112.9045ms,3.3
+ 112.9046ms,0.0V 112.9199ms,0.0
+ 112.9200ms,3.3V 112.9245ms,3.3
+ 112.9246ms,0.0V 112.9399ms,0.0
+ 112.9400ms,3.3V 112.9445ms,3.3
+ 112.9446ms,0.0V 112.9599ms,0.0
+ 112.9600ms,3.3V 112.9645ms,3.3
+ 112.9646ms,0.0V 112.9799ms,0.0
+ 112.9800ms,3.3V 112.9845ms,3.3
+ 112.9846ms,0.0V 112.9999ms,0.0
+ 113.0000ms,3.3V 113.0045ms,3.3
+ 113.0046ms,0.0V 113.0199ms,0.0
+ 113.0200ms,3.3V 113.0245ms,3.3
+ 113.0246ms,0.0V 113.0399ms,0.0
+ 113.0400ms,3.3V 113.0445ms,3.3
+ 113.0446ms,0.0V 113.0599ms,0.0
+ 113.0600ms,3.3V 113.0645ms,3.3
+ 113.0646ms,0.0V 113.0799ms,0.0
+ 113.0800ms,3.3V 113.0845ms,3.3
+ 113.0846ms,0.0V 113.0999ms,0.0
+ 113.1000ms,3.3V 113.1045ms,3.3
+ 113.1046ms,0.0V 113.1199ms,0.0
+ 113.1200ms,3.3V 113.1245ms,3.3
+ 113.1246ms,0.0V 113.1399ms,0.0
+ 113.1400ms,3.3V 113.1445ms,3.3
+ 113.1446ms,0.0V 113.1599ms,0.0
+ 113.1600ms,3.3V 113.1645ms,3.3
+ 113.1646ms,0.0V 113.1799ms,0.0
+ 113.1800ms,3.3V 113.1845ms,3.3
+ 113.1846ms,0.0V 113.1999ms,0.0
+ 113.2000ms,3.3V 113.2045ms,3.3
+ 113.2046ms,0.0V 113.2199ms,0.0
+ 113.2200ms,3.3V 113.2245ms,3.3
+ 113.2246ms,0.0V 113.2399ms,0.0
+ 113.2400ms,3.3V 113.2445ms,3.3
+ 113.2446ms,0.0V 113.2599ms,0.0
+ 113.2600ms,3.3V 113.2645ms,3.3
+ 113.2646ms,0.0V 113.2799ms,0.0
+ 113.2800ms,3.3V 113.2845ms,3.3
+ 113.2846ms,0.0V 113.2999ms,0.0
+ 113.3000ms,3.3V 113.3045ms,3.3
+ 113.3046ms,0.0V 113.3199ms,0.0
+ 113.3200ms,3.3V 113.3245ms,3.3
+ 113.3246ms,0.0V 113.3399ms,0.0
+ 113.3400ms,3.3V 113.3445ms,3.3
+ 113.3446ms,0.0V 113.3599ms,0.0
+ 113.3600ms,3.3V 113.3645ms,3.3
+ 113.3646ms,0.0V 113.3799ms,0.0
+ 113.3800ms,3.3V 113.3845ms,3.3
+ 113.3846ms,0.0V 113.3999ms,0.0
+ 113.4000ms,3.3V 113.4045ms,3.3
+ 113.4046ms,0.0V 113.4199ms,0.0
+ 113.4200ms,3.3V 113.4245ms,3.3
+ 113.4246ms,0.0V 113.4399ms,0.0
+ 113.4400ms,3.3V 113.4445ms,3.3
+ 113.4446ms,0.0V 113.4599ms,0.0
+ 113.4600ms,3.3V 113.4645ms,3.3
+ 113.4646ms,0.0V 113.4799ms,0.0
+ 113.4800ms,3.3V 113.4845ms,3.3
+ 113.4846ms,0.0V 113.4999ms,0.0
+ 113.5000ms,3.3V 113.5045ms,3.3
+ 113.5046ms,0.0V 113.5199ms,0.0
+ 113.5200ms,3.3V 113.5245ms,3.3
+ 113.5246ms,0.0V 113.5399ms,0.0
+ 113.5400ms,3.3V 113.5445ms,3.3
+ 113.5446ms,0.0V 113.5599ms,0.0
+ 113.5600ms,3.3V 113.5645ms,3.3
+ 113.5646ms,0.0V 113.5799ms,0.0
+ 113.5800ms,3.3V 113.5845ms,3.3
+ 113.5846ms,0.0V 113.5999ms,0.0
+ 113.6000ms,3.3V 113.6045ms,3.3
+ 113.6046ms,0.0V 113.6199ms,0.0
+ 113.6200ms,3.3V 113.6245ms,3.3
+ 113.6246ms,0.0V 113.6399ms,0.0
+ 113.6400ms,3.3V 113.6445ms,3.3
+ 113.6446ms,0.0V 113.6599ms,0.0
+ 113.6600ms,3.3V 113.6645ms,3.3
+ 113.6646ms,0.0V 113.6799ms,0.0
+ 113.6800ms,3.3V 113.6845ms,3.3
+ 113.6846ms,0.0V 113.6999ms,0.0
+ 113.7000ms,3.3V 113.7045ms,3.3
+ 113.7046ms,0.0V 113.7199ms,0.0
+ 113.7200ms,3.3V 113.7245ms,3.3
+ 113.7246ms,0.0V 113.7399ms,0.0
+ 113.7400ms,3.3V 113.7445ms,3.3
+ 113.7446ms,0.0V 113.7599ms,0.0
+ 113.7600ms,3.3V 113.7645ms,3.3
+ 113.7646ms,0.0V 113.7799ms,0.0
+ 113.7800ms,3.3V 113.7845ms,3.3
+ 113.7846ms,0.0V 113.7999ms,0.0
+ 113.8000ms,3.3V 113.8045ms,3.3
+ 113.8046ms,0.0V 113.8199ms,0.0
+ 113.8200ms,3.3V 113.8245ms,3.3
+ 113.8246ms,0.0V 113.8399ms,0.0
+ 113.8400ms,3.3V 113.8445ms,3.3
+ 113.8446ms,0.0V 113.8599ms,0.0
+ 113.8600ms,3.3V 113.8645ms,3.3
+ 113.8646ms,0.0V 113.8799ms,0.0
+ 113.8800ms,3.3V 113.8845ms,3.3
+ 113.8846ms,0.0V 113.8999ms,0.0
+ 113.9000ms,3.3V 113.9045ms,3.3
+ 113.9046ms,0.0V 113.9199ms,0.0
+ 113.9200ms,3.3V 113.9245ms,3.3
+ 113.9246ms,0.0V 113.9399ms,0.0
+ 113.9400ms,3.3V 113.9445ms,3.3
+ 113.9446ms,0.0V 113.9599ms,0.0
+ 113.9600ms,3.3V 113.9645ms,3.3
+ 113.9646ms,0.0V 113.9799ms,0.0
+ 113.9800ms,3.3V 113.9845ms,3.3
+ 113.9846ms,0.0V 113.9999ms,0.0
+ 114.0000ms,3.3V 114.0045ms,3.3
+ 114.0046ms,0.0V 114.0199ms,0.0
+ 114.0200ms,3.3V 114.0245ms,3.3
+ 114.0246ms,0.0V 114.0399ms,0.0
+ 114.0400ms,3.3V 114.0445ms,3.3
+ 114.0446ms,0.0V 114.0599ms,0.0
+ 114.0600ms,3.3V 114.0645ms,3.3
+ 114.0646ms,0.0V 114.0799ms,0.0
+ 114.0800ms,3.3V 114.0845ms,3.3
+ 114.0846ms,0.0V 114.0999ms,0.0
+ 114.1000ms,3.3V 114.1045ms,3.3
+ 114.1046ms,0.0V 114.1199ms,0.0
+ 114.1200ms,3.3V 114.1245ms,3.3
+ 114.1246ms,0.0V 114.1399ms,0.0
+ 114.1400ms,3.3V 114.1445ms,3.3
+ 114.1446ms,0.0V 114.1599ms,0.0
+ 114.1600ms,3.3V 114.1645ms,3.3
+ 114.1646ms,0.0V 114.1799ms,0.0
+ 114.1800ms,3.3V 114.1845ms,3.3
+ 114.1846ms,0.0V 114.1999ms,0.0
+ 114.2000ms,3.3V 114.2045ms,3.3
+ 114.2046ms,0.0V 114.2199ms,0.0
+ 114.2200ms,3.3V 114.2245ms,3.3
+ 114.2246ms,0.0V 114.2399ms,0.0
+ 114.2400ms,3.3V 114.2445ms,3.3
+ 114.2446ms,0.0V 114.2599ms,0.0
+ 114.2600ms,3.3V 114.2645ms,3.3
+ 114.2646ms,0.0V 114.2799ms,0.0
+ 114.2800ms,3.3V 114.2845ms,3.3
+ 114.2846ms,0.0V 114.2999ms,0.0
+ 114.3000ms,3.3V 114.3045ms,3.3
+ 114.3046ms,0.0V 114.3199ms,0.0
+ 114.3200ms,3.3V 114.3245ms,3.3
+ 114.3246ms,0.0V 114.3399ms,0.0
+ 114.3400ms,3.3V 114.3445ms,3.3
+ 114.3446ms,0.0V 114.3599ms,0.0
+ 114.3600ms,3.3V 114.3645ms,3.3
+ 114.3646ms,0.0V 114.3799ms,0.0
+ 114.3800ms,3.3V 114.3845ms,3.3
+ 114.3846ms,0.0V 114.3999ms,0.0
+ 114.4000ms,3.3V 114.4045ms,3.3
+ 114.4046ms,0.0V 114.4199ms,0.0
+ 114.4200ms,3.3V 114.4245ms,3.3
+ 114.4246ms,0.0V 114.4399ms,0.0
+ 114.4400ms,3.3V 114.4445ms,3.3
+ 114.4446ms,0.0V 114.4599ms,0.0
+ 114.4600ms,3.3V 114.4645ms,3.3
+ 114.4646ms,0.0V 114.4799ms,0.0
+ 114.4800ms,3.3V 114.4845ms,3.3
+ 114.4846ms,0.0V 114.4999ms,0.0
+ 114.5000ms,3.3V 114.5045ms,3.3
+ 114.5046ms,0.0V 114.5199ms,0.0
+ 114.5200ms,3.3V 114.5245ms,3.3
+ 114.5246ms,0.0V 114.5399ms,0.0
+ 114.5400ms,3.3V 114.5445ms,3.3
+ 114.5446ms,0.0V 114.5599ms,0.0
+ 114.5600ms,3.3V 114.5645ms,3.3
+ 114.5646ms,0.0V 114.5799ms,0.0
+ 114.5800ms,3.3V 114.5845ms,3.3
+ 114.5846ms,0.0V 114.5999ms,0.0
+ 114.6000ms,3.3V 114.6045ms,3.3
+ 114.6046ms,0.0V 114.6199ms,0.0
+ 114.6200ms,3.3V 114.6245ms,3.3
+ 114.6246ms,0.0V 114.6399ms,0.0
+ 114.6400ms,3.3V 114.6445ms,3.3
+ 114.6446ms,0.0V 114.6599ms,0.0
+ 114.6600ms,3.3V 114.6645ms,3.3
+ 114.6646ms,0.0V 114.6799ms,0.0
+ 114.6800ms,3.3V 114.6845ms,3.3
+ 114.6846ms,0.0V 114.6999ms,0.0
+ 114.7000ms,3.3V 114.7045ms,3.3
+ 114.7046ms,0.0V 114.7199ms,0.0
+ 114.7200ms,3.3V 114.7245ms,3.3
+ 114.7246ms,0.0V 114.7399ms,0.0
+ 114.7400ms,3.3V 114.7445ms,3.3
+ 114.7446ms,0.0V 114.7599ms,0.0
+ 114.7600ms,3.3V 114.7645ms,3.3
+ 114.7646ms,0.0V 114.7799ms,0.0
+ 114.7800ms,3.3V 114.7845ms,3.3
+ 114.7846ms,0.0V 114.7999ms,0.0
+ 114.8000ms,3.3V 114.8045ms,3.3
+ 114.8046ms,0.0V 114.8199ms,0.0
+ 114.8200ms,3.3V 114.8245ms,3.3
+ 114.8246ms,0.0V 114.8399ms,0.0
+ 114.8400ms,3.3V 114.8445ms,3.3
+ 114.8446ms,0.0V 114.8599ms,0.0
+ 114.8600ms,3.3V 114.8645ms,3.3
+ 114.8646ms,0.0V 114.8799ms,0.0
+ 114.8800ms,3.3V 114.8845ms,3.3
+ 114.8846ms,0.0V 114.8999ms,0.0
+ 114.9000ms,3.3V 114.9045ms,3.3
+ 114.9046ms,0.0V 114.9199ms,0.0
+ 114.9200ms,3.3V 114.9245ms,3.3
+ 114.9246ms,0.0V 114.9399ms,0.0
+ 114.9400ms,3.3V 114.9445ms,3.3
+ 114.9446ms,0.0V 114.9599ms,0.0
+ 114.9600ms,3.3V 114.9645ms,3.3
+ 114.9646ms,0.0V 114.9799ms,0.0
+ 114.9800ms,3.3V 114.9845ms,3.3
+ 114.9846ms,0.0V 114.9999ms,0.0
+ 115.0000ms,3.3V 115.0045ms,3.3
+ 115.0046ms,0.0V 115.0199ms,0.0
+ 115.0200ms,3.3V 115.0245ms,3.3
+ 115.0246ms,0.0V 115.0399ms,0.0
+ 115.0400ms,3.3V 115.0445ms,3.3
+ 115.0446ms,0.0V 115.0599ms,0.0
+ 115.0600ms,3.3V 115.0645ms,3.3
+ 115.0646ms,0.0V 115.0799ms,0.0
+ 115.0800ms,3.3V 115.0845ms,3.3
+ 115.0846ms,0.0V 115.0999ms,0.0
+ 115.1000ms,3.3V 115.1045ms,3.3
+ 115.1046ms,0.0V 115.1199ms,0.0
+ 115.1200ms,3.3V 115.1245ms,3.3
+ 115.1246ms,0.0V 115.1399ms,0.0
+ 115.1400ms,3.3V 115.1445ms,3.3
+ 115.1446ms,0.0V 115.1599ms,0.0
+ 115.1600ms,3.3V 115.1645ms,3.3
+ 115.1646ms,0.0V 115.1799ms,0.0
+ 115.1800ms,3.3V 115.1845ms,3.3
+ 115.1846ms,0.0V 115.1999ms,0.0
+ 115.2000ms,3.3V 115.2045ms,3.3
+ 115.2046ms,0.0V 115.2199ms,0.0
+ 115.2200ms,3.3V 115.2245ms,3.3
+ 115.2246ms,0.0V 115.2399ms,0.0
+ 115.2400ms,3.3V 115.2445ms,3.3
+ 115.2446ms,0.0V 115.2599ms,0.0
+ 115.2600ms,3.3V 115.2645ms,3.3
+ 115.2646ms,0.0V 115.2799ms,0.0
+ 115.2800ms,3.3V 115.2845ms,3.3
+ 115.2846ms,0.0V 115.2999ms,0.0
+ 115.3000ms,3.3V 115.3045ms,3.3
+ 115.3046ms,0.0V 115.3199ms,0.0
+ 115.3200ms,3.3V 115.3247ms,3.3
+ 115.3248ms,0.0V 115.3399ms,0.0
+ 115.3400ms,3.3V 115.3447ms,3.3
+ 115.3448ms,0.0V 115.3599ms,0.0
+ 115.3600ms,3.3V 115.3647ms,3.3
+ 115.3648ms,0.0V 115.3799ms,0.0
+ 115.3800ms,3.3V 115.3847ms,3.3
+ 115.3848ms,0.0V 115.3999ms,0.0
+ 115.4000ms,3.3V 115.4047ms,3.3
+ 115.4048ms,0.0V 115.4199ms,0.0
+ 115.4200ms,3.3V 115.4247ms,3.3
+ 115.4248ms,0.0V 115.4399ms,0.0
+ 115.4400ms,3.3V 115.4447ms,3.3
+ 115.4448ms,0.0V 115.4599ms,0.0
+ 115.4600ms,3.3V 115.4647ms,3.3
+ 115.4648ms,0.0V 115.4799ms,0.0
+ 115.4800ms,3.3V 115.4847ms,3.3
+ 115.4848ms,0.0V 115.4999ms,0.0
+ 115.5000ms,3.3V 115.5047ms,3.3
+ 115.5048ms,0.0V 115.5199ms,0.0
+ 115.5200ms,3.3V 115.5247ms,3.3
+ 115.5248ms,0.0V 115.5399ms,0.0
+ 115.5400ms,3.3V 115.5447ms,3.3
+ 115.5448ms,0.0V 115.5599ms,0.0
+ 115.5600ms,3.3V 115.5647ms,3.3
+ 115.5648ms,0.0V 115.5799ms,0.0
+ 115.5800ms,3.3V 115.5847ms,3.3
+ 115.5848ms,0.0V 115.5999ms,0.0
+ 115.6000ms,3.3V 115.6047ms,3.3
+ 115.6048ms,0.0V 115.6199ms,0.0
+ 115.6200ms,3.3V 115.6247ms,3.3
+ 115.6248ms,0.0V 115.6399ms,0.0
+ 115.6400ms,3.3V 115.6447ms,3.3
+ 115.6448ms,0.0V 115.6599ms,0.0
+ 115.6600ms,3.3V 115.6647ms,3.3
+ 115.6648ms,0.0V 115.6799ms,0.0
+ 115.6800ms,3.3V 115.6847ms,3.3
+ 115.6848ms,0.0V 115.6999ms,0.0
+ 115.7000ms,3.3V 115.7047ms,3.3
+ 115.7048ms,0.0V 115.7199ms,0.0
+ 115.7200ms,3.3V 115.7247ms,3.3
+ 115.7248ms,0.0V 115.7399ms,0.0
+ 115.7400ms,3.3V 115.7447ms,3.3
+ 115.7448ms,0.0V 115.7599ms,0.0
+ 115.7600ms,3.3V 115.7647ms,3.3
+ 115.7648ms,0.0V 115.7799ms,0.0
+ 115.7800ms,3.3V 115.7847ms,3.3
+ 115.7848ms,0.0V 115.7999ms,0.0
+ 115.8000ms,3.3V 115.8047ms,3.3
+ 115.8048ms,0.0V 115.8199ms,0.0
+ 115.8200ms,3.3V 115.8247ms,3.3
+ 115.8248ms,0.0V 115.8399ms,0.0
+ 115.8400ms,3.3V 115.8447ms,3.3
+ 115.8448ms,0.0V 115.8599ms,0.0
+ 115.8600ms,3.3V 115.8647ms,3.3
+ 115.8648ms,0.0V 115.8799ms,0.0
+ 115.8800ms,3.3V 115.8847ms,3.3
+ 115.8848ms,0.0V 115.8999ms,0.0
+ 115.9000ms,3.3V 115.9047ms,3.3
+ 115.9048ms,0.0V 115.9199ms,0.0
+ 115.9200ms,3.3V 115.9247ms,3.3
+ 115.9248ms,0.0V 115.9399ms,0.0
+ 115.9400ms,3.3V 115.9447ms,3.3
+ 115.9448ms,0.0V 115.9599ms,0.0
+ 115.9600ms,3.3V 115.9647ms,3.3
+ 115.9648ms,0.0V 115.9799ms,0.0
+ 115.9800ms,3.3V 115.9847ms,3.3
+ 115.9848ms,0.0V 115.9999ms,0.0
+ 116.0000ms,3.3V 116.0047ms,3.3
+ 116.0048ms,0.0V 116.0199ms,0.0
+ 116.0200ms,3.3V 116.0247ms,3.3
+ 116.0248ms,0.0V 116.0399ms,0.0
+ 116.0400ms,3.3V 116.0447ms,3.3
+ 116.0448ms,0.0V 116.0599ms,0.0
+ 116.0600ms,3.3V 116.0647ms,3.3
+ 116.0648ms,0.0V 116.0799ms,0.0
+ 116.0800ms,3.3V 116.0847ms,3.3
+ 116.0848ms,0.0V 116.0999ms,0.0
+ 116.1000ms,3.3V 116.1047ms,3.3
+ 116.1048ms,0.0V 116.1199ms,0.0
+ 116.1200ms,3.3V 116.1247ms,3.3
+ 116.1248ms,0.0V 116.1399ms,0.0
+ 116.1400ms,3.3V 116.1447ms,3.3
+ 116.1448ms,0.0V 116.1599ms,0.0
+ 116.1600ms,3.3V 116.1647ms,3.3
+ 116.1648ms,0.0V 116.1799ms,0.0
+ 116.1800ms,3.3V 116.1847ms,3.3
+ 116.1848ms,0.0V 116.1999ms,0.0
+ 116.2000ms,3.3V 116.2047ms,3.3
+ 116.2048ms,0.0V 116.2199ms,0.0
+ 116.2200ms,3.3V 116.2247ms,3.3
+ 116.2248ms,0.0V 116.2399ms,0.0
+ 116.2400ms,3.3V 116.2447ms,3.3
+ 116.2448ms,0.0V 116.2599ms,0.0
+ 116.2600ms,3.3V 116.2647ms,3.3
+ 116.2648ms,0.0V 116.2799ms,0.0
+ 116.2800ms,3.3V 116.2847ms,3.3
+ 116.2848ms,0.0V 116.2999ms,0.0
+ 116.3000ms,3.3V 116.3047ms,3.3
+ 116.3048ms,0.0V 116.3199ms,0.0
+ 116.3200ms,3.3V 116.3247ms,3.3
+ 116.3248ms,0.0V 116.3399ms,0.0
+ 116.3400ms,3.3V 116.3447ms,3.3
+ 116.3448ms,0.0V 116.3599ms,0.0
+ 116.3600ms,3.3V 116.3647ms,3.3
+ 116.3648ms,0.0V 116.3799ms,0.0
+ 116.3800ms,3.3V 116.3847ms,3.3
+ 116.3848ms,0.0V 116.3999ms,0.0
+ 116.4000ms,3.3V 116.4047ms,3.3
+ 116.4048ms,0.0V 116.4199ms,0.0
+ 116.4200ms,3.3V 116.4247ms,3.3
+ 116.4248ms,0.0V 116.4399ms,0.0
+ 116.4400ms,3.3V 116.4447ms,3.3
+ 116.4448ms,0.0V 116.4599ms,0.0
+ 116.4600ms,3.3V 116.4647ms,3.3
+ 116.4648ms,0.0V 116.4799ms,0.0
+ 116.4800ms,3.3V 116.4847ms,3.3
+ 116.4848ms,0.0V 116.4999ms,0.0
+ 116.5000ms,3.3V 116.5047ms,3.3
+ 116.5048ms,0.0V 116.5199ms,0.0
+ 116.5200ms,3.3V 116.5247ms,3.3
+ 116.5248ms,0.0V 116.5399ms,0.0
+ 116.5400ms,3.3V 116.5447ms,3.3
+ 116.5448ms,0.0V 116.5599ms,0.0
+ 116.5600ms,3.3V 116.5647ms,3.3
+ 116.5648ms,0.0V 116.5799ms,0.0
+ 116.5800ms,3.3V 116.5847ms,3.3
+ 116.5848ms,0.0V 116.5999ms,0.0
+ 116.6000ms,3.3V 116.6047ms,3.3
+ 116.6048ms,0.0V 116.6199ms,0.0
+ 116.6200ms,3.3V 116.6247ms,3.3
+ 116.6248ms,0.0V 116.6399ms,0.0
+ 116.6400ms,3.3V 116.6447ms,3.3
+ 116.6448ms,0.0V 116.6599ms,0.0
+ 116.6600ms,3.3V 116.6647ms,3.3
+ 116.6648ms,0.0V 116.6799ms,0.0
+ 116.6800ms,3.3V 116.6847ms,3.3
+ 116.6848ms,0.0V 116.6999ms,0.0
+ 116.7000ms,3.3V 116.7047ms,3.3
+ 116.7048ms,0.0V 116.7199ms,0.0
+ 116.7200ms,3.3V 116.7247ms,3.3
+ 116.7248ms,0.0V 116.7399ms,0.0
+ 116.7400ms,3.3V 116.7447ms,3.3
+ 116.7448ms,0.0V 116.7599ms,0.0
+ 116.7600ms,3.3V 116.7647ms,3.3
+ 116.7648ms,0.0V 116.7799ms,0.0
+ 116.7800ms,3.3V 116.7847ms,3.3
+ 116.7848ms,0.0V 116.7999ms,0.0
+ 116.8000ms,3.3V 116.8047ms,3.3
+ 116.8048ms,0.0V 116.8199ms,0.0
+ 116.8200ms,3.3V 116.8247ms,3.3
+ 116.8248ms,0.0V 116.8399ms,0.0
+ 116.8400ms,3.3V 116.8447ms,3.3
+ 116.8448ms,0.0V 116.8599ms,0.0
+ 116.8600ms,3.3V 116.8647ms,3.3
+ 116.8648ms,0.0V 116.8799ms,0.0
+ 116.8800ms,3.3V 116.8847ms,3.3
+ 116.8848ms,0.0V 116.8999ms,0.0
+ 116.9000ms,3.3V 116.9047ms,3.3
+ 116.9048ms,0.0V 116.9199ms,0.0
+ 116.9200ms,3.3V 116.9247ms,3.3
+ 116.9248ms,0.0V 116.9399ms,0.0
+ 116.9400ms,3.3V 116.9447ms,3.3
+ 116.9448ms,0.0V 116.9599ms,0.0
+ 116.9600ms,3.3V 116.9647ms,3.3
+ 116.9648ms,0.0V 116.9799ms,0.0
+ 116.9800ms,3.3V 116.9847ms,3.3
+ 116.9848ms,0.0V 116.9999ms,0.0
+ 117.0000ms,3.3V 117.0047ms,3.3
+ 117.0048ms,0.0V 117.0199ms,0.0
+ 117.0200ms,3.3V 117.0247ms,3.3
+ 117.0248ms,0.0V 117.0399ms,0.0
+ 117.0400ms,3.3V 117.0447ms,3.3
+ 117.0448ms,0.0V 117.0599ms,0.0
+ 117.0600ms,3.3V 117.0647ms,3.3
+ 117.0648ms,0.0V 117.0799ms,0.0
+ 117.0800ms,3.3V 117.0847ms,3.3
+ 117.0848ms,0.0V 117.0999ms,0.0
+ 117.1000ms,3.3V 117.1047ms,3.3
+ 117.1048ms,0.0V 117.1199ms,0.0
+ 117.1200ms,3.3V 117.1247ms,3.3
+ 117.1248ms,0.0V 117.1399ms,0.0
+ 117.1400ms,3.3V 117.1447ms,3.3
+ 117.1448ms,0.0V 117.1599ms,0.0
+ 117.1600ms,3.3V 117.1647ms,3.3
+ 117.1648ms,0.0V 117.1799ms,0.0
+ 117.1800ms,3.3V 117.1847ms,3.3
+ 117.1848ms,0.0V 117.1999ms,0.0
+ 117.2000ms,3.3V 117.2047ms,3.3
+ 117.2048ms,0.0V 117.2199ms,0.0
+ 117.2200ms,3.3V 117.2247ms,3.3
+ 117.2248ms,0.0V 117.2399ms,0.0
+ 117.2400ms,3.3V 117.2447ms,3.3
+ 117.2448ms,0.0V 117.2599ms,0.0
+ 117.2600ms,3.3V 117.2647ms,3.3
+ 117.2648ms,0.0V 117.2799ms,0.0
+ 117.2800ms,3.3V 117.2847ms,3.3
+ 117.2848ms,0.0V 117.2999ms,0.0
+ 117.3000ms,3.3V 117.3047ms,3.3
+ 117.3048ms,0.0V 117.3199ms,0.0
+ 117.3200ms,3.3V 117.3247ms,3.3
+ 117.3248ms,0.0V 117.3399ms,0.0
+ 117.3400ms,3.3V 117.3447ms,3.3
+ 117.3448ms,0.0V 117.3599ms,0.0
+ 117.3600ms,3.3V 117.3647ms,3.3
+ 117.3648ms,0.0V 117.3799ms,0.0
+ 117.3800ms,3.3V 117.3847ms,3.3
+ 117.3848ms,0.0V 117.3999ms,0.0
+ 117.4000ms,3.3V 117.4047ms,3.3
+ 117.4048ms,0.0V 117.4199ms,0.0
+ 117.4200ms,3.3V 117.4247ms,3.3
+ 117.4248ms,0.0V 117.4399ms,0.0
+ 117.4400ms,3.3V 117.4447ms,3.3
+ 117.4448ms,0.0V 117.4599ms,0.0
+ 117.4600ms,3.3V 117.4647ms,3.3
+ 117.4648ms,0.0V 117.4799ms,0.0
+ 117.4800ms,3.3V 117.4847ms,3.3
+ 117.4848ms,0.0V 117.4999ms,0.0
+ 117.5000ms,3.3V 117.5047ms,3.3
+ 117.5048ms,0.0V 117.5199ms,0.0
+ 117.5200ms,3.3V 117.5247ms,3.3
+ 117.5248ms,0.0V 117.5399ms,0.0
+ 117.5400ms,3.3V 117.5447ms,3.3
+ 117.5448ms,0.0V 117.5599ms,0.0
+ 117.5600ms,3.3V 117.5647ms,3.3
+ 117.5648ms,0.0V 117.5799ms,0.0
+ 117.5800ms,3.3V 117.5847ms,3.3
+ 117.5848ms,0.0V 117.5999ms,0.0
+ 117.6000ms,3.3V 117.6047ms,3.3
+ 117.6048ms,0.0V 117.6199ms,0.0
+ 117.6200ms,3.3V 117.6247ms,3.3
+ 117.6248ms,0.0V 117.6399ms,0.0
+ 117.6400ms,3.3V 117.6447ms,3.3
+ 117.6448ms,0.0V 117.6599ms,0.0
+ 117.6600ms,3.3V 117.6647ms,3.3
+ 117.6648ms,0.0V 117.6799ms,0.0
+ 117.6800ms,3.3V 117.6847ms,3.3
+ 117.6848ms,0.0V 117.6999ms,0.0
+ 117.7000ms,3.3V 117.7047ms,3.3
+ 117.7048ms,0.0V 117.7199ms,0.0
+ 117.7200ms,3.3V 117.7247ms,3.3
+ 117.7248ms,0.0V 117.7399ms,0.0
+ 117.7400ms,3.3V 117.7447ms,3.3
+ 117.7448ms,0.0V 117.7599ms,0.0
+ 117.7600ms,3.3V 117.7647ms,3.3
+ 117.7648ms,0.0V 117.7799ms,0.0
+ 117.7800ms,3.3V 117.7847ms,3.3
+ 117.7848ms,0.0V 117.7999ms,0.0
+ 117.8000ms,3.3V 117.8047ms,3.3
+ 117.8048ms,0.0V 117.8199ms,0.0
+ 117.8200ms,3.3V 117.8247ms,3.3
+ 117.8248ms,0.0V 117.8399ms,0.0
+ 117.8400ms,3.3V 117.8447ms,3.3
+ 117.8448ms,0.0V 117.8599ms,0.0
+ 117.8600ms,3.3V 117.8647ms,3.3
+ 117.8648ms,0.0V 117.8799ms,0.0
+ 117.8800ms,3.3V 117.8847ms,3.3
+ 117.8848ms,0.0V 117.8999ms,0.0
+ 117.9000ms,3.3V 117.9047ms,3.3
+ 117.9048ms,0.0V 117.9199ms,0.0
+ 117.9200ms,3.3V 117.9247ms,3.3
+ 117.9248ms,0.0V 117.9399ms,0.0
+ 117.9400ms,3.3V 117.9447ms,3.3
+ 117.9448ms,0.0V 117.9599ms,0.0
+ 117.9600ms,3.3V 117.9647ms,3.3
+ 117.9648ms,0.0V 117.9799ms,0.0
+ 117.9800ms,3.3V 117.9847ms,3.3
+ 117.9848ms,0.0V 117.9999ms,0.0
+ 118.0000ms,3.3V 118.0047ms,3.3
+ 118.0048ms,0.0V 118.0199ms,0.0
+ 118.0200ms,3.3V 118.0247ms,3.3
+ 118.0248ms,0.0V 118.0399ms,0.0
+ 118.0400ms,3.3V 118.0447ms,3.3
+ 118.0448ms,0.0V 118.0599ms,0.0
+ 118.0600ms,3.3V 118.0647ms,3.3
+ 118.0648ms,0.0V 118.0799ms,0.0
+ 118.0800ms,3.3V 118.0847ms,3.3
+ 118.0848ms,0.0V 118.0999ms,0.0
+ 118.1000ms,3.3V 118.1047ms,3.3
+ 118.1048ms,0.0V 118.1199ms,0.0
+ 118.1200ms,3.3V 118.1247ms,3.3
+ 118.1248ms,0.0V 118.1399ms,0.0
+ 118.1400ms,3.3V 118.1447ms,3.3
+ 118.1448ms,0.0V 118.1599ms,0.0
+ 118.1600ms,3.3V 118.1647ms,3.3
+ 118.1648ms,0.0V 118.1799ms,0.0
+ 118.1800ms,3.3V 118.1847ms,3.3
+ 118.1848ms,0.0V 118.1999ms,0.0
+ 118.2000ms,3.3V 118.2047ms,3.3
+ 118.2048ms,0.0V 118.2199ms,0.0
+ 118.2200ms,3.3V 118.2247ms,3.3
+ 118.2248ms,0.0V 118.2399ms,0.0
+ 118.2400ms,3.3V 118.2447ms,3.3
+ 118.2448ms,0.0V 118.2599ms,0.0
+ 118.2600ms,3.3V 118.2647ms,3.3
+ 118.2648ms,0.0V 118.2799ms,0.0
+ 118.2800ms,3.3V 118.2847ms,3.3
+ 118.2848ms,0.0V 118.2999ms,0.0
+ 118.3000ms,3.3V 118.3047ms,3.3
+ 118.3048ms,0.0V 118.3199ms,0.0
+ 118.3200ms,3.3V 118.3247ms,3.3
+ 118.3248ms,0.0V 118.3399ms,0.0
+ 118.3400ms,3.3V 118.3447ms,3.3
+ 118.3448ms,0.0V 118.3599ms,0.0
+ 118.3600ms,3.3V 118.3647ms,3.3
+ 118.3648ms,0.0V 118.3799ms,0.0
+ 118.3800ms,3.3V 118.3847ms,3.3
+ 118.3848ms,0.0V 118.3999ms,0.0
+ 118.4000ms,3.3V 118.4047ms,3.3
+ 118.4048ms,0.0V 118.4199ms,0.0
+ 118.4200ms,3.3V 118.4247ms,3.3
+ 118.4248ms,0.0V 118.4399ms,0.0
+ 118.4400ms,3.3V 118.4447ms,3.3
+ 118.4448ms,0.0V 118.4599ms,0.0
+ 118.4600ms,3.3V 118.4647ms,3.3
+ 118.4648ms,0.0V 118.4799ms,0.0
+ 118.4800ms,3.3V 118.4847ms,3.3
+ 118.4848ms,0.0V 118.4999ms,0.0
+ 118.5000ms,3.3V 118.5047ms,3.3
+ 118.5048ms,0.0V 118.5199ms,0.0
+ 118.5200ms,3.3V 118.5247ms,3.3
+ 118.5248ms,0.0V 118.5399ms,0.0
+ 118.5400ms,3.3V 118.5447ms,3.3
+ 118.5448ms,0.0V 118.5599ms,0.0
+ 118.5600ms,3.3V 118.5647ms,3.3
+ 118.5648ms,0.0V 118.5799ms,0.0
+ 118.5800ms,3.3V 118.5847ms,3.3
+ 118.5848ms,0.0V 118.5999ms,0.0
+ 118.6000ms,3.3V 118.6047ms,3.3
+ 118.6048ms,0.0V 118.6199ms,0.0
+ 118.6200ms,3.3V 118.6247ms,3.3
+ 118.6248ms,0.0V 118.6399ms,0.0
+ 118.6400ms,3.3V 118.6447ms,3.3
+ 118.6448ms,0.0V 118.6599ms,0.0
+ 118.6600ms,3.3V 118.6647ms,3.3
+ 118.6648ms,0.0V 118.6799ms,0.0
+ 118.6800ms,3.3V 118.6847ms,3.3
+ 118.6848ms,0.0V 118.6999ms,0.0
+ 118.7000ms,3.3V 118.7047ms,3.3
+ 118.7048ms,0.0V 118.7199ms,0.0
+ 118.7200ms,3.3V 118.7247ms,3.3
+ 118.7248ms,0.0V 118.7399ms,0.0
+ 118.7400ms,3.3V 118.7447ms,3.3
+ 118.7448ms,0.0V 118.7599ms,0.0
+ 118.7600ms,3.3V 118.7647ms,3.3
+ 118.7648ms,0.0V 118.7799ms,0.0
+ 118.7800ms,3.3V 118.7847ms,3.3
+ 118.7848ms,0.0V 118.7999ms,0.0
+ 118.8000ms,3.3V 118.8047ms,3.3
+ 118.8048ms,0.0V 118.8199ms,0.0
+ 118.8200ms,3.3V 118.8247ms,3.3
+ 118.8248ms,0.0V 118.8399ms,0.0
+ 118.8400ms,3.3V 118.8447ms,3.3
+ 118.8448ms,0.0V 118.8599ms,0.0
+ 118.8600ms,3.3V 118.8647ms,3.3
+ 118.8648ms,0.0V 118.8799ms,0.0
+ 118.8800ms,3.3V 118.8847ms,3.3
+ 118.8848ms,0.0V 118.8999ms,0.0
+ 118.9000ms,3.3V 118.9047ms,3.3
+ 118.9048ms,0.0V 118.9199ms,0.0
+ 118.9200ms,3.3V 118.9247ms,3.3
+ 118.9248ms,0.0V 118.9399ms,0.0
+ 118.9400ms,3.3V 118.9447ms,3.3
+ 118.9448ms,0.0V 118.9599ms,0.0
+ 118.9600ms,3.3V 118.9647ms,3.3
+ 118.9648ms,0.0V 118.9799ms,0.0
+ 118.9800ms,3.3V 118.9847ms,3.3
+ 118.9848ms,0.0V 118.9999ms,0.0
+ 119.0000ms,3.3V 119.0047ms,3.3
+ 119.0048ms,0.0V 119.0199ms,0.0
+ 119.0200ms,3.3V 119.0247ms,3.3
+ 119.0248ms,0.0V 119.0399ms,0.0
+ 119.0400ms,3.3V 119.0447ms,3.3
+ 119.0448ms,0.0V 119.0599ms,0.0
+ 119.0600ms,3.3V 119.0647ms,3.3
+ 119.0648ms,0.0V 119.0799ms,0.0
+ 119.0800ms,3.3V 119.0847ms,3.3
+ 119.0848ms,0.0V 119.0999ms,0.0
+ 119.1000ms,3.3V 119.1047ms,3.3
+ 119.1048ms,0.0V 119.1199ms,0.0
+ 119.1200ms,3.3V 119.1247ms,3.3
+ 119.1248ms,0.0V 119.1399ms,0.0
+ 119.1400ms,3.3V 119.1447ms,3.3
+ 119.1448ms,0.0V 119.1599ms,0.0
+ 119.1600ms,3.3V 119.1647ms,3.3
+ 119.1648ms,0.0V 119.1799ms,0.0
+ 119.1800ms,3.3V 119.1847ms,3.3
+ 119.1848ms,0.0V 119.1999ms,0.0
+ 119.2000ms,3.3V 119.2047ms,3.3
+ 119.2048ms,0.0V 119.2199ms,0.0
+ 119.2200ms,3.3V 119.2247ms,3.3
+ 119.2248ms,0.0V 119.2399ms,0.0
+ 119.2400ms,3.3V 119.2447ms,3.3
+ 119.2448ms,0.0V 119.2599ms,0.0
+ 119.2600ms,3.3V 119.2647ms,3.3
+ 119.2648ms,0.0V 119.2799ms,0.0
+ 119.2800ms,3.3V 119.2847ms,3.3
+ 119.2848ms,0.0V 119.2999ms,0.0
+ 119.3000ms,3.3V 119.3047ms,3.3
+ 119.3048ms,0.0V 119.3199ms,0.0
+ 119.3200ms,3.3V 119.3247ms,3.3
+ 119.3248ms,0.0V 119.3399ms,0.0
+ 119.3400ms,3.3V 119.3447ms,3.3
+ 119.3448ms,0.0V 119.3599ms,0.0
+ 119.3600ms,3.3V 119.3647ms,3.3
+ 119.3648ms,0.0V 119.3799ms,0.0
+ 119.3800ms,3.3V 119.3847ms,3.3
+ 119.3848ms,0.0V 119.3999ms,0.0
+ 119.4000ms,3.3V 119.4047ms,3.3
+ 119.4048ms,0.0V 119.4199ms,0.0
+ 119.4200ms,3.3V 119.4247ms,3.3
+ 119.4248ms,0.0V 119.4399ms,0.0
+ 119.4400ms,3.3V 119.4447ms,3.3
+ 119.4448ms,0.0V 119.4599ms,0.0
+ 119.4600ms,3.3V 119.4647ms,3.3
+ 119.4648ms,0.0V 119.4799ms,0.0
+ 119.4800ms,3.3V 119.4847ms,3.3
+ 119.4848ms,0.0V 119.4999ms,0.0
+ 119.5000ms,3.3V 119.5047ms,3.3
+ 119.5048ms,0.0V 119.5199ms,0.0
+ 119.5200ms,3.3V 119.5247ms,3.3
+ 119.5248ms,0.0V 119.5399ms,0.0
+ 119.5400ms,3.3V 119.5447ms,3.3
+ 119.5448ms,0.0V 119.5599ms,0.0
+ 119.5600ms,3.3V 119.5647ms,3.3
+ 119.5648ms,0.0V 119.5799ms,0.0
+ 119.5800ms,3.3V 119.5847ms,3.3
+ 119.5848ms,0.0V 119.5999ms,0.0
+ 119.6000ms,3.3V 119.6047ms,3.3
+ 119.6048ms,0.0V 119.6199ms,0.0
+ 119.6200ms,3.3V 119.6247ms,3.3
+ 119.6248ms,0.0V 119.6399ms,0.0
+ 119.6400ms,3.3V 119.6447ms,3.3
+ 119.6448ms,0.0V 119.6599ms,0.0
+ 119.6600ms,3.3V 119.6647ms,3.3
+ 119.6648ms,0.0V 119.6799ms,0.0
+ 119.6800ms,3.3V 119.6847ms,3.3
+ 119.6848ms,0.0V 119.6999ms,0.0
+ 119.7000ms,3.3V 119.7047ms,3.3
+ 119.7048ms,0.0V 119.7199ms,0.0
+ 119.7200ms,3.3V 119.7247ms,3.3
+ 119.7248ms,0.0V 119.7399ms,0.0
+ 119.7400ms,3.3V 119.7447ms,3.3
+ 119.7448ms,0.0V 119.7599ms,0.0
+ 119.7600ms,3.3V 119.7647ms,3.3
+ 119.7648ms,0.0V 119.7799ms,0.0
+ 119.7800ms,3.3V 119.7847ms,3.3
+ 119.7848ms,0.0V 119.7999ms,0.0
+ 119.8000ms,3.3V 119.8047ms,3.3
+ 119.8048ms,0.0V 119.8199ms,0.0
+ 119.8200ms,3.3V 119.8247ms,3.3
+ 119.8248ms,0.0V 119.8399ms,0.0
+ 119.8400ms,3.3V 119.8447ms,3.3
+ 119.8448ms,0.0V 119.8599ms,0.0
+ 119.8600ms,3.3V 119.8647ms,3.3
+ 119.8648ms,0.0V 119.8799ms,0.0
+ 119.8800ms,3.3V 119.8847ms,3.3
+ 119.8848ms,0.0V 119.8999ms,0.0
+ 119.9000ms,3.3V 119.9047ms,3.3
+ 119.9048ms,0.0V 119.9199ms,0.0
+ 119.9200ms,3.3V 119.9247ms,3.3
+ 119.9248ms,0.0V 119.9399ms,0.0
+ 119.9400ms,3.3V 119.9447ms,3.3
+ 119.9448ms,0.0V 119.9599ms,0.0
+ 119.9600ms,3.3V 119.9647ms,3.3
+ 119.9648ms,0.0V 119.9799ms,0.0
+ 119.9800ms,3.3V 119.9847ms,3.3
+ 119.9848ms,0.0V 119.9999ms,0.0
+ 120.0000ms,3.3V 120.0047ms,3.3
+ 120.0048ms,0.0V 120.0199ms,0.0
+ 120.0200ms,3.3V 120.0247ms,3.3
+ 120.0248ms,0.0V 120.0399ms,0.0
+ 120.0400ms,3.3V 120.0447ms,3.3
+ 120.0448ms,0.0V 120.0599ms,0.0
+ 120.0600ms,3.3V 120.0647ms,3.3
+ 120.0648ms,0.0V 120.0799ms,0.0
+ 120.0800ms,3.3V 120.0847ms,3.3
+ 120.0848ms,0.0V 120.0999ms,0.0
+ 120.1000ms,3.3V 120.1047ms,3.3
+ 120.1048ms,0.0V 120.1199ms,0.0
+ 120.1200ms,3.3V 120.1247ms,3.3
+ 120.1248ms,0.0V 120.1399ms,0.0
+ 120.1400ms,3.3V 120.1447ms,3.3
+ 120.1448ms,0.0V 120.1599ms,0.0
+ 120.1600ms,3.3V 120.1647ms,3.3
+ 120.1648ms,0.0V 120.1799ms,0.0
+ 120.1800ms,3.3V 120.1847ms,3.3
+ 120.1848ms,0.0V 120.1999ms,0.0
+ 120.2000ms,3.3V 120.2047ms,3.3
+ 120.2048ms,0.0V 120.2199ms,0.0
+ 120.2200ms,3.3V 120.2247ms,3.3
+ 120.2248ms,0.0V 120.2399ms,0.0
+ 120.2400ms,3.3V 120.2447ms,3.3
+ 120.2448ms,0.0V 120.2599ms,0.0
+ 120.2600ms,3.3V 120.2647ms,3.3
+ 120.2648ms,0.0V 120.2799ms,0.0
+ 120.2800ms,3.3V 120.2847ms,3.3
+ 120.2848ms,0.0V 120.2999ms,0.0
+ 120.3000ms,3.3V 120.3047ms,3.3
+ 120.3048ms,0.0V 120.3199ms,0.0
+ 120.3200ms,3.3V 120.3247ms,3.3
+ 120.3248ms,0.0V 120.3399ms,0.0
+ 120.3400ms,3.3V 120.3449ms,3.3
+ 120.3450ms,0.0V 120.3599ms,0.0
+ 120.3600ms,3.3V 120.3649ms,3.3
+ 120.3650ms,0.0V 120.3799ms,0.0
+ 120.3800ms,3.3V 120.3849ms,3.3
+ 120.3850ms,0.0V 120.3999ms,0.0
+ 120.4000ms,3.3V 120.4049ms,3.3
+ 120.4050ms,0.0V 120.4199ms,0.0
+ 120.4200ms,3.3V 120.4249ms,3.3
+ 120.4250ms,0.0V 120.4399ms,0.0
+ 120.4400ms,3.3V 120.4449ms,3.3
+ 120.4450ms,0.0V 120.4599ms,0.0
+ 120.4600ms,3.3V 120.4649ms,3.3
+ 120.4650ms,0.0V 120.4799ms,0.0
+ 120.4800ms,3.3V 120.4849ms,3.3
+ 120.4850ms,0.0V 120.4999ms,0.0
+ 120.5000ms,3.3V 120.5049ms,3.3
+ 120.5050ms,0.0V 120.5199ms,0.0
+ 120.5200ms,3.3V 120.5249ms,3.3
+ 120.5250ms,0.0V 120.5399ms,0.0
+ 120.5400ms,3.3V 120.5449ms,3.3
+ 120.5450ms,0.0V 120.5599ms,0.0
+ 120.5600ms,3.3V 120.5649ms,3.3
+ 120.5650ms,0.0V 120.5799ms,0.0
+ 120.5800ms,3.3V 120.5849ms,3.3
+ 120.5850ms,0.0V 120.5999ms,0.0
+ 120.6000ms,3.3V 120.6049ms,3.3
+ 120.6050ms,0.0V 120.6199ms,0.0
+ 120.6200ms,3.3V 120.6249ms,3.3
+ 120.6250ms,0.0V 120.6399ms,0.0
+ 120.6400ms,3.3V 120.6449ms,3.3
+ 120.6450ms,0.0V 120.6599ms,0.0
+ 120.6600ms,3.3V 120.6649ms,3.3
+ 120.6650ms,0.0V 120.6799ms,0.0
+ 120.6800ms,3.3V 120.6849ms,3.3
+ 120.6850ms,0.0V 120.6999ms,0.0
+ 120.7000ms,3.3V 120.7049ms,3.3
+ 120.7050ms,0.0V 120.7199ms,0.0
+ 120.7200ms,3.3V 120.7249ms,3.3
+ 120.7250ms,0.0V 120.7399ms,0.0
+ 120.7400ms,3.3V 120.7449ms,3.3
+ 120.7450ms,0.0V 120.7599ms,0.0
+ 120.7600ms,3.3V 120.7649ms,3.3
+ 120.7650ms,0.0V 120.7799ms,0.0
+ 120.7800ms,3.3V 120.7849ms,3.3
+ 120.7850ms,0.0V 120.7999ms,0.0
+ 120.8000ms,3.3V 120.8049ms,3.3
+ 120.8050ms,0.0V 120.8199ms,0.0
+ 120.8200ms,3.3V 120.8249ms,3.3
+ 120.8250ms,0.0V 120.8399ms,0.0
+ 120.8400ms,3.3V 120.8449ms,3.3
+ 120.8450ms,0.0V 120.8599ms,0.0
+ 120.8600ms,3.3V 120.8649ms,3.3
+ 120.8650ms,0.0V 120.8799ms,0.0
+ 120.8800ms,3.3V 120.8849ms,3.3
+ 120.8850ms,0.0V 120.8999ms,0.0
+ 120.9000ms,3.3V 120.9049ms,3.3
+ 120.9050ms,0.0V 120.9199ms,0.0
+ 120.9200ms,3.3V 120.9249ms,3.3
+ 120.9250ms,0.0V 120.9399ms,0.0
+ 120.9400ms,3.3V 120.9449ms,3.3
+ 120.9450ms,0.0V 120.9599ms,0.0
+ 120.9600ms,3.3V 120.9649ms,3.3
+ 120.9650ms,0.0V 120.9799ms,0.0
+ 120.9800ms,3.3V 120.9849ms,3.3
+ 120.9850ms,0.0V 120.9999ms,0.0
+ 121.0000ms,3.3V 121.0049ms,3.3
+ 121.0050ms,0.0V 121.0199ms,0.0
+ 121.0200ms,3.3V 121.0249ms,3.3
+ 121.0250ms,0.0V 121.0399ms,0.0
+ 121.0400ms,3.3V 121.0449ms,3.3
+ 121.0450ms,0.0V 121.0599ms,0.0
+ 121.0600ms,3.3V 121.0649ms,3.3
+ 121.0650ms,0.0V 121.0799ms,0.0
+ 121.0800ms,3.3V 121.0849ms,3.3
+ 121.0850ms,0.0V 121.0999ms,0.0
+ 121.1000ms,3.3V 121.1049ms,3.3
+ 121.1050ms,0.0V 121.1199ms,0.0
+ 121.1200ms,3.3V 121.1249ms,3.3
+ 121.1250ms,0.0V 121.1399ms,0.0
+ 121.1400ms,3.3V 121.1449ms,3.3
+ 121.1450ms,0.0V 121.1599ms,0.0
+ 121.1600ms,3.3V 121.1649ms,3.3
+ 121.1650ms,0.0V 121.1799ms,0.0
+ 121.1800ms,3.3V 121.1849ms,3.3
+ 121.1850ms,0.0V 121.1999ms,0.0
+ 121.2000ms,3.3V 121.2049ms,3.3
+ 121.2050ms,0.0V 121.2199ms,0.0
+ 121.2200ms,3.3V 121.2249ms,3.3
+ 121.2250ms,0.0V 121.2399ms,0.0
+ 121.2400ms,3.3V 121.2449ms,3.3
+ 121.2450ms,0.0V 121.2599ms,0.0
+ 121.2600ms,3.3V 121.2649ms,3.3
+ 121.2650ms,0.0V 121.2799ms,0.0
+ 121.2800ms,3.3V 121.2849ms,3.3
+ 121.2850ms,0.0V 121.2999ms,0.0
+ 121.3000ms,3.3V 121.3049ms,3.3
+ 121.3050ms,0.0V 121.3199ms,0.0
+ 121.3200ms,3.3V 121.3249ms,3.3
+ 121.3250ms,0.0V 121.3399ms,0.0
+ 121.3400ms,3.3V 121.3449ms,3.3
+ 121.3450ms,0.0V 121.3599ms,0.0
+ 121.3600ms,3.3V 121.3649ms,3.3
+ 121.3650ms,0.0V 121.3799ms,0.0
+ 121.3800ms,3.3V 121.3849ms,3.3
+ 121.3850ms,0.0V 121.3999ms,0.0
+ 121.4000ms,3.3V 121.4049ms,3.3
+ 121.4050ms,0.0V 121.4199ms,0.0
+ 121.4200ms,3.3V 121.4249ms,3.3
+ 121.4250ms,0.0V 121.4399ms,0.0
+ 121.4400ms,3.3V 121.4449ms,3.3
+ 121.4450ms,0.0V 121.4599ms,0.0
+ 121.4600ms,3.3V 121.4649ms,3.3
+ 121.4650ms,0.0V 121.4799ms,0.0
+ 121.4800ms,3.3V 121.4849ms,3.3
+ 121.4850ms,0.0V 121.4999ms,0.0
+ 121.5000ms,3.3V 121.5049ms,3.3
+ 121.5050ms,0.0V 121.5199ms,0.0
+ 121.5200ms,3.3V 121.5249ms,3.3
+ 121.5250ms,0.0V 121.5399ms,0.0
+ 121.5400ms,3.3V 121.5449ms,3.3
+ 121.5450ms,0.0V 121.5599ms,0.0
+ 121.5600ms,3.3V 121.5649ms,3.3
+ 121.5650ms,0.0V 121.5799ms,0.0
+ 121.5800ms,3.3V 121.5849ms,3.3
+ 121.5850ms,0.0V 121.5999ms,0.0
+ 121.6000ms,3.3V 121.6049ms,3.3
+ 121.6050ms,0.0V 121.6199ms,0.0
+ 121.6200ms,3.3V 121.6249ms,3.3
+ 121.6250ms,0.0V 121.6399ms,0.0
+ 121.6400ms,3.3V 121.6449ms,3.3
+ 121.6450ms,0.0V 121.6599ms,0.0
+ 121.6600ms,3.3V 121.6649ms,3.3
+ 121.6650ms,0.0V 121.6799ms,0.0
+ 121.6800ms,3.3V 121.6849ms,3.3
+ 121.6850ms,0.0V 121.6999ms,0.0
+ 121.7000ms,3.3V 121.7049ms,3.3
+ 121.7050ms,0.0V 121.7199ms,0.0
+ 121.7200ms,3.3V 121.7249ms,3.3
+ 121.7250ms,0.0V 121.7399ms,0.0
+ 121.7400ms,3.3V 121.7449ms,3.3
+ 121.7450ms,0.0V 121.7599ms,0.0
+ 121.7600ms,3.3V 121.7649ms,3.3
+ 121.7650ms,0.0V 121.7799ms,0.0
+ 121.7800ms,3.3V 121.7849ms,3.3
+ 121.7850ms,0.0V 121.7999ms,0.0
+ 121.8000ms,3.3V 121.8049ms,3.3
+ 121.8050ms,0.0V 121.8199ms,0.0
+ 121.8200ms,3.3V 121.8249ms,3.3
+ 121.8250ms,0.0V 121.8399ms,0.0
+ 121.8400ms,3.3V 121.8449ms,3.3
+ 121.8450ms,0.0V 121.8599ms,0.0
+ 121.8600ms,3.3V 121.8649ms,3.3
+ 121.8650ms,0.0V 121.8799ms,0.0
+ 121.8800ms,3.3V 121.8849ms,3.3
+ 121.8850ms,0.0V 121.8999ms,0.0
+ 121.9000ms,3.3V 121.9049ms,3.3
+ 121.9050ms,0.0V 121.9199ms,0.0
+ 121.9200ms,3.3V 121.9249ms,3.3
+ 121.9250ms,0.0V 121.9399ms,0.0
+ 121.9400ms,3.3V 121.9449ms,3.3
+ 121.9450ms,0.0V 121.9599ms,0.0
+ 121.9600ms,3.3V 121.9649ms,3.3
+ 121.9650ms,0.0V 121.9799ms,0.0
+ 121.9800ms,3.3V 121.9849ms,3.3
+ 121.9850ms,0.0V 121.9999ms,0.0
+ 122.0000ms,3.3V 122.0049ms,3.3
+ 122.0050ms,0.0V 122.0199ms,0.0
+ 122.0200ms,3.3V 122.0249ms,3.3
+ 122.0250ms,0.0V 122.0399ms,0.0
+ 122.0400ms,3.3V 122.0449ms,3.3
+ 122.0450ms,0.0V 122.0599ms,0.0
+ 122.0600ms,3.3V 122.0649ms,3.3
+ 122.0650ms,0.0V 122.0799ms,0.0
+ 122.0800ms,3.3V 122.0849ms,3.3
+ 122.0850ms,0.0V 122.0999ms,0.0
+ 122.1000ms,3.3V 122.1049ms,3.3
+ 122.1050ms,0.0V 122.1199ms,0.0
+ 122.1200ms,3.3V 122.1249ms,3.3
+ 122.1250ms,0.0V 122.1399ms,0.0
+ 122.1400ms,3.3V 122.1449ms,3.3
+ 122.1450ms,0.0V 122.1599ms,0.0
+ 122.1600ms,3.3V 122.1649ms,3.3
+ 122.1650ms,0.0V 122.1799ms,0.0
+ 122.1800ms,3.3V 122.1849ms,3.3
+ 122.1850ms,0.0V 122.1999ms,0.0
+ 122.2000ms,3.3V 122.2049ms,3.3
+ 122.2050ms,0.0V 122.2199ms,0.0
+ 122.2200ms,3.3V 122.2249ms,3.3
+ 122.2250ms,0.0V 122.2399ms,0.0
+ 122.2400ms,3.3V 122.2449ms,3.3
+ 122.2450ms,0.0V 122.2599ms,0.0
+ 122.2600ms,3.3V 122.2649ms,3.3
+ 122.2650ms,0.0V 122.2799ms,0.0
+ 122.2800ms,3.3V 122.2849ms,3.3
+ 122.2850ms,0.0V 122.2999ms,0.0
+ 122.3000ms,3.3V 122.3049ms,3.3
+ 122.3050ms,0.0V 122.3199ms,0.0
+ 122.3200ms,3.3V 122.3249ms,3.3
+ 122.3250ms,0.0V 122.3399ms,0.0
+ 122.3400ms,3.3V 122.3449ms,3.3
+ 122.3450ms,0.0V 122.3599ms,0.0
+ 122.3600ms,3.3V 122.3649ms,3.3
+ 122.3650ms,0.0V 122.3799ms,0.0
+ 122.3800ms,3.3V 122.3849ms,3.3
+ 122.3850ms,0.0V 122.3999ms,0.0
+ 122.4000ms,3.3V 122.4049ms,3.3
+ 122.4050ms,0.0V 122.4199ms,0.0
+ 122.4200ms,3.3V 122.4249ms,3.3
+ 122.4250ms,0.0V 122.4399ms,0.0
+ 122.4400ms,3.3V 122.4449ms,3.3
+ 122.4450ms,0.0V 122.4599ms,0.0
+ 122.4600ms,3.3V 122.4649ms,3.3
+ 122.4650ms,0.0V 122.4799ms,0.0
+ 122.4800ms,3.3V 122.4849ms,3.3
+ 122.4850ms,0.0V 122.4999ms,0.0
+ 122.5000ms,3.3V 122.5049ms,3.3
+ 122.5050ms,0.0V 122.5199ms,0.0
+ 122.5200ms,3.3V 122.5249ms,3.3
+ 122.5250ms,0.0V 122.5399ms,0.0
+ 122.5400ms,3.3V 122.5449ms,3.3
+ 122.5450ms,0.0V 122.5599ms,0.0
+ 122.5600ms,3.3V 122.5649ms,3.3
+ 122.5650ms,0.0V 122.5799ms,0.0
+ 122.5800ms,3.3V 122.5849ms,3.3
+ 122.5850ms,0.0V 122.5999ms,0.0
+ 122.6000ms,3.3V 122.6049ms,3.3
+ 122.6050ms,0.0V 122.6199ms,0.0
+ 122.6200ms,3.3V 122.6249ms,3.3
+ 122.6250ms,0.0V 122.6399ms,0.0
+ 122.6400ms,3.3V 122.6449ms,3.3
+ 122.6450ms,0.0V 122.6599ms,0.0
+ 122.6600ms,3.3V 122.6649ms,3.3
+ 122.6650ms,0.0V 122.6799ms,0.0
+ 122.6800ms,3.3V 122.6849ms,3.3
+ 122.6850ms,0.0V 122.6999ms,0.0
+ 122.7000ms,3.3V 122.7049ms,3.3
+ 122.7050ms,0.0V 122.7199ms,0.0
+ 122.7200ms,3.3V 122.7249ms,3.3
+ 122.7250ms,0.0V 122.7399ms,0.0
+ 122.7400ms,3.3V 122.7449ms,3.3
+ 122.7450ms,0.0V 122.7599ms,0.0
+ 122.7600ms,3.3V 122.7649ms,3.3
+ 122.7650ms,0.0V 122.7799ms,0.0
+ 122.7800ms,3.3V 122.7849ms,3.3
+ 122.7850ms,0.0V 122.7999ms,0.0
+ 122.8000ms,3.3V 122.8049ms,3.3
+ 122.8050ms,0.0V 122.8199ms,0.0
+ 122.8200ms,3.3V 122.8249ms,3.3
+ 122.8250ms,0.0V 122.8399ms,0.0
+ 122.8400ms,3.3V 122.8449ms,3.3
+ 122.8450ms,0.0V 122.8599ms,0.0
+ 122.8600ms,3.3V 122.8649ms,3.3
+ 122.8650ms,0.0V 122.8799ms,0.0
+ 122.8800ms,3.3V 122.8849ms,3.3
+ 122.8850ms,0.0V 122.8999ms,0.0
+ 122.9000ms,3.3V 122.9049ms,3.3
+ 122.9050ms,0.0V 122.9199ms,0.0
+ 122.9200ms,3.3V 122.9249ms,3.3
+ 122.9250ms,0.0V 122.9399ms,0.0
+ 122.9400ms,3.3V 122.9449ms,3.3
+ 122.9450ms,0.0V 122.9599ms,0.0
+ 122.9600ms,3.3V 122.9649ms,3.3
+ 122.9650ms,0.0V 122.9799ms,0.0
+ 122.9800ms,3.3V 122.9849ms,3.3
+ 122.9850ms,0.0V 122.9999ms,0.0
+ 123.0000ms,3.3V 123.0049ms,3.3
+ 123.0050ms,0.0V 123.0199ms,0.0
+ 123.0200ms,3.3V 123.0249ms,3.3
+ 123.0250ms,0.0V 123.0399ms,0.0
+ 123.0400ms,3.3V 123.0449ms,3.3
+ 123.0450ms,0.0V 123.0599ms,0.0
+ 123.0600ms,3.3V 123.0649ms,3.3
+ 123.0650ms,0.0V 123.0799ms,0.0
+ 123.0800ms,3.3V 123.0849ms,3.3
+ 123.0850ms,0.0V 123.0999ms,0.0
+ 123.1000ms,3.3V 123.1049ms,3.3
+ 123.1050ms,0.0V 123.1199ms,0.0
+ 123.1200ms,3.3V 123.1249ms,3.3
+ 123.1250ms,0.0V 123.1399ms,0.0
+ 123.1400ms,3.3V 123.1449ms,3.3
+ 123.1450ms,0.0V 123.1599ms,0.0
+ 123.1600ms,3.3V 123.1649ms,3.3
+ 123.1650ms,0.0V 123.1799ms,0.0
+ 123.1800ms,3.3V 123.1849ms,3.3
+ 123.1850ms,0.0V 123.1999ms,0.0
+ 123.2000ms,3.3V 123.2049ms,3.3
+ 123.2050ms,0.0V 123.2199ms,0.0
+ 123.2200ms,3.3V 123.2249ms,3.3
+ 123.2250ms,0.0V 123.2399ms,0.0
+ 123.2400ms,3.3V 123.2449ms,3.3
+ 123.2450ms,0.0V 123.2599ms,0.0
+ 123.2600ms,3.3V 123.2649ms,3.3
+ 123.2650ms,0.0V 123.2799ms,0.0
+ 123.2800ms,3.3V 123.2849ms,3.3
+ 123.2850ms,0.0V 123.2999ms,0.0
+ 123.3000ms,3.3V 123.3049ms,3.3
+ 123.3050ms,0.0V 123.3199ms,0.0
+ 123.3200ms,3.3V 123.3249ms,3.3
+ 123.3250ms,0.0V 123.3399ms,0.0
+ 123.3400ms,3.3V 123.3449ms,3.3
+ 123.3450ms,0.0V 123.3599ms,0.0
+ 123.3600ms,3.3V 123.3649ms,3.3
+ 123.3650ms,0.0V 123.3799ms,0.0
+ 123.3800ms,3.3V 123.3849ms,3.3
+ 123.3850ms,0.0V 123.3999ms,0.0
+ 123.4000ms,3.3V 123.4049ms,3.3
+ 123.4050ms,0.0V 123.4199ms,0.0
+ 123.4200ms,3.3V 123.4249ms,3.3
+ 123.4250ms,0.0V 123.4399ms,0.0
+ 123.4400ms,3.3V 123.4449ms,3.3
+ 123.4450ms,0.0V 123.4599ms,0.0
+ 123.4600ms,3.3V 123.4649ms,3.3
+ 123.4650ms,0.0V 123.4799ms,0.0
+ 123.4800ms,3.3V 123.4849ms,3.3
+ 123.4850ms,0.0V 123.4999ms,0.0
+ 123.5000ms,3.3V 123.5049ms,3.3
+ 123.5050ms,0.0V 123.5199ms,0.0
+ 123.5200ms,3.3V 123.5249ms,3.3
+ 123.5250ms,0.0V 123.5399ms,0.0
+ 123.5400ms,3.3V 123.5449ms,3.3
+ 123.5450ms,0.0V 123.5599ms,0.0
+ 123.5600ms,3.3V 123.5649ms,3.3
+ 123.5650ms,0.0V 123.5799ms,0.0
+ 123.5800ms,3.3V 123.5849ms,3.3
+ 123.5850ms,0.0V 123.5999ms,0.0
+ 123.6000ms,3.3V 123.6049ms,3.3
+ 123.6050ms,0.0V 123.6199ms,0.0
+ 123.6200ms,3.3V 123.6249ms,3.3
+ 123.6250ms,0.0V 123.6399ms,0.0
+ 123.6400ms,3.3V 123.6449ms,3.3
+ 123.6450ms,0.0V 123.6599ms,0.0
+ 123.6600ms,3.3V 123.6649ms,3.3
+ 123.6650ms,0.0V 123.6799ms,0.0
+ 123.6800ms,3.3V 123.6849ms,3.3
+ 123.6850ms,0.0V 123.6999ms,0.0
+ 123.7000ms,3.3V 123.7049ms,3.3
+ 123.7050ms,0.0V 123.7199ms,0.0
+ 123.7200ms,3.3V 123.7249ms,3.3
+ 123.7250ms,0.0V 123.7399ms,0.0
+ 123.7400ms,3.3V 123.7449ms,3.3
+ 123.7450ms,0.0V 123.7599ms,0.0
+ 123.7600ms,3.3V 123.7649ms,3.3
+ 123.7650ms,0.0V 123.7799ms,0.0
+ 123.7800ms,3.3V 123.7849ms,3.3
+ 123.7850ms,0.0V 123.7999ms,0.0
+ 123.8000ms,3.3V 123.8049ms,3.3
+ 123.8050ms,0.0V 123.8199ms,0.0
+ 123.8200ms,3.3V 123.8249ms,3.3
+ 123.8250ms,0.0V 123.8399ms,0.0
+ 123.8400ms,3.3V 123.8449ms,3.3
+ 123.8450ms,0.0V 123.8599ms,0.0
+ 123.8600ms,3.3V 123.8649ms,3.3
+ 123.8650ms,0.0V 123.8799ms,0.0
+ 123.8800ms,3.3V 123.8849ms,3.3
+ 123.8850ms,0.0V 123.8999ms,0.0
+ 123.9000ms,3.3V 123.9049ms,3.3
+ 123.9050ms,0.0V 123.9199ms,0.0
+ 123.9200ms,3.3V 123.9249ms,3.3
+ 123.9250ms,0.0V 123.9399ms,0.0
+ 123.9400ms,3.3V 123.9449ms,3.3
+ 123.9450ms,0.0V 123.9599ms,0.0
+ 123.9600ms,3.3V 123.9649ms,3.3
+ 123.9650ms,0.0V 123.9799ms,0.0
+ 123.9800ms,3.3V 123.9849ms,3.3
+ 123.9850ms,0.0V 123.9999ms,0.0
+ 124.0000ms,3.3V 124.0049ms,3.3
+ 124.0050ms,0.0V 124.0199ms,0.0
+ 124.0200ms,3.3V 124.0249ms,3.3
+ 124.0250ms,0.0V 124.0399ms,0.0
+ 124.0400ms,3.3V 124.0449ms,3.3
+ 124.0450ms,0.0V 124.0599ms,0.0
+ 124.0600ms,3.3V 124.0649ms,3.3
+ 124.0650ms,0.0V 124.0799ms,0.0
+ 124.0800ms,3.3V 124.0849ms,3.3
+ 124.0850ms,0.0V 124.0999ms,0.0
+ 124.1000ms,3.3V 124.1049ms,3.3
+ 124.1050ms,0.0V 124.1199ms,0.0
+ 124.1200ms,3.3V 124.1249ms,3.3
+ 124.1250ms,0.0V 124.1399ms,0.0
+ 124.1400ms,3.3V 124.1449ms,3.3
+ 124.1450ms,0.0V 124.1599ms,0.0
+ 124.1600ms,3.3V 124.1649ms,3.3
+ 124.1650ms,0.0V 124.1799ms,0.0
+ 124.1800ms,3.3V 124.1849ms,3.3
+ 124.1850ms,0.0V 124.1999ms,0.0
+ 124.2000ms,3.3V 124.2049ms,3.3
+ 124.2050ms,0.0V 124.2199ms,0.0
+ 124.2200ms,3.3V 124.2249ms,3.3
+ 124.2250ms,0.0V 124.2399ms,0.0
+ 124.2400ms,3.3V 124.2449ms,3.3
+ 124.2450ms,0.0V 124.2599ms,0.0
+ 124.2600ms,3.3V 124.2649ms,3.3
+ 124.2650ms,0.0V 124.2799ms,0.0
+ 124.2800ms,3.3V 124.2849ms,3.3
+ 124.2850ms,0.0V 124.2999ms,0.0
+ 124.3000ms,3.3V 124.3049ms,3.3
+ 124.3050ms,0.0V 124.3199ms,0.0
+ 124.3200ms,3.3V 124.3249ms,3.3
+ 124.3250ms,0.0V 124.3399ms,0.0
+ 124.3400ms,3.3V 124.3449ms,3.3
+ 124.3450ms,0.0V 124.3599ms,0.0
+ 124.3600ms,3.3V 124.3649ms,3.3
+ 124.3650ms,0.0V 124.3799ms,0.0
+ 124.3800ms,3.3V 124.3849ms,3.3
+ 124.3850ms,0.0V 124.3999ms,0.0
+ 124.4000ms,3.3V 124.4049ms,3.3
+ 124.4050ms,0.0V 124.4199ms,0.0
+ 124.4200ms,3.3V 124.4249ms,3.3
+ 124.4250ms,0.0V 124.4399ms,0.0
+ 124.4400ms,3.3V 124.4449ms,3.3
+ 124.4450ms,0.0V 124.4599ms,0.0
+ 124.4600ms,3.3V 124.4649ms,3.3
+ 124.4650ms,0.0V 124.4799ms,0.0
+ 124.4800ms,3.3V 124.4849ms,3.3
+ 124.4850ms,0.0V 124.4999ms,0.0
+ 124.5000ms,3.3V 124.5049ms,3.3
+ 124.5050ms,0.0V 124.5199ms,0.0
+ 124.5200ms,3.3V 124.5249ms,3.3
+ 124.5250ms,0.0V 124.5399ms,0.0
+ 124.5400ms,3.3V 124.5449ms,3.3
+ 124.5450ms,0.0V 124.5599ms,0.0
+ 124.5600ms,3.3V 124.5649ms,3.3
+ 124.5650ms,0.0V 124.5799ms,0.0
+ 124.5800ms,3.3V 124.5849ms,3.3
+ 124.5850ms,0.0V 124.5999ms,0.0
+ 124.6000ms,3.3V 124.6049ms,3.3
+ 124.6050ms,0.0V 124.6199ms,0.0
+ 124.6200ms,3.3V 124.6249ms,3.3
+ 124.6250ms,0.0V 124.6399ms,0.0
+ 124.6400ms,3.3V 124.6449ms,3.3
+ 124.6450ms,0.0V 124.6599ms,0.0
+ 124.6600ms,3.3V 124.6649ms,3.3
+ 124.6650ms,0.0V 124.6799ms,0.0
+ 124.6800ms,3.3V 124.6849ms,3.3
+ 124.6850ms,0.0V 124.6999ms,0.0
+ 124.7000ms,3.3V 124.7049ms,3.3
+ 124.7050ms,0.0V 124.7199ms,0.0
+ 124.7200ms,3.3V 124.7249ms,3.3
+ 124.7250ms,0.0V 124.7399ms,0.0
+ 124.7400ms,3.3V 124.7449ms,3.3
+ 124.7450ms,0.0V 124.7599ms,0.0
+ 124.7600ms,3.3V 124.7649ms,3.3
+ 124.7650ms,0.0V 124.7799ms,0.0
+ 124.7800ms,3.3V 124.7849ms,3.3
+ 124.7850ms,0.0V 124.7999ms,0.0
+ 124.8000ms,3.3V 124.8049ms,3.3
+ 124.8050ms,0.0V 124.8199ms,0.0
+ 124.8200ms,3.3V 124.8249ms,3.3
+ 124.8250ms,0.0V 124.8399ms,0.0
+ 124.8400ms,3.3V 124.8449ms,3.3
+ 124.8450ms,0.0V 124.8599ms,0.0
+ 124.8600ms,3.3V 124.8649ms,3.3
+ 124.8650ms,0.0V 124.8799ms,0.0
+ 124.8800ms,3.3V 124.8849ms,3.3
+ 124.8850ms,0.0V 124.8999ms,0.0
+ 124.9000ms,3.3V 124.9049ms,3.3
+ 124.9050ms,0.0V 124.9199ms,0.0
+ 124.9200ms,3.3V 124.9249ms,3.3
+ 124.9250ms,0.0V 124.9399ms,0.0
+ 124.9400ms,3.3V 124.9449ms,3.3
+ 124.9450ms,0.0V 124.9599ms,0.0
+ 124.9600ms,3.3V 124.9649ms,3.3
+ 124.9650ms,0.0V 124.9799ms,0.0
+ 124.9800ms,3.3V 124.9849ms,3.3
+ 124.9850ms,0.0V 124.9999ms,0.0
+ 125.0000ms,3.3V 125.0049ms,3.3
+ 125.0050ms,0.0V 125.0199ms,0.0
+ 125.0200ms,3.3V 125.0249ms,3.3
+ 125.0250ms,0.0V 125.0399ms,0.0
+ 125.0400ms,3.3V 125.0449ms,3.3
+ 125.0450ms,0.0V 125.0599ms,0.0
+ 125.0600ms,3.3V 125.0649ms,3.3
+ 125.0650ms,0.0V 125.0799ms,0.0
+ 125.0800ms,3.3V 125.0849ms,3.3
+ 125.0850ms,0.0V 125.0999ms,0.0
+ 125.1000ms,3.3V 125.1049ms,3.3
+ 125.1050ms,0.0V 125.1199ms,0.0
+ 125.1200ms,3.3V 125.1249ms,3.3
+ 125.1250ms,0.0V 125.1399ms,0.0
+ 125.1400ms,3.3V 125.1449ms,3.3
+ 125.1450ms,0.0V 125.1599ms,0.0
+ 125.1600ms,3.3V 125.1649ms,3.3
+ 125.1650ms,0.0V 125.1799ms,0.0
+ 125.1800ms,3.3V 125.1849ms,3.3
+ 125.1850ms,0.0V 125.1999ms,0.0
+ 125.2000ms,3.3V 125.2049ms,3.3
+ 125.2050ms,0.0V 125.2199ms,0.0
+ 125.2200ms,3.3V 125.2249ms,3.3
+ 125.2250ms,0.0V 125.2399ms,0.0
+ 125.2400ms,3.3V 125.2449ms,3.3
+ 125.2450ms,0.0V 125.2599ms,0.0
+ 125.2600ms,3.3V 125.2649ms,3.3
+ 125.2650ms,0.0V 125.2799ms,0.0
+ 125.2800ms,3.3V 125.2849ms,3.3
+ 125.2850ms,0.0V 125.2999ms,0.0
+ 125.3000ms,3.3V 125.3049ms,3.3
+ 125.3050ms,0.0V 125.3199ms,0.0
+ 125.3200ms,3.3V 125.3249ms,3.3
+ 125.3250ms,0.0V 125.3399ms,0.0
+ 125.3400ms,3.3V 125.3449ms,3.3
+ 125.3450ms,0.0V 125.3599ms,0.0
+ 125.3600ms,3.3V 125.3651ms,3.3
+ 125.3652ms,0.0V 125.3799ms,0.0
+ 125.3800ms,3.3V 125.3851ms,3.3
+ 125.3852ms,0.0V 125.3999ms,0.0
+ 125.4000ms,3.3V 125.4051ms,3.3
+ 125.4052ms,0.0V 125.4199ms,0.0
+ 125.4200ms,3.3V 125.4251ms,3.3
+ 125.4252ms,0.0V 125.4399ms,0.0
+ 125.4400ms,3.3V 125.4451ms,3.3
+ 125.4452ms,0.0V 125.4599ms,0.0
+ 125.4600ms,3.3V 125.4651ms,3.3
+ 125.4652ms,0.0V 125.4799ms,0.0
+ 125.4800ms,3.3V 125.4851ms,3.3
+ 125.4852ms,0.0V 125.4999ms,0.0
+ 125.5000ms,3.3V 125.5051ms,3.3
+ 125.5052ms,0.0V 125.5199ms,0.0
+ 125.5200ms,3.3V 125.5251ms,3.3
+ 125.5252ms,0.0V 125.5399ms,0.0
+ 125.5400ms,3.3V 125.5451ms,3.3
+ 125.5452ms,0.0V 125.5599ms,0.0
+ 125.5600ms,3.3V 125.5651ms,3.3
+ 125.5652ms,0.0V 125.5799ms,0.0
+ 125.5800ms,3.3V 125.5851ms,3.3
+ 125.5852ms,0.0V 125.5999ms,0.0
+ 125.6000ms,3.3V 125.6051ms,3.3
+ 125.6052ms,0.0V 125.6199ms,0.0
+ 125.6200ms,3.3V 125.6251ms,3.3
+ 125.6252ms,0.0V 125.6399ms,0.0
+ 125.6400ms,3.3V 125.6451ms,3.3
+ 125.6452ms,0.0V 125.6599ms,0.0
+ 125.6600ms,3.3V 125.6651ms,3.3
+ 125.6652ms,0.0V 125.6799ms,0.0
+ 125.6800ms,3.3V 125.6851ms,3.3
+ 125.6852ms,0.0V 125.6999ms,0.0
+ 125.7000ms,3.3V 125.7051ms,3.3
+ 125.7052ms,0.0V 125.7199ms,0.0
+ 125.7200ms,3.3V 125.7251ms,3.3
+ 125.7252ms,0.0V 125.7399ms,0.0
+ 125.7400ms,3.3V 125.7451ms,3.3
+ 125.7452ms,0.0V 125.7599ms,0.0
+ 125.7600ms,3.3V 125.7651ms,3.3
+ 125.7652ms,0.0V 125.7799ms,0.0
+ 125.7800ms,3.3V 125.7851ms,3.3
+ 125.7852ms,0.0V 125.7999ms,0.0
+ 125.8000ms,3.3V 125.8051ms,3.3
+ 125.8052ms,0.0V 125.8199ms,0.0
+ 125.8200ms,3.3V 125.8251ms,3.3
+ 125.8252ms,0.0V 125.8399ms,0.0
+ 125.8400ms,3.3V 125.8451ms,3.3
+ 125.8452ms,0.0V 125.8599ms,0.0
+ 125.8600ms,3.3V 125.8651ms,3.3
+ 125.8652ms,0.0V 125.8799ms,0.0
+ 125.8800ms,3.3V 125.8851ms,3.3
+ 125.8852ms,0.0V 125.8999ms,0.0
+ 125.9000ms,3.3V 125.9051ms,3.3
+ 125.9052ms,0.0V 125.9199ms,0.0
+ 125.9200ms,3.3V 125.9251ms,3.3
+ 125.9252ms,0.0V 125.9399ms,0.0
+ 125.9400ms,3.3V 125.9451ms,3.3
+ 125.9452ms,0.0V 125.9599ms,0.0
+ 125.9600ms,3.3V 125.9651ms,3.3
+ 125.9652ms,0.0V 125.9799ms,0.0
+ 125.9800ms,3.3V 125.9851ms,3.3
+ 125.9852ms,0.0V 125.9999ms,0.0
+ 126.0000ms,3.3V 126.0051ms,3.3
+ 126.0052ms,0.0V 126.0199ms,0.0
+ 126.0200ms,3.3V 126.0251ms,3.3
+ 126.0252ms,0.0V 126.0399ms,0.0
+ 126.0400ms,3.3V 126.0451ms,3.3
+ 126.0452ms,0.0V 126.0599ms,0.0
+ 126.0600ms,3.3V 126.0651ms,3.3
+ 126.0652ms,0.0V 126.0799ms,0.0
+ 126.0800ms,3.3V 126.0851ms,3.3
+ 126.0852ms,0.0V 126.0999ms,0.0
+ 126.1000ms,3.3V 126.1051ms,3.3
+ 126.1052ms,0.0V 126.1199ms,0.0
+ 126.1200ms,3.3V 126.1251ms,3.3
+ 126.1252ms,0.0V 126.1399ms,0.0
+ 126.1400ms,3.3V 126.1451ms,3.3
+ 126.1452ms,0.0V 126.1599ms,0.0
+ 126.1600ms,3.3V 126.1651ms,3.3
+ 126.1652ms,0.0V 126.1799ms,0.0
+ 126.1800ms,3.3V 126.1851ms,3.3
+ 126.1852ms,0.0V 126.1999ms,0.0
+ 126.2000ms,3.3V 126.2051ms,3.3
+ 126.2052ms,0.0V 126.2199ms,0.0
+ 126.2200ms,3.3V 126.2251ms,3.3
+ 126.2252ms,0.0V 126.2399ms,0.0
+ 126.2400ms,3.3V 126.2451ms,3.3
+ 126.2452ms,0.0V 126.2599ms,0.0
+ 126.2600ms,3.3V 126.2651ms,3.3
+ 126.2652ms,0.0V 126.2799ms,0.0
+ 126.2800ms,3.3V 126.2851ms,3.3
+ 126.2852ms,0.0V 126.2999ms,0.0
+ 126.3000ms,3.3V 126.3051ms,3.3
+ 126.3052ms,0.0V 126.3199ms,0.0
+ 126.3200ms,3.3V 126.3251ms,3.3
+ 126.3252ms,0.0V 126.3399ms,0.0
+ 126.3400ms,3.3V 126.3451ms,3.3
+ 126.3452ms,0.0V 126.3599ms,0.0
+ 126.3600ms,3.3V 126.3651ms,3.3
+ 126.3652ms,0.0V 126.3799ms,0.0
+ 126.3800ms,3.3V 126.3851ms,3.3
+ 126.3852ms,0.0V 126.3999ms,0.0
+ 126.4000ms,3.3V 126.4051ms,3.3
+ 126.4052ms,0.0V 126.4199ms,0.0
+ 126.4200ms,3.3V 126.4251ms,3.3
+ 126.4252ms,0.0V 126.4399ms,0.0
+ 126.4400ms,3.3V 126.4451ms,3.3
+ 126.4452ms,0.0V 126.4599ms,0.0
+ 126.4600ms,3.3V 126.4651ms,3.3
+ 126.4652ms,0.0V 126.4799ms,0.0
+ 126.4800ms,3.3V 126.4851ms,3.3
+ 126.4852ms,0.0V 126.4999ms,0.0
+ 126.5000ms,3.3V 126.5051ms,3.3
+ 126.5052ms,0.0V 126.5199ms,0.0
+ 126.5200ms,3.3V 126.5251ms,3.3
+ 126.5252ms,0.0V 126.5399ms,0.0
+ 126.5400ms,3.3V 126.5451ms,3.3
+ 126.5452ms,0.0V 126.5599ms,0.0
+ 126.5600ms,3.3V 126.5651ms,3.3
+ 126.5652ms,0.0V 126.5799ms,0.0
+ 126.5800ms,3.3V 126.5851ms,3.3
+ 126.5852ms,0.0V 126.5999ms,0.0
+ 126.6000ms,3.3V 126.6051ms,3.3
+ 126.6052ms,0.0V 126.6199ms,0.0
+ 126.6200ms,3.3V 126.6251ms,3.3
+ 126.6252ms,0.0V 126.6399ms,0.0
+ 126.6400ms,3.3V 126.6451ms,3.3
+ 126.6452ms,0.0V 126.6599ms,0.0
+ 126.6600ms,3.3V 126.6651ms,3.3
+ 126.6652ms,0.0V 126.6799ms,0.0
+ 126.6800ms,3.3V 126.6851ms,3.3
+ 126.6852ms,0.0V 126.6999ms,0.0
+ 126.7000ms,3.3V 126.7051ms,3.3
+ 126.7052ms,0.0V 126.7199ms,0.0
+ 126.7200ms,3.3V 126.7251ms,3.3
+ 126.7252ms,0.0V 126.7399ms,0.0
+ 126.7400ms,3.3V 126.7451ms,3.3
+ 126.7452ms,0.0V 126.7599ms,0.0
+ 126.7600ms,3.3V 126.7651ms,3.3
+ 126.7652ms,0.0V 126.7799ms,0.0
+ 126.7800ms,3.3V 126.7851ms,3.3
+ 126.7852ms,0.0V 126.7999ms,0.0
+ 126.8000ms,3.3V 126.8051ms,3.3
+ 126.8052ms,0.0V 126.8199ms,0.0
+ 126.8200ms,3.3V 126.8251ms,3.3
+ 126.8252ms,0.0V 126.8399ms,0.0
+ 126.8400ms,3.3V 126.8451ms,3.3
+ 126.8452ms,0.0V 126.8599ms,0.0
+ 126.8600ms,3.3V 126.8651ms,3.3
+ 126.8652ms,0.0V 126.8799ms,0.0
+ 126.8800ms,3.3V 126.8851ms,3.3
+ 126.8852ms,0.0V 126.8999ms,0.0
+ 126.9000ms,3.3V 126.9051ms,3.3
+ 126.9052ms,0.0V 126.9199ms,0.0
+ 126.9200ms,3.3V 126.9251ms,3.3
+ 126.9252ms,0.0V 126.9399ms,0.0
+ 126.9400ms,3.3V 126.9451ms,3.3
+ 126.9452ms,0.0V 126.9599ms,0.0
+ 126.9600ms,3.3V 126.9651ms,3.3
+ 126.9652ms,0.0V 126.9799ms,0.0
+ 126.9800ms,3.3V 126.9851ms,3.3
+ 126.9852ms,0.0V 126.9999ms,0.0
+ 127.0000ms,3.3V 127.0051ms,3.3
+ 127.0052ms,0.0V 127.0199ms,0.0
+ 127.0200ms,3.3V 127.0251ms,3.3
+ 127.0252ms,0.0V 127.0399ms,0.0
+ 127.0400ms,3.3V 127.0451ms,3.3
+ 127.0452ms,0.0V 127.0599ms,0.0
+ 127.0600ms,3.3V 127.0651ms,3.3
+ 127.0652ms,0.0V 127.0799ms,0.0
+ 127.0800ms,3.3V 127.0851ms,3.3
+ 127.0852ms,0.0V 127.0999ms,0.0
+ 127.1000ms,3.3V 127.1051ms,3.3
+ 127.1052ms,0.0V 127.1199ms,0.0
+ 127.1200ms,3.3V 127.1251ms,3.3
+ 127.1252ms,0.0V 127.1399ms,0.0
+ 127.1400ms,3.3V 127.1451ms,3.3
+ 127.1452ms,0.0V 127.1599ms,0.0
+ 127.1600ms,3.3V 127.1651ms,3.3
+ 127.1652ms,0.0V 127.1799ms,0.0
+ 127.1800ms,3.3V 127.1851ms,3.3
+ 127.1852ms,0.0V 127.1999ms,0.0
+ 127.2000ms,3.3V 127.2051ms,3.3
+ 127.2052ms,0.0V 127.2199ms,0.0
+ 127.2200ms,3.3V 127.2251ms,3.3
+ 127.2252ms,0.0V 127.2399ms,0.0
+ 127.2400ms,3.3V 127.2451ms,3.3
+ 127.2452ms,0.0V 127.2599ms,0.0
+ 127.2600ms,3.3V 127.2651ms,3.3
+ 127.2652ms,0.0V 127.2799ms,0.0
+ 127.2800ms,3.3V 127.2851ms,3.3
+ 127.2852ms,0.0V 127.2999ms,0.0
+ 127.3000ms,3.3V 127.3051ms,3.3
+ 127.3052ms,0.0V 127.3199ms,0.0
+ 127.3200ms,3.3V 127.3251ms,3.3
+ 127.3252ms,0.0V 127.3399ms,0.0
+ 127.3400ms,3.3V 127.3451ms,3.3
+ 127.3452ms,0.0V 127.3599ms,0.0
+ 127.3600ms,3.3V 127.3651ms,3.3
+ 127.3652ms,0.0V 127.3799ms,0.0
+ 127.3800ms,3.3V 127.3851ms,3.3
+ 127.3852ms,0.0V 127.3999ms,0.0
+ 127.4000ms,3.3V 127.4051ms,3.3
+ 127.4052ms,0.0V 127.4199ms,0.0
+ 127.4200ms,3.3V 127.4251ms,3.3
+ 127.4252ms,0.0V 127.4399ms,0.0
+ 127.4400ms,3.3V 127.4451ms,3.3
+ 127.4452ms,0.0V 127.4599ms,0.0
+ 127.4600ms,3.3V 127.4651ms,3.3
+ 127.4652ms,0.0V 127.4799ms,0.0
+ 127.4800ms,3.3V 127.4851ms,3.3
+ 127.4852ms,0.0V 127.4999ms,0.0
+ 127.5000ms,3.3V 127.5051ms,3.3
+ 127.5052ms,0.0V 127.5199ms,0.0
+ 127.5200ms,3.3V 127.5251ms,3.3
+ 127.5252ms,0.0V 127.5399ms,0.0
+ 127.5400ms,3.3V 127.5451ms,3.3
+ 127.5452ms,0.0V 127.5599ms,0.0
+ 127.5600ms,3.3V 127.5651ms,3.3
+ 127.5652ms,0.0V 127.5799ms,0.0
+ 127.5800ms,3.3V 127.5851ms,3.3
+ 127.5852ms,0.0V 127.5999ms,0.0
+ 127.6000ms,3.3V 127.6051ms,3.3
+ 127.6052ms,0.0V 127.6199ms,0.0
+ 127.6200ms,3.3V 127.6251ms,3.3
+ 127.6252ms,0.0V 127.6399ms,0.0
+ 127.6400ms,3.3V 127.6451ms,3.3
+ 127.6452ms,0.0V 127.6599ms,0.0
+ 127.6600ms,3.3V 127.6651ms,3.3
+ 127.6652ms,0.0V 127.6799ms,0.0
+ 127.6800ms,3.3V 127.6851ms,3.3
+ 127.6852ms,0.0V 127.6999ms,0.0
+ 127.7000ms,3.3V 127.7051ms,3.3
+ 127.7052ms,0.0V 127.7199ms,0.0
+ 127.7200ms,3.3V 127.7251ms,3.3
+ 127.7252ms,0.0V 127.7399ms,0.0
+ 127.7400ms,3.3V 127.7451ms,3.3
+ 127.7452ms,0.0V 127.7599ms,0.0
+ 127.7600ms,3.3V 127.7651ms,3.3
+ 127.7652ms,0.0V 127.7799ms,0.0
+ 127.7800ms,3.3V 127.7851ms,3.3
+ 127.7852ms,0.0V 127.7999ms,0.0
+ 127.8000ms,3.3V 127.8051ms,3.3
+ 127.8052ms,0.0V 127.8199ms,0.0
+ 127.8200ms,3.3V 127.8251ms,3.3
+ 127.8252ms,0.0V 127.8399ms,0.0
+ 127.8400ms,3.3V 127.8451ms,3.3
+ 127.8452ms,0.0V 127.8599ms,0.0
+ 127.8600ms,3.3V 127.8651ms,3.3
+ 127.8652ms,0.0V 127.8799ms,0.0
+ 127.8800ms,3.3V 127.8851ms,3.3
+ 127.8852ms,0.0V 127.8999ms,0.0
+ 127.9000ms,3.3V 127.9051ms,3.3
+ 127.9052ms,0.0V 127.9199ms,0.0
+ 127.9200ms,3.3V 127.9251ms,3.3
+ 127.9252ms,0.0V 127.9399ms,0.0
+ 127.9400ms,3.3V 127.9451ms,3.3
+ 127.9452ms,0.0V 127.9599ms,0.0
+ 127.9600ms,3.3V 127.9651ms,3.3
+ 127.9652ms,0.0V 127.9799ms,0.0
+ 127.9800ms,3.3V 127.9851ms,3.3
+ 127.9852ms,0.0V 127.9999ms,0.0
+ 128.0000ms,3.3V 128.0051ms,3.3
+ 128.0052ms,0.0V 128.0199ms,0.0
+ 128.0200ms,3.3V 128.0251ms,3.3
+ 128.0252ms,0.0V 128.0399ms,0.0
+ 128.0400ms,3.3V 128.0451ms,3.3
+ 128.0452ms,0.0V 128.0599ms,0.0
+ 128.0600ms,3.3V 128.0651ms,3.3
+ 128.0652ms,0.0V 128.0799ms,0.0
+ 128.0800ms,3.3V 128.0851ms,3.3
+ 128.0852ms,0.0V 128.0999ms,0.0
+ 128.1000ms,3.3V 128.1051ms,3.3
+ 128.1052ms,0.0V 128.1199ms,0.0
+ 128.1200ms,3.3V 128.1251ms,3.3
+ 128.1252ms,0.0V 128.1399ms,0.0
+ 128.1400ms,3.3V 128.1451ms,3.3
+ 128.1452ms,0.0V 128.1599ms,0.0
+ 128.1600ms,3.3V 128.1651ms,3.3
+ 128.1652ms,0.0V 128.1799ms,0.0
+ 128.1800ms,3.3V 128.1851ms,3.3
+ 128.1852ms,0.0V 128.1999ms,0.0
+ 128.2000ms,3.3V 128.2051ms,3.3
+ 128.2052ms,0.0V 128.2199ms,0.0
+ 128.2200ms,3.3V 128.2251ms,3.3
+ 128.2252ms,0.0V 128.2399ms,0.0
+ 128.2400ms,3.3V 128.2451ms,3.3
+ 128.2452ms,0.0V 128.2599ms,0.0
+ 128.2600ms,3.3V 128.2651ms,3.3
+ 128.2652ms,0.0V 128.2799ms,0.0
+ 128.2800ms,3.3V 128.2851ms,3.3
+ 128.2852ms,0.0V 128.2999ms,0.0
+ 128.3000ms,3.3V 128.3051ms,3.3
+ 128.3052ms,0.0V 128.3199ms,0.0
+ 128.3200ms,3.3V 128.3251ms,3.3
+ 128.3252ms,0.0V 128.3399ms,0.0
+ 128.3400ms,3.3V 128.3451ms,3.3
+ 128.3452ms,0.0V 128.3599ms,0.0
+ 128.3600ms,3.3V 128.3651ms,3.3
+ 128.3652ms,0.0V 128.3799ms,0.0
+ 128.3800ms,3.3V 128.3851ms,3.3
+ 128.3852ms,0.0V 128.3999ms,0.0
+ 128.4000ms,3.3V 128.4051ms,3.3
+ 128.4052ms,0.0V 128.4199ms,0.0
+ 128.4200ms,3.3V 128.4251ms,3.3
+ 128.4252ms,0.0V 128.4399ms,0.0
+ 128.4400ms,3.3V 128.4451ms,3.3
+ 128.4452ms,0.0V 128.4599ms,0.0
+ 128.4600ms,3.3V 128.4651ms,3.3
+ 128.4652ms,0.0V 128.4799ms,0.0
+ 128.4800ms,3.3V 128.4851ms,3.3
+ 128.4852ms,0.0V 128.4999ms,0.0
+ 128.5000ms,3.3V 128.5051ms,3.3
+ 128.5052ms,0.0V 128.5199ms,0.0
+ 128.5200ms,3.3V 128.5251ms,3.3
+ 128.5252ms,0.0V 128.5399ms,0.0
+ 128.5400ms,3.3V 128.5451ms,3.3
+ 128.5452ms,0.0V 128.5599ms,0.0
+ 128.5600ms,3.3V 128.5651ms,3.3
+ 128.5652ms,0.0V 128.5799ms,0.0
+ 128.5800ms,3.3V 128.5851ms,3.3
+ 128.5852ms,0.0V 128.5999ms,0.0
+ 128.6000ms,3.3V 128.6051ms,3.3
+ 128.6052ms,0.0V 128.6199ms,0.0
+ 128.6200ms,3.3V 128.6251ms,3.3
+ 128.6252ms,0.0V 128.6399ms,0.0
+ 128.6400ms,3.3V 128.6451ms,3.3
+ 128.6452ms,0.0V 128.6599ms,0.0
+ 128.6600ms,3.3V 128.6651ms,3.3
+ 128.6652ms,0.0V 128.6799ms,0.0
+ 128.6800ms,3.3V 128.6851ms,3.3
+ 128.6852ms,0.0V 128.6999ms,0.0
+ 128.7000ms,3.3V 128.7051ms,3.3
+ 128.7052ms,0.0V 128.7199ms,0.0
+ 128.7200ms,3.3V 128.7251ms,3.3
+ 128.7252ms,0.0V 128.7399ms,0.0
+ 128.7400ms,3.3V 128.7451ms,3.3
+ 128.7452ms,0.0V 128.7599ms,0.0
+ 128.7600ms,3.3V 128.7651ms,3.3
+ 128.7652ms,0.0V 128.7799ms,0.0
+ 128.7800ms,3.3V 128.7851ms,3.3
+ 128.7852ms,0.0V 128.7999ms,0.0
+ 128.8000ms,3.3V 128.8051ms,3.3
+ 128.8052ms,0.0V 128.8199ms,0.0
+ 128.8200ms,3.3V 128.8251ms,3.3
+ 128.8252ms,0.0V 128.8399ms,0.0
+ 128.8400ms,3.3V 128.8451ms,3.3
+ 128.8452ms,0.0V 128.8599ms,0.0
+ 128.8600ms,3.3V 128.8651ms,3.3
+ 128.8652ms,0.0V 128.8799ms,0.0
+ 128.8800ms,3.3V 128.8851ms,3.3
+ 128.8852ms,0.0V 128.8999ms,0.0
+ 128.9000ms,3.3V 128.9051ms,3.3
+ 128.9052ms,0.0V 128.9199ms,0.0
+ 128.9200ms,3.3V 128.9251ms,3.3
+ 128.9252ms,0.0V 128.9399ms,0.0
+ 128.9400ms,3.3V 128.9451ms,3.3
+ 128.9452ms,0.0V 128.9599ms,0.0
+ 128.9600ms,3.3V 128.9651ms,3.3
+ 128.9652ms,0.0V 128.9799ms,0.0
+ 128.9800ms,3.3V 128.9851ms,3.3
+ 128.9852ms,0.0V 128.9999ms,0.0
+ 129.0000ms,3.3V 129.0051ms,3.3
+ 129.0052ms,0.0V 129.0199ms,0.0
+ 129.0200ms,3.3V 129.0251ms,3.3
+ 129.0252ms,0.0V 129.0399ms,0.0
+ 129.0400ms,3.3V 129.0451ms,3.3
+ 129.0452ms,0.0V 129.0599ms,0.0
+ 129.0600ms,3.3V 129.0651ms,3.3
+ 129.0652ms,0.0V 129.0799ms,0.0
+ 129.0800ms,3.3V 129.0851ms,3.3
+ 129.0852ms,0.0V 129.0999ms,0.0
+ 129.1000ms,3.3V 129.1051ms,3.3
+ 129.1052ms,0.0V 129.1199ms,0.0
+ 129.1200ms,3.3V 129.1251ms,3.3
+ 129.1252ms,0.0V 129.1399ms,0.0
+ 129.1400ms,3.3V 129.1451ms,3.3
+ 129.1452ms,0.0V 129.1599ms,0.0
+ 129.1600ms,3.3V 129.1651ms,3.3
+ 129.1652ms,0.0V 129.1799ms,0.0
+ 129.1800ms,3.3V 129.1851ms,3.3
+ 129.1852ms,0.0V 129.1999ms,0.0
+ 129.2000ms,3.3V 129.2051ms,3.3
+ 129.2052ms,0.0V 129.2199ms,0.0
+ 129.2200ms,3.3V 129.2251ms,3.3
+ 129.2252ms,0.0V 129.2399ms,0.0
+ 129.2400ms,3.3V 129.2451ms,3.3
+ 129.2452ms,0.0V 129.2599ms,0.0
+ 129.2600ms,3.3V 129.2651ms,3.3
+ 129.2652ms,0.0V 129.2799ms,0.0
+ 129.2800ms,3.3V 129.2851ms,3.3
+ 129.2852ms,0.0V 129.2999ms,0.0
+ 129.3000ms,3.3V 129.3051ms,3.3
+ 129.3052ms,0.0V 129.3199ms,0.0
+ 129.3200ms,3.3V 129.3251ms,3.3
+ 129.3252ms,0.0V 129.3399ms,0.0
+ 129.3400ms,3.3V 129.3451ms,3.3
+ 129.3452ms,0.0V 129.3599ms,0.0
+ 129.3600ms,3.3V 129.3651ms,3.3
+ 129.3652ms,0.0V 129.3799ms,0.0
+ 129.3800ms,3.3V 129.3851ms,3.3
+ 129.3852ms,0.0V 129.3999ms,0.0
+ 129.4000ms,3.3V 129.4051ms,3.3
+ 129.4052ms,0.0V 129.4199ms,0.0
+ 129.4200ms,3.3V 129.4251ms,3.3
+ 129.4252ms,0.0V 129.4399ms,0.0
+ 129.4400ms,3.3V 129.4451ms,3.3
+ 129.4452ms,0.0V 129.4599ms,0.0
+ 129.4600ms,3.3V 129.4651ms,3.3
+ 129.4652ms,0.0V 129.4799ms,0.0
+ 129.4800ms,3.3V 129.4851ms,3.3
+ 129.4852ms,0.0V 129.4999ms,0.0
+ 129.5000ms,3.3V 129.5051ms,3.3
+ 129.5052ms,0.0V 129.5199ms,0.0
+ 129.5200ms,3.3V 129.5251ms,3.3
+ 129.5252ms,0.0V 129.5399ms,0.0
+ 129.5400ms,3.3V 129.5451ms,3.3
+ 129.5452ms,0.0V 129.5599ms,0.0
+ 129.5600ms,3.3V 129.5651ms,3.3
+ 129.5652ms,0.0V 129.5799ms,0.0
+ 129.5800ms,3.3V 129.5851ms,3.3
+ 129.5852ms,0.0V 129.5999ms,0.0
+ 129.6000ms,3.3V 129.6051ms,3.3
+ 129.6052ms,0.0V 129.6199ms,0.0
+ 129.6200ms,3.3V 129.6251ms,3.3
+ 129.6252ms,0.0V 129.6399ms,0.0
+ 129.6400ms,3.3V 129.6451ms,3.3
+ 129.6452ms,0.0V 129.6599ms,0.0
+ 129.6600ms,3.3V 129.6651ms,3.3
+ 129.6652ms,0.0V 129.6799ms,0.0
+ 129.6800ms,3.3V 129.6851ms,3.3
+ 129.6852ms,0.0V 129.6999ms,0.0
+ 129.7000ms,3.3V 129.7051ms,3.3
+ 129.7052ms,0.0V 129.7199ms,0.0
+ 129.7200ms,3.3V 129.7251ms,3.3
+ 129.7252ms,0.0V 129.7399ms,0.0
+ 129.7400ms,3.3V 129.7451ms,3.3
+ 129.7452ms,0.0V 129.7599ms,0.0
+ 129.7600ms,3.3V 129.7651ms,3.3
+ 129.7652ms,0.0V 129.7799ms,0.0
+ 129.7800ms,3.3V 129.7851ms,3.3
+ 129.7852ms,0.0V 129.7999ms,0.0
+ 129.8000ms,3.3V 129.8051ms,3.3
+ 129.8052ms,0.0V 129.8199ms,0.0
+ 129.8200ms,3.3V 129.8251ms,3.3
+ 129.8252ms,0.0V 129.8399ms,0.0
+ 129.8400ms,3.3V 129.8451ms,3.3
+ 129.8452ms,0.0V 129.8599ms,0.0
+ 129.8600ms,3.3V 129.8651ms,3.3
+ 129.8652ms,0.0V 129.8799ms,0.0
+ 129.8800ms,3.3V 129.8851ms,3.3
+ 129.8852ms,0.0V 129.8999ms,0.0
+ 129.9000ms,3.3V 129.9051ms,3.3
+ 129.9052ms,0.0V 129.9199ms,0.0
+ 129.9200ms,3.3V 129.9251ms,3.3
+ 129.9252ms,0.0V 129.9399ms,0.0
+ 129.9400ms,3.3V 129.9451ms,3.3
+ 129.9452ms,0.0V 129.9599ms,0.0
+ 129.9600ms,3.3V 129.9651ms,3.3
+ 129.9652ms,0.0V 129.9799ms,0.0
+ 129.9800ms,3.3V 129.9851ms,3.3
+ 129.9852ms,0.0V 129.9999ms,0.0
+ 130.0000ms,3.3V 130.0051ms,3.3
+ 130.0052ms,0.0V 130.0199ms,0.0
+ 130.0200ms,3.3V 130.0251ms,3.3
+ 130.0252ms,0.0V 130.0399ms,0.0
+ 130.0400ms,3.3V 130.0451ms,3.3
+ 130.0452ms,0.0V 130.0599ms,0.0
+ 130.0600ms,3.3V 130.0651ms,3.3
+ 130.0652ms,0.0V 130.0799ms,0.0
+ 130.0800ms,3.3V 130.0851ms,3.3
+ 130.0852ms,0.0V 130.0999ms,0.0
+ 130.1000ms,3.3V 130.1051ms,3.3
+ 130.1052ms,0.0V 130.1199ms,0.0
+ 130.1200ms,3.3V 130.1251ms,3.3
+ 130.1252ms,0.0V 130.1399ms,0.0
+ 130.1400ms,3.3V 130.1451ms,3.3
+ 130.1452ms,0.0V 130.1599ms,0.0
+ 130.1600ms,3.3V 130.1651ms,3.3
+ 130.1652ms,0.0V 130.1799ms,0.0
+ 130.1800ms,3.3V 130.1851ms,3.3
+ 130.1852ms,0.0V 130.1999ms,0.0
+ 130.2000ms,3.3V 130.2051ms,3.3
+ 130.2052ms,0.0V 130.2199ms,0.0
+ 130.2200ms,3.3V 130.2251ms,3.3
+ 130.2252ms,0.0V 130.2399ms,0.0
+ 130.2400ms,3.3V 130.2451ms,3.3
+ 130.2452ms,0.0V 130.2599ms,0.0
+ 130.2600ms,3.3V 130.2651ms,3.3
+ 130.2652ms,0.0V 130.2799ms,0.0
+ 130.2800ms,3.3V 130.2851ms,3.3
+ 130.2852ms,0.0V 130.2999ms,0.0
+ 130.3000ms,3.3V 130.3051ms,3.3
+ 130.3052ms,0.0V 130.3199ms,0.0
+ 130.3200ms,3.3V 130.3251ms,3.3
+ 130.3252ms,0.0V 130.3399ms,0.0
+ 130.3400ms,3.3V 130.3451ms,3.3
+ 130.3452ms,0.0V 130.3599ms,0.0
+ 130.3600ms,3.3V 130.3653ms,3.3
+ 130.3654ms,0.0V 130.3799ms,0.0
+ 130.3800ms,3.3V 130.3853ms,3.3
+ 130.3854ms,0.0V 130.3999ms,0.0
+ 130.4000ms,3.3V 130.4053ms,3.3
+ 130.4054ms,0.0V 130.4199ms,0.0
+ 130.4200ms,3.3V 130.4253ms,3.3
+ 130.4254ms,0.0V 130.4399ms,0.0
+ 130.4400ms,3.3V 130.4453ms,3.3
+ 130.4454ms,0.0V 130.4599ms,0.0
+ 130.4600ms,3.3V 130.4653ms,3.3
+ 130.4654ms,0.0V 130.4799ms,0.0
+ 130.4800ms,3.3V 130.4853ms,3.3
+ 130.4854ms,0.0V 130.4999ms,0.0
+ 130.5000ms,3.3V 130.5053ms,3.3
+ 130.5054ms,0.0V 130.5199ms,0.0
+ 130.5200ms,3.3V 130.5253ms,3.3
+ 130.5254ms,0.0V 130.5399ms,0.0
+ 130.5400ms,3.3V 130.5453ms,3.3
+ 130.5454ms,0.0V 130.5599ms,0.0
+ 130.5600ms,3.3V 130.5653ms,3.3
+ 130.5654ms,0.0V 130.5799ms,0.0
+ 130.5800ms,3.3V 130.5853ms,3.3
+ 130.5854ms,0.0V 130.5999ms,0.0
+ 130.6000ms,3.3V 130.6053ms,3.3
+ 130.6054ms,0.0V 130.6199ms,0.0
+ 130.6200ms,3.3V 130.6253ms,3.3
+ 130.6254ms,0.0V 130.6399ms,0.0
+ 130.6400ms,3.3V 130.6453ms,3.3
+ 130.6454ms,0.0V 130.6599ms,0.0
+ 130.6600ms,3.3V 130.6653ms,3.3
+ 130.6654ms,0.0V 130.6799ms,0.0
+ 130.6800ms,3.3V 130.6853ms,3.3
+ 130.6854ms,0.0V 130.6999ms,0.0
+ 130.7000ms,3.3V 130.7053ms,3.3
+ 130.7054ms,0.0V 130.7199ms,0.0
+ 130.7200ms,3.3V 130.7253ms,3.3
+ 130.7254ms,0.0V 130.7399ms,0.0
+ 130.7400ms,3.3V 130.7453ms,3.3
+ 130.7454ms,0.0V 130.7599ms,0.0
+ 130.7600ms,3.3V 130.7653ms,3.3
+ 130.7654ms,0.0V 130.7799ms,0.0
+ 130.7800ms,3.3V 130.7853ms,3.3
+ 130.7854ms,0.0V 130.7999ms,0.0
+ 130.8000ms,3.3V 130.8053ms,3.3
+ 130.8054ms,0.0V 130.8199ms,0.0
+ 130.8200ms,3.3V 130.8253ms,3.3
+ 130.8254ms,0.0V 130.8399ms,0.0
+ 130.8400ms,3.3V 130.8453ms,3.3
+ 130.8454ms,0.0V 130.8599ms,0.0
+ 130.8600ms,3.3V 130.8653ms,3.3
+ 130.8654ms,0.0V 130.8799ms,0.0
+ 130.8800ms,3.3V 130.8853ms,3.3
+ 130.8854ms,0.0V 130.8999ms,0.0
+ 130.9000ms,3.3V 130.9053ms,3.3
+ 130.9054ms,0.0V 130.9199ms,0.0
+ 130.9200ms,3.3V 130.9253ms,3.3
+ 130.9254ms,0.0V 130.9399ms,0.0
+ 130.9400ms,3.3V 130.9453ms,3.3
+ 130.9454ms,0.0V 130.9599ms,0.0
+ 130.9600ms,3.3V 130.9653ms,3.3
+ 130.9654ms,0.0V 130.9799ms,0.0
+ 130.9800ms,3.3V 130.9853ms,3.3
+ 130.9854ms,0.0V 130.9999ms,0.0
+ 131.0000ms,3.3V 131.0053ms,3.3
+ 131.0054ms,0.0V 131.0199ms,0.0
+ 131.0200ms,3.3V 131.0253ms,3.3
+ 131.0254ms,0.0V 131.0399ms,0.0
+ 131.0400ms,3.3V 131.0453ms,3.3
+ 131.0454ms,0.0V 131.0599ms,0.0
+ 131.0600ms,3.3V 131.0653ms,3.3
+ 131.0654ms,0.0V 131.0799ms,0.0
+ 131.0800ms,3.3V 131.0853ms,3.3
+ 131.0854ms,0.0V 131.0999ms,0.0
+ 131.1000ms,3.3V 131.1053ms,3.3
+ 131.1054ms,0.0V 131.1199ms,0.0
+ 131.1200ms,3.3V 131.1253ms,3.3
+ 131.1254ms,0.0V 131.1399ms,0.0
+ 131.1400ms,3.3V 131.1453ms,3.3
+ 131.1454ms,0.0V 131.1599ms,0.0
+ 131.1600ms,3.3V 131.1653ms,3.3
+ 131.1654ms,0.0V 131.1799ms,0.0
+ 131.1800ms,3.3V 131.1853ms,3.3
+ 131.1854ms,0.0V 131.1999ms,0.0
+ 131.2000ms,3.3V 131.2053ms,3.3
+ 131.2054ms,0.0V 131.2199ms,0.0
+ 131.2200ms,3.3V 131.2253ms,3.3
+ 131.2254ms,0.0V 131.2399ms,0.0
+ 131.2400ms,3.3V 131.2453ms,3.3
+ 131.2454ms,0.0V 131.2599ms,0.0
+ 131.2600ms,3.3V 131.2653ms,3.3
+ 131.2654ms,0.0V 131.2799ms,0.0
+ 131.2800ms,3.3V 131.2853ms,3.3
+ 131.2854ms,0.0V 131.2999ms,0.0
+ 131.3000ms,3.3V 131.3053ms,3.3
+ 131.3054ms,0.0V 131.3199ms,0.0
+ 131.3200ms,3.3V 131.3253ms,3.3
+ 131.3254ms,0.0V 131.3399ms,0.0
+ 131.3400ms,3.3V 131.3453ms,3.3
+ 131.3454ms,0.0V 131.3599ms,0.0
+ 131.3600ms,3.3V 131.3653ms,3.3
+ 131.3654ms,0.0V 131.3799ms,0.0
+ 131.3800ms,3.3V 131.3853ms,3.3
+ 131.3854ms,0.0V 131.3999ms,0.0
+ 131.4000ms,3.3V 131.4053ms,3.3
+ 131.4054ms,0.0V 131.4199ms,0.0
+ 131.4200ms,3.3V 131.4253ms,3.3
+ 131.4254ms,0.0V 131.4399ms,0.0
+ 131.4400ms,3.3V 131.4453ms,3.3
+ 131.4454ms,0.0V 131.4599ms,0.0
+ 131.4600ms,3.3V 131.4653ms,3.3
+ 131.4654ms,0.0V 131.4799ms,0.0
+ 131.4800ms,3.3V 131.4853ms,3.3
+ 131.4854ms,0.0V 131.4999ms,0.0
+ 131.5000ms,3.3V 131.5053ms,3.3
+ 131.5054ms,0.0V 131.5199ms,0.0
+ 131.5200ms,3.3V 131.5253ms,3.3
+ 131.5254ms,0.0V 131.5399ms,0.0
+ 131.5400ms,3.3V 131.5453ms,3.3
+ 131.5454ms,0.0V 131.5599ms,0.0
+ 131.5600ms,3.3V 131.5653ms,3.3
+ 131.5654ms,0.0V 131.5799ms,0.0
+ 131.5800ms,3.3V 131.5853ms,3.3
+ 131.5854ms,0.0V 131.5999ms,0.0
+ 131.6000ms,3.3V 131.6053ms,3.3
+ 131.6054ms,0.0V 131.6199ms,0.0
+ 131.6200ms,3.3V 131.6253ms,3.3
+ 131.6254ms,0.0V 131.6399ms,0.0
+ 131.6400ms,3.3V 131.6453ms,3.3
+ 131.6454ms,0.0V 131.6599ms,0.0
+ 131.6600ms,3.3V 131.6653ms,3.3
+ 131.6654ms,0.0V 131.6799ms,0.0
+ 131.6800ms,3.3V 131.6853ms,3.3
+ 131.6854ms,0.0V 131.6999ms,0.0
+ 131.7000ms,3.3V 131.7053ms,3.3
+ 131.7054ms,0.0V 131.7199ms,0.0
+ 131.7200ms,3.3V 131.7253ms,3.3
+ 131.7254ms,0.0V 131.7399ms,0.0
+ 131.7400ms,3.3V 131.7453ms,3.3
+ 131.7454ms,0.0V 131.7599ms,0.0
+ 131.7600ms,3.3V 131.7653ms,3.3
+ 131.7654ms,0.0V 131.7799ms,0.0
+ 131.7800ms,3.3V 131.7853ms,3.3
+ 131.7854ms,0.0V 131.7999ms,0.0
+ 131.8000ms,3.3V 131.8053ms,3.3
+ 131.8054ms,0.0V 131.8199ms,0.0
+ 131.8200ms,3.3V 131.8253ms,3.3
+ 131.8254ms,0.0V 131.8399ms,0.0
+ 131.8400ms,3.3V 131.8453ms,3.3
+ 131.8454ms,0.0V 131.8599ms,0.0
+ 131.8600ms,3.3V 131.8653ms,3.3
+ 131.8654ms,0.0V 131.8799ms,0.0
+ 131.8800ms,3.3V 131.8853ms,3.3
+ 131.8854ms,0.0V 131.8999ms,0.0
+ 131.9000ms,3.3V 131.9053ms,3.3
+ 131.9054ms,0.0V 131.9199ms,0.0
+ 131.9200ms,3.3V 131.9253ms,3.3
+ 131.9254ms,0.0V 131.9399ms,0.0
+ 131.9400ms,3.3V 131.9453ms,3.3
+ 131.9454ms,0.0V 131.9599ms,0.0
+ 131.9600ms,3.3V 131.9653ms,3.3
+ 131.9654ms,0.0V 131.9799ms,0.0
+ 131.9800ms,3.3V 131.9853ms,3.3
+ 131.9854ms,0.0V 131.9999ms,0.0
+ 132.0000ms,3.3V 132.0053ms,3.3
+ 132.0054ms,0.0V 132.0199ms,0.0
+ 132.0200ms,3.3V 132.0253ms,3.3
+ 132.0254ms,0.0V 132.0399ms,0.0
+ 132.0400ms,3.3V 132.0453ms,3.3
+ 132.0454ms,0.0V 132.0599ms,0.0
+ 132.0600ms,3.3V 132.0653ms,3.3
+ 132.0654ms,0.0V 132.0799ms,0.0
+ 132.0800ms,3.3V 132.0853ms,3.3
+ 132.0854ms,0.0V 132.0999ms,0.0
+ 132.1000ms,3.3V 132.1053ms,3.3
+ 132.1054ms,0.0V 132.1199ms,0.0
+ 132.1200ms,3.3V 132.1253ms,3.3
+ 132.1254ms,0.0V 132.1399ms,0.0
+ 132.1400ms,3.3V 132.1453ms,3.3
+ 132.1454ms,0.0V 132.1599ms,0.0
+ 132.1600ms,3.3V 132.1653ms,3.3
+ 132.1654ms,0.0V 132.1799ms,0.0
+ 132.1800ms,3.3V 132.1853ms,3.3
+ 132.1854ms,0.0V 132.1999ms,0.0
+ 132.2000ms,3.3V 132.2053ms,3.3
+ 132.2054ms,0.0V 132.2199ms,0.0
+ 132.2200ms,3.3V 132.2253ms,3.3
+ 132.2254ms,0.0V 132.2399ms,0.0
+ 132.2400ms,3.3V 132.2453ms,3.3
+ 132.2454ms,0.0V 132.2599ms,0.0
+ 132.2600ms,3.3V 132.2653ms,3.3
+ 132.2654ms,0.0V 132.2799ms,0.0
+ 132.2800ms,3.3V 132.2853ms,3.3
+ 132.2854ms,0.0V 132.2999ms,0.0
+ 132.3000ms,3.3V 132.3053ms,3.3
+ 132.3054ms,0.0V 132.3199ms,0.0
+ 132.3200ms,3.3V 132.3253ms,3.3
+ 132.3254ms,0.0V 132.3399ms,0.0
+ 132.3400ms,3.3V 132.3453ms,3.3
+ 132.3454ms,0.0V 132.3599ms,0.0
+ 132.3600ms,3.3V 132.3653ms,3.3
+ 132.3654ms,0.0V 132.3799ms,0.0
+ 132.3800ms,3.3V 132.3853ms,3.3
+ 132.3854ms,0.0V 132.3999ms,0.0
+ 132.4000ms,3.3V 132.4053ms,3.3
+ 132.4054ms,0.0V 132.4199ms,0.0
+ 132.4200ms,3.3V 132.4253ms,3.3
+ 132.4254ms,0.0V 132.4399ms,0.0
+ 132.4400ms,3.3V 132.4453ms,3.3
+ 132.4454ms,0.0V 132.4599ms,0.0
+ 132.4600ms,3.3V 132.4653ms,3.3
+ 132.4654ms,0.0V 132.4799ms,0.0
+ 132.4800ms,3.3V 132.4853ms,3.3
+ 132.4854ms,0.0V 132.4999ms,0.0
+ 132.5000ms,3.3V 132.5053ms,3.3
+ 132.5054ms,0.0V 132.5199ms,0.0
+ 132.5200ms,3.3V 132.5253ms,3.3
+ 132.5254ms,0.0V 132.5399ms,0.0
+ 132.5400ms,3.3V 132.5453ms,3.3
+ 132.5454ms,0.0V 132.5599ms,0.0
+ 132.5600ms,3.3V 132.5653ms,3.3
+ 132.5654ms,0.0V 132.5799ms,0.0
+ 132.5800ms,3.3V 132.5853ms,3.3
+ 132.5854ms,0.0V 132.5999ms,0.0
+ 132.6000ms,3.3V 132.6053ms,3.3
+ 132.6054ms,0.0V 132.6199ms,0.0
+ 132.6200ms,3.3V 132.6253ms,3.3
+ 132.6254ms,0.0V 132.6399ms,0.0
+ 132.6400ms,3.3V 132.6453ms,3.3
+ 132.6454ms,0.0V 132.6599ms,0.0
+ 132.6600ms,3.3V 132.6653ms,3.3
+ 132.6654ms,0.0V 132.6799ms,0.0
+ 132.6800ms,3.3V 132.6853ms,3.3
+ 132.6854ms,0.0V 132.6999ms,0.0
+ 132.7000ms,3.3V 132.7053ms,3.3
+ 132.7054ms,0.0V 132.7199ms,0.0
+ 132.7200ms,3.3V 132.7253ms,3.3
+ 132.7254ms,0.0V 132.7399ms,0.0
+ 132.7400ms,3.3V 132.7453ms,3.3
+ 132.7454ms,0.0V 132.7599ms,0.0
+ 132.7600ms,3.3V 132.7653ms,3.3
+ 132.7654ms,0.0V 132.7799ms,0.0
+ 132.7800ms,3.3V 132.7853ms,3.3
+ 132.7854ms,0.0V 132.7999ms,0.0
+ 132.8000ms,3.3V 132.8053ms,3.3
+ 132.8054ms,0.0V 132.8199ms,0.0
+ 132.8200ms,3.3V 132.8253ms,3.3
+ 132.8254ms,0.0V 132.8399ms,0.0
+ 132.8400ms,3.3V 132.8453ms,3.3
+ 132.8454ms,0.0V 132.8599ms,0.0
+ 132.8600ms,3.3V 132.8653ms,3.3
+ 132.8654ms,0.0V 132.8799ms,0.0
+ 132.8800ms,3.3V 132.8853ms,3.3
+ 132.8854ms,0.0V 132.8999ms,0.0
+ 132.9000ms,3.3V 132.9053ms,3.3
+ 132.9054ms,0.0V 132.9199ms,0.0
+ 132.9200ms,3.3V 132.9253ms,3.3
+ 132.9254ms,0.0V 132.9399ms,0.0
+ 132.9400ms,3.3V 132.9453ms,3.3
+ 132.9454ms,0.0V 132.9599ms,0.0
+ 132.9600ms,3.3V 132.9653ms,3.3
+ 132.9654ms,0.0V 132.9799ms,0.0
+ 132.9800ms,3.3V 132.9853ms,3.3
+ 132.9854ms,0.0V 132.9999ms,0.0
+ 133.0000ms,3.3V 133.0053ms,3.3
+ 133.0054ms,0.0V 133.0199ms,0.0
+ 133.0200ms,3.3V 133.0253ms,3.3
+ 133.0254ms,0.0V 133.0399ms,0.0
+ 133.0400ms,3.3V 133.0453ms,3.3
+ 133.0454ms,0.0V 133.0599ms,0.0
+ 133.0600ms,3.3V 133.0653ms,3.3
+ 133.0654ms,0.0V 133.0799ms,0.0
+ 133.0800ms,3.3V 133.0853ms,3.3
+ 133.0854ms,0.0V 133.0999ms,0.0
+ 133.1000ms,3.3V 133.1053ms,3.3
+ 133.1054ms,0.0V 133.1199ms,0.0
+ 133.1200ms,3.3V 133.1253ms,3.3
+ 133.1254ms,0.0V 133.1399ms,0.0
+ 133.1400ms,3.3V 133.1453ms,3.3
+ 133.1454ms,0.0V 133.1599ms,0.0
+ 133.1600ms,3.3V 133.1653ms,3.3
+ 133.1654ms,0.0V 133.1799ms,0.0
+ 133.1800ms,3.3V 133.1853ms,3.3
+ 133.1854ms,0.0V 133.1999ms,0.0
+ 133.2000ms,3.3V 133.2053ms,3.3
+ 133.2054ms,0.0V 133.2199ms,0.0
+ 133.2200ms,3.3V 133.2253ms,3.3
+ 133.2254ms,0.0V 133.2399ms,0.0
+ 133.2400ms,3.3V 133.2453ms,3.3
+ 133.2454ms,0.0V 133.2599ms,0.0
+ 133.2600ms,3.3V 133.2653ms,3.3
+ 133.2654ms,0.0V 133.2799ms,0.0
+ 133.2800ms,3.3V 133.2853ms,3.3
+ 133.2854ms,0.0V 133.2999ms,0.0
+ 133.3000ms,3.3V 133.3053ms,3.3
+ 133.3054ms,0.0V 133.3199ms,0.0
+ 133.3200ms,3.3V 133.3253ms,3.3
+ 133.3254ms,0.0V 133.3399ms,0.0
+ 133.3400ms,3.3V 133.3453ms,3.3
+ 133.3454ms,0.0V 133.3599ms,0.0
+ 133.3600ms,3.3V 133.3653ms,3.3
+ 133.3654ms,0.0V 133.3799ms,0.0
+ 133.3800ms,3.3V 133.3853ms,3.3
+ 133.3854ms,0.0V 133.3999ms,0.0
+ 133.4000ms,3.3V 133.4053ms,3.3
+ 133.4054ms,0.0V 133.4199ms,0.0
+ 133.4200ms,3.3V 133.4253ms,3.3
+ 133.4254ms,0.0V 133.4399ms,0.0
+ 133.4400ms,3.3V 133.4453ms,3.3
+ 133.4454ms,0.0V 133.4599ms,0.0
+ 133.4600ms,3.3V 133.4653ms,3.3
+ 133.4654ms,0.0V 133.4799ms,0.0
+ 133.4800ms,3.3V 133.4853ms,3.3
+ 133.4854ms,0.0V 133.4999ms,0.0
+ 133.5000ms,3.3V 133.5053ms,3.3
+ 133.5054ms,0.0V 133.5199ms,0.0
+ 133.5200ms,3.3V 133.5253ms,3.3
+ 133.5254ms,0.0V 133.5399ms,0.0
+ 133.5400ms,3.3V 133.5453ms,3.3
+ 133.5454ms,0.0V 133.5599ms,0.0
+ 133.5600ms,3.3V 133.5653ms,3.3
+ 133.5654ms,0.0V 133.5799ms,0.0
+ 133.5800ms,3.3V 133.5853ms,3.3
+ 133.5854ms,0.0V 133.5999ms,0.0
+ 133.6000ms,3.3V 133.6053ms,3.3
+ 133.6054ms,0.0V 133.6199ms,0.0
+ 133.6200ms,3.3V 133.6253ms,3.3
+ 133.6254ms,0.0V 133.6399ms,0.0
+ 133.6400ms,3.3V 133.6453ms,3.3
+ 133.6454ms,0.0V 133.6599ms,0.0
+ 133.6600ms,3.3V 133.6653ms,3.3
+ 133.6654ms,0.0V 133.6799ms,0.0
+ 133.6800ms,3.3V 133.6853ms,3.3
+ 133.6854ms,0.0V 133.6999ms,0.0
+ 133.7000ms,3.3V 133.7053ms,3.3
+ 133.7054ms,0.0V 133.7199ms,0.0
+ 133.7200ms,3.3V 133.7253ms,3.3
+ 133.7254ms,0.0V 133.7399ms,0.0
+ 133.7400ms,3.3V 133.7453ms,3.3
+ 133.7454ms,0.0V 133.7599ms,0.0
+ 133.7600ms,3.3V 133.7653ms,3.3
+ 133.7654ms,0.0V 133.7799ms,0.0
+ 133.7800ms,3.3V 133.7853ms,3.3
+ 133.7854ms,0.0V 133.7999ms,0.0
+ 133.8000ms,3.3V 133.8053ms,3.3
+ 133.8054ms,0.0V 133.8199ms,0.0
+ 133.8200ms,3.3V 133.8253ms,3.3
+ 133.8254ms,0.0V 133.8399ms,0.0
+ 133.8400ms,3.3V 133.8453ms,3.3
+ 133.8454ms,0.0V 133.8599ms,0.0
+ 133.8600ms,3.3V 133.8653ms,3.3
+ 133.8654ms,0.0V 133.8799ms,0.0
+ 133.8800ms,3.3V 133.8853ms,3.3
+ 133.8854ms,0.0V 133.8999ms,0.0
+ 133.9000ms,3.3V 133.9053ms,3.3
+ 133.9054ms,0.0V 133.9199ms,0.0
+ 133.9200ms,3.3V 133.9253ms,3.3
+ 133.9254ms,0.0V 133.9399ms,0.0
+ 133.9400ms,3.3V 133.9453ms,3.3
+ 133.9454ms,0.0V 133.9599ms,0.0
+ 133.9600ms,3.3V 133.9653ms,3.3
+ 133.9654ms,0.0V 133.9799ms,0.0
+ 133.9800ms,3.3V 133.9853ms,3.3
+ 133.9854ms,0.0V 133.9999ms,0.0
+ 134.0000ms,3.3V 134.0053ms,3.3
+ 134.0054ms,0.0V 134.0199ms,0.0
+ 134.0200ms,3.3V 134.0253ms,3.3
+ 134.0254ms,0.0V 134.0399ms,0.0
+ 134.0400ms,3.3V 134.0453ms,3.3
+ 134.0454ms,0.0V 134.0599ms,0.0
+ 134.0600ms,3.3V 134.0653ms,3.3
+ 134.0654ms,0.0V 134.0799ms,0.0
+ 134.0800ms,3.3V 134.0853ms,3.3
+ 134.0854ms,0.0V 134.0999ms,0.0
+ 134.1000ms,3.3V 134.1053ms,3.3
+ 134.1054ms,0.0V 134.1199ms,0.0
+ 134.1200ms,3.3V 134.1253ms,3.3
+ 134.1254ms,0.0V 134.1399ms,0.0
+ 134.1400ms,3.3V 134.1453ms,3.3
+ 134.1454ms,0.0V 134.1599ms,0.0
+ 134.1600ms,3.3V 134.1653ms,3.3
+ 134.1654ms,0.0V 134.1799ms,0.0
+ 134.1800ms,3.3V 134.1853ms,3.3
+ 134.1854ms,0.0V 134.1999ms,0.0
+ 134.2000ms,3.3V 134.2053ms,3.3
+ 134.2054ms,0.0V 134.2199ms,0.0
+ 134.2200ms,3.3V 134.2253ms,3.3
+ 134.2254ms,0.0V 134.2399ms,0.0
+ 134.2400ms,3.3V 134.2453ms,3.3
+ 134.2454ms,0.0V 134.2599ms,0.0
+ 134.2600ms,3.3V 134.2653ms,3.3
+ 134.2654ms,0.0V 134.2799ms,0.0
+ 134.2800ms,3.3V 134.2853ms,3.3
+ 134.2854ms,0.0V 134.2999ms,0.0
+ 134.3000ms,3.3V 134.3053ms,3.3
+ 134.3054ms,0.0V 134.3199ms,0.0
+ 134.3200ms,3.3V 134.3253ms,3.3
+ 134.3254ms,0.0V 134.3399ms,0.0
+ 134.3400ms,3.3V 134.3453ms,3.3
+ 134.3454ms,0.0V 134.3599ms,0.0
+ 134.3600ms,3.3V 134.3653ms,3.3
+ 134.3654ms,0.0V 134.3799ms,0.0
+ 134.3800ms,3.3V 134.3853ms,3.3
+ 134.3854ms,0.0V 134.3999ms,0.0
+ 134.4000ms,3.3V 134.4053ms,3.3
+ 134.4054ms,0.0V 134.4199ms,0.0
+ 134.4200ms,3.3V 134.4253ms,3.3
+ 134.4254ms,0.0V 134.4399ms,0.0
+ 134.4400ms,3.3V 134.4453ms,3.3
+ 134.4454ms,0.0V 134.4599ms,0.0
+ 134.4600ms,3.3V 134.4653ms,3.3
+ 134.4654ms,0.0V 134.4799ms,0.0
+ 134.4800ms,3.3V 134.4853ms,3.3
+ 134.4854ms,0.0V 134.4999ms,0.0
+ 134.5000ms,3.3V 134.5053ms,3.3
+ 134.5054ms,0.0V 134.5199ms,0.0
+ 134.5200ms,3.3V 134.5253ms,3.3
+ 134.5254ms,0.0V 134.5399ms,0.0
+ 134.5400ms,3.3V 134.5453ms,3.3
+ 134.5454ms,0.0V 134.5599ms,0.0
+ 134.5600ms,3.3V 134.5653ms,3.3
+ 134.5654ms,0.0V 134.5799ms,0.0
+ 134.5800ms,3.3V 134.5853ms,3.3
+ 134.5854ms,0.0V 134.5999ms,0.0
+ 134.6000ms,3.3V 134.6053ms,3.3
+ 134.6054ms,0.0V 134.6199ms,0.0
+ 134.6200ms,3.3V 134.6253ms,3.3
+ 134.6254ms,0.0V 134.6399ms,0.0
+ 134.6400ms,3.3V 134.6453ms,3.3
+ 134.6454ms,0.0V 134.6599ms,0.0
+ 134.6600ms,3.3V 134.6653ms,3.3
+ 134.6654ms,0.0V 134.6799ms,0.0
+ 134.6800ms,3.3V 134.6853ms,3.3
+ 134.6854ms,0.0V 134.6999ms,0.0
+ 134.7000ms,3.3V 134.7053ms,3.3
+ 134.7054ms,0.0V 134.7199ms,0.0
+ 134.7200ms,3.3V 134.7253ms,3.3
+ 134.7254ms,0.0V 134.7399ms,0.0
+ 134.7400ms,3.3V 134.7453ms,3.3
+ 134.7454ms,0.0V 134.7599ms,0.0
+ 134.7600ms,3.3V 134.7653ms,3.3
+ 134.7654ms,0.0V 134.7799ms,0.0
+ 134.7800ms,3.3V 134.7853ms,3.3
+ 134.7854ms,0.0V 134.7999ms,0.0
+ 134.8000ms,3.3V 134.8053ms,3.3
+ 134.8054ms,0.0V 134.8199ms,0.0
+ 134.8200ms,3.3V 134.8253ms,3.3
+ 134.8254ms,0.0V 134.8399ms,0.0
+ 134.8400ms,3.3V 134.8453ms,3.3
+ 134.8454ms,0.0V 134.8599ms,0.0
+ 134.8600ms,3.3V 134.8653ms,3.3
+ 134.8654ms,0.0V 134.8799ms,0.0
+ 134.8800ms,3.3V 134.8853ms,3.3
+ 134.8854ms,0.0V 134.8999ms,0.0
+ 134.9000ms,3.3V 134.9053ms,3.3
+ 134.9054ms,0.0V 134.9199ms,0.0
+ 134.9200ms,3.3V 134.9253ms,3.3
+ 134.9254ms,0.0V 134.9399ms,0.0
+ 134.9400ms,3.3V 134.9453ms,3.3
+ 134.9454ms,0.0V 134.9599ms,0.0
+ 134.9600ms,3.3V 134.9653ms,3.3
+ 134.9654ms,0.0V 134.9799ms,0.0
+ 134.9800ms,3.3V 134.9853ms,3.3
+ 134.9854ms,0.0V 134.9999ms,0.0
+ 135.0000ms,3.3V 135.0053ms,3.3
+ 135.0054ms,0.0V 135.0199ms,0.0
+ 135.0200ms,3.3V 135.0253ms,3.3
+ 135.0254ms,0.0V 135.0399ms,0.0
+ 135.0400ms,3.3V 135.0453ms,3.3
+ 135.0454ms,0.0V 135.0599ms,0.0
+ 135.0600ms,3.3V 135.0653ms,3.3
+ 135.0654ms,0.0V 135.0799ms,0.0
+ 135.0800ms,3.3V 135.0853ms,3.3
+ 135.0854ms,0.0V 135.0999ms,0.0
+ 135.1000ms,3.3V 135.1053ms,3.3
+ 135.1054ms,0.0V 135.1199ms,0.0
+ 135.1200ms,3.3V 135.1253ms,3.3
+ 135.1254ms,0.0V 135.1399ms,0.0
+ 135.1400ms,3.3V 135.1453ms,3.3
+ 135.1454ms,0.0V 135.1599ms,0.0
+ 135.1600ms,3.3V 135.1653ms,3.3
+ 135.1654ms,0.0V 135.1799ms,0.0
+ 135.1800ms,3.3V 135.1853ms,3.3
+ 135.1854ms,0.0V 135.1999ms,0.0
+ 135.2000ms,3.3V 135.2053ms,3.3
+ 135.2054ms,0.0V 135.2199ms,0.0
+ 135.2200ms,3.3V 135.2253ms,3.3
+ 135.2254ms,0.0V 135.2399ms,0.0
+ 135.2400ms,3.3V 135.2453ms,3.3
+ 135.2454ms,0.0V 135.2599ms,0.0
+ 135.2600ms,3.3V 135.2653ms,3.3
+ 135.2654ms,0.0V 135.2799ms,0.0
+ 135.2800ms,3.3V 135.2853ms,3.3
+ 135.2854ms,0.0V 135.2999ms,0.0
+ 135.3000ms,3.3V 135.3053ms,3.3
+ 135.3054ms,0.0V 135.3199ms,0.0
+ 135.3200ms,3.3V 135.3253ms,3.3
+ 135.3254ms,0.0V 135.3399ms,0.0
+ 135.3400ms,3.3V 135.3453ms,3.3
+ 135.3454ms,0.0V 135.3599ms,0.0
+ 135.3600ms,3.3V 135.3655ms,3.3
+ 135.3656ms,0.0V 135.3799ms,0.0
+ 135.3800ms,3.3V 135.3855ms,3.3
+ 135.3856ms,0.0V 135.3999ms,0.0
+ 135.4000ms,3.3V 135.4055ms,3.3
+ 135.4056ms,0.0V 135.4199ms,0.0
+ 135.4200ms,3.3V 135.4255ms,3.3
+ 135.4256ms,0.0V 135.4399ms,0.0
+ 135.4400ms,3.3V 135.4455ms,3.3
+ 135.4456ms,0.0V 135.4599ms,0.0
+ 135.4600ms,3.3V 135.4655ms,3.3
+ 135.4656ms,0.0V 135.4799ms,0.0
+ 135.4800ms,3.3V 135.4855ms,3.3
+ 135.4856ms,0.0V 135.4999ms,0.0
+ 135.5000ms,3.3V 135.5055ms,3.3
+ 135.5056ms,0.0V 135.5199ms,0.0
+ 135.5200ms,3.3V 135.5255ms,3.3
+ 135.5256ms,0.0V 135.5399ms,0.0
+ 135.5400ms,3.3V 135.5455ms,3.3
+ 135.5456ms,0.0V 135.5599ms,0.0
+ 135.5600ms,3.3V 135.5655ms,3.3
+ 135.5656ms,0.0V 135.5799ms,0.0
+ 135.5800ms,3.3V 135.5855ms,3.3
+ 135.5856ms,0.0V 135.5999ms,0.0
+ 135.6000ms,3.3V 135.6055ms,3.3
+ 135.6056ms,0.0V 135.6199ms,0.0
+ 135.6200ms,3.3V 135.6255ms,3.3
+ 135.6256ms,0.0V 135.6399ms,0.0
+ 135.6400ms,3.3V 135.6455ms,3.3
+ 135.6456ms,0.0V 135.6599ms,0.0
+ 135.6600ms,3.3V 135.6655ms,3.3
+ 135.6656ms,0.0V 135.6799ms,0.0
+ 135.6800ms,3.3V 135.6855ms,3.3
+ 135.6856ms,0.0V 135.6999ms,0.0
+ 135.7000ms,3.3V 135.7055ms,3.3
+ 135.7056ms,0.0V 135.7199ms,0.0
+ 135.7200ms,3.3V 135.7255ms,3.3
+ 135.7256ms,0.0V 135.7399ms,0.0
+ 135.7400ms,3.3V 135.7455ms,3.3
+ 135.7456ms,0.0V 135.7599ms,0.0
+ 135.7600ms,3.3V 135.7655ms,3.3
+ 135.7656ms,0.0V 135.7799ms,0.0
+ 135.7800ms,3.3V 135.7855ms,3.3
+ 135.7856ms,0.0V 135.7999ms,0.0
+ 135.8000ms,3.3V 135.8055ms,3.3
+ 135.8056ms,0.0V 135.8199ms,0.0
+ 135.8200ms,3.3V 135.8255ms,3.3
+ 135.8256ms,0.0V 135.8399ms,0.0
+ 135.8400ms,3.3V 135.8455ms,3.3
+ 135.8456ms,0.0V 135.8599ms,0.0
+ 135.8600ms,3.3V 135.8655ms,3.3
+ 135.8656ms,0.0V 135.8799ms,0.0
+ 135.8800ms,3.3V 135.8855ms,3.3
+ 135.8856ms,0.0V 135.8999ms,0.0
+ 135.9000ms,3.3V 135.9055ms,3.3
+ 135.9056ms,0.0V 135.9199ms,0.0
+ 135.9200ms,3.3V 135.9255ms,3.3
+ 135.9256ms,0.0V 135.9399ms,0.0
+ 135.9400ms,3.3V 135.9455ms,3.3
+ 135.9456ms,0.0V 135.9599ms,0.0
+ 135.9600ms,3.3V 135.9655ms,3.3
+ 135.9656ms,0.0V 135.9799ms,0.0
+ 135.9800ms,3.3V 135.9855ms,3.3
+ 135.9856ms,0.0V 135.9999ms,0.0
+ 136.0000ms,3.3V 136.0055ms,3.3
+ 136.0056ms,0.0V 136.0199ms,0.0
+ 136.0200ms,3.3V 136.0255ms,3.3
+ 136.0256ms,0.0V 136.0399ms,0.0
+ 136.0400ms,3.3V 136.0455ms,3.3
+ 136.0456ms,0.0V 136.0599ms,0.0
+ 136.0600ms,3.3V 136.0655ms,3.3
+ 136.0656ms,0.0V 136.0799ms,0.0
+ 136.0800ms,3.3V 136.0855ms,3.3
+ 136.0856ms,0.0V 136.0999ms,0.0
+ 136.1000ms,3.3V 136.1055ms,3.3
+ 136.1056ms,0.0V 136.1199ms,0.0
+ 136.1200ms,3.3V 136.1255ms,3.3
+ 136.1256ms,0.0V 136.1399ms,0.0
+ 136.1400ms,3.3V 136.1455ms,3.3
+ 136.1456ms,0.0V 136.1599ms,0.0
+ 136.1600ms,3.3V 136.1655ms,3.3
+ 136.1656ms,0.0V 136.1799ms,0.0
+ 136.1800ms,3.3V 136.1855ms,3.3
+ 136.1856ms,0.0V 136.1999ms,0.0
+ 136.2000ms,3.3V 136.2055ms,3.3
+ 136.2056ms,0.0V 136.2199ms,0.0
+ 136.2200ms,3.3V 136.2255ms,3.3
+ 136.2256ms,0.0V 136.2399ms,0.0
+ 136.2400ms,3.3V 136.2455ms,3.3
+ 136.2456ms,0.0V 136.2599ms,0.0
+ 136.2600ms,3.3V 136.2655ms,3.3
+ 136.2656ms,0.0V 136.2799ms,0.0
+ 136.2800ms,3.3V 136.2855ms,3.3
+ 136.2856ms,0.0V 136.2999ms,0.0
+ 136.3000ms,3.3V 136.3055ms,3.3
+ 136.3056ms,0.0V 136.3199ms,0.0
+ 136.3200ms,3.3V 136.3255ms,3.3
+ 136.3256ms,0.0V 136.3399ms,0.0
+ 136.3400ms,3.3V 136.3455ms,3.3
+ 136.3456ms,0.0V 136.3599ms,0.0
+ 136.3600ms,3.3V 136.3655ms,3.3
+ 136.3656ms,0.0V 136.3799ms,0.0
+ 136.3800ms,3.3V 136.3855ms,3.3
+ 136.3856ms,0.0V 136.3999ms,0.0
+ 136.4000ms,3.3V 136.4055ms,3.3
+ 136.4056ms,0.0V 136.4199ms,0.0
+ 136.4200ms,3.3V 136.4255ms,3.3
+ 136.4256ms,0.0V 136.4399ms,0.0
+ 136.4400ms,3.3V 136.4455ms,3.3
+ 136.4456ms,0.0V 136.4599ms,0.0
+ 136.4600ms,3.3V 136.4655ms,3.3
+ 136.4656ms,0.0V 136.4799ms,0.0
+ 136.4800ms,3.3V 136.4855ms,3.3
+ 136.4856ms,0.0V 136.4999ms,0.0
+ 136.5000ms,3.3V 136.5055ms,3.3
+ 136.5056ms,0.0V 136.5199ms,0.0
+ 136.5200ms,3.3V 136.5255ms,3.3
+ 136.5256ms,0.0V 136.5399ms,0.0
+ 136.5400ms,3.3V 136.5455ms,3.3
+ 136.5456ms,0.0V 136.5599ms,0.0
+ 136.5600ms,3.3V 136.5655ms,3.3
+ 136.5656ms,0.0V 136.5799ms,0.0
+ 136.5800ms,3.3V 136.5855ms,3.3
+ 136.5856ms,0.0V 136.5999ms,0.0
+ 136.6000ms,3.3V 136.6055ms,3.3
+ 136.6056ms,0.0V 136.6199ms,0.0
+ 136.6200ms,3.3V 136.6255ms,3.3
+ 136.6256ms,0.0V 136.6399ms,0.0
+ 136.6400ms,3.3V 136.6455ms,3.3
+ 136.6456ms,0.0V 136.6599ms,0.0
+ 136.6600ms,3.3V 136.6655ms,3.3
+ 136.6656ms,0.0V 136.6799ms,0.0
+ 136.6800ms,3.3V 136.6855ms,3.3
+ 136.6856ms,0.0V 136.6999ms,0.0
+ 136.7000ms,3.3V 136.7055ms,3.3
+ 136.7056ms,0.0V 136.7199ms,0.0
+ 136.7200ms,3.3V 136.7255ms,3.3
+ 136.7256ms,0.0V 136.7399ms,0.0
+ 136.7400ms,3.3V 136.7455ms,3.3
+ 136.7456ms,0.0V 136.7599ms,0.0
+ 136.7600ms,3.3V 136.7655ms,3.3
+ 136.7656ms,0.0V 136.7799ms,0.0
+ 136.7800ms,3.3V 136.7855ms,3.3
+ 136.7856ms,0.0V 136.7999ms,0.0
+ 136.8000ms,3.3V 136.8055ms,3.3
+ 136.8056ms,0.0V 136.8199ms,0.0
+ 136.8200ms,3.3V 136.8255ms,3.3
+ 136.8256ms,0.0V 136.8399ms,0.0
+ 136.8400ms,3.3V 136.8455ms,3.3
+ 136.8456ms,0.0V 136.8599ms,0.0
+ 136.8600ms,3.3V 136.8655ms,3.3
+ 136.8656ms,0.0V 136.8799ms,0.0
+ 136.8800ms,3.3V 136.8855ms,3.3
+ 136.8856ms,0.0V 136.8999ms,0.0
+ 136.9000ms,3.3V 136.9055ms,3.3
+ 136.9056ms,0.0V 136.9199ms,0.0
+ 136.9200ms,3.3V 136.9255ms,3.3
+ 136.9256ms,0.0V 136.9399ms,0.0
+ 136.9400ms,3.3V 136.9455ms,3.3
+ 136.9456ms,0.0V 136.9599ms,0.0
+ 136.9600ms,3.3V 136.9655ms,3.3
+ 136.9656ms,0.0V 136.9799ms,0.0
+ 136.9800ms,3.3V 136.9855ms,3.3
+ 136.9856ms,0.0V 136.9999ms,0.0
+ 137.0000ms,3.3V 137.0055ms,3.3
+ 137.0056ms,0.0V 137.0199ms,0.0
+ 137.0200ms,3.3V 137.0255ms,3.3
+ 137.0256ms,0.0V 137.0399ms,0.0
+ 137.0400ms,3.3V 137.0455ms,3.3
+ 137.0456ms,0.0V 137.0599ms,0.0
+ 137.0600ms,3.3V 137.0655ms,3.3
+ 137.0656ms,0.0V 137.0799ms,0.0
+ 137.0800ms,3.3V 137.0855ms,3.3
+ 137.0856ms,0.0V 137.0999ms,0.0
+ 137.1000ms,3.3V 137.1055ms,3.3
+ 137.1056ms,0.0V 137.1199ms,0.0
+ 137.1200ms,3.3V 137.1255ms,3.3
+ 137.1256ms,0.0V 137.1399ms,0.0
+ 137.1400ms,3.3V 137.1455ms,3.3
+ 137.1456ms,0.0V 137.1599ms,0.0
+ 137.1600ms,3.3V 137.1655ms,3.3
+ 137.1656ms,0.0V 137.1799ms,0.0
+ 137.1800ms,3.3V 137.1855ms,3.3
+ 137.1856ms,0.0V 137.1999ms,0.0
+ 137.2000ms,3.3V 137.2055ms,3.3
+ 137.2056ms,0.0V 137.2199ms,0.0
+ 137.2200ms,3.3V 137.2255ms,3.3
+ 137.2256ms,0.0V 137.2399ms,0.0
+ 137.2400ms,3.3V 137.2455ms,3.3
+ 137.2456ms,0.0V 137.2599ms,0.0
+ 137.2600ms,3.3V 137.2655ms,3.3
+ 137.2656ms,0.0V 137.2799ms,0.0
+ 137.2800ms,3.3V 137.2855ms,3.3
+ 137.2856ms,0.0V 137.2999ms,0.0
+ 137.3000ms,3.3V 137.3055ms,3.3
+ 137.3056ms,0.0V 137.3199ms,0.0
+ 137.3200ms,3.3V 137.3255ms,3.3
+ 137.3256ms,0.0V 137.3399ms,0.0
+ 137.3400ms,3.3V 137.3455ms,3.3
+ 137.3456ms,0.0V 137.3599ms,0.0
+ 137.3600ms,3.3V 137.3655ms,3.3
+ 137.3656ms,0.0V 137.3799ms,0.0
+ 137.3800ms,3.3V 137.3855ms,3.3
+ 137.3856ms,0.0V 137.3999ms,0.0
+ 137.4000ms,3.3V 137.4055ms,3.3
+ 137.4056ms,0.0V 137.4199ms,0.0
+ 137.4200ms,3.3V 137.4255ms,3.3
+ 137.4256ms,0.0V 137.4399ms,0.0
+ 137.4400ms,3.3V 137.4455ms,3.3
+ 137.4456ms,0.0V 137.4599ms,0.0
+ 137.4600ms,3.3V 137.4655ms,3.3
+ 137.4656ms,0.0V 137.4799ms,0.0
+ 137.4800ms,3.3V 137.4855ms,3.3
+ 137.4856ms,0.0V 137.4999ms,0.0
+ 137.5000ms,3.3V 137.5055ms,3.3
+ 137.5056ms,0.0V 137.5199ms,0.0
+ 137.5200ms,3.3V 137.5255ms,3.3
+ 137.5256ms,0.0V 137.5399ms,0.0
+ 137.5400ms,3.3V 137.5455ms,3.3
+ 137.5456ms,0.0V 137.5599ms,0.0
+ 137.5600ms,3.3V 137.5655ms,3.3
+ 137.5656ms,0.0V 137.5799ms,0.0
+ 137.5800ms,3.3V 137.5855ms,3.3
+ 137.5856ms,0.0V 137.5999ms,0.0
+ 137.6000ms,3.3V 137.6055ms,3.3
+ 137.6056ms,0.0V 137.6199ms,0.0
+ 137.6200ms,3.3V 137.6255ms,3.3
+ 137.6256ms,0.0V 137.6399ms,0.0
+ 137.6400ms,3.3V 137.6455ms,3.3
+ 137.6456ms,0.0V 137.6599ms,0.0
+ 137.6600ms,3.3V 137.6655ms,3.3
+ 137.6656ms,0.0V 137.6799ms,0.0
+ 137.6800ms,3.3V 137.6855ms,3.3
+ 137.6856ms,0.0V 137.6999ms,0.0
+ 137.7000ms,3.3V 137.7055ms,3.3
+ 137.7056ms,0.0V 137.7199ms,0.0
+ 137.7200ms,3.3V 137.7255ms,3.3
+ 137.7256ms,0.0V 137.7399ms,0.0
+ 137.7400ms,3.3V 137.7455ms,3.3
+ 137.7456ms,0.0V 137.7599ms,0.0
+ 137.7600ms,3.3V 137.7655ms,3.3
+ 137.7656ms,0.0V 137.7799ms,0.0
+ 137.7800ms,3.3V 137.7855ms,3.3
+ 137.7856ms,0.0V 137.7999ms,0.0
+ 137.8000ms,3.3V 137.8055ms,3.3
+ 137.8056ms,0.0V 137.8199ms,0.0
+ 137.8200ms,3.3V 137.8255ms,3.3
+ 137.8256ms,0.0V 137.8399ms,0.0
+ 137.8400ms,3.3V 137.8455ms,3.3
+ 137.8456ms,0.0V 137.8599ms,0.0
+ 137.8600ms,3.3V 137.8655ms,3.3
+ 137.8656ms,0.0V 137.8799ms,0.0
+ 137.8800ms,3.3V 137.8855ms,3.3
+ 137.8856ms,0.0V 137.8999ms,0.0
+ 137.9000ms,3.3V 137.9055ms,3.3
+ 137.9056ms,0.0V 137.9199ms,0.0
+ 137.9200ms,3.3V 137.9255ms,3.3
+ 137.9256ms,0.0V 137.9399ms,0.0
+ 137.9400ms,3.3V 137.9455ms,3.3
+ 137.9456ms,0.0V 137.9599ms,0.0
+ 137.9600ms,3.3V 137.9655ms,3.3
+ 137.9656ms,0.0V 137.9799ms,0.0
+ 137.9800ms,3.3V 137.9855ms,3.3
+ 137.9856ms,0.0V 137.9999ms,0.0
+ 138.0000ms,3.3V 138.0055ms,3.3
+ 138.0056ms,0.0V 138.0199ms,0.0
+ 138.0200ms,3.3V 138.0255ms,3.3
+ 138.0256ms,0.0V 138.0399ms,0.0
+ 138.0400ms,3.3V 138.0455ms,3.3
+ 138.0456ms,0.0V 138.0599ms,0.0
+ 138.0600ms,3.3V 138.0655ms,3.3
+ 138.0656ms,0.0V 138.0799ms,0.0
+ 138.0800ms,3.3V 138.0855ms,3.3
+ 138.0856ms,0.0V 138.0999ms,0.0
+ 138.1000ms,3.3V 138.1055ms,3.3
+ 138.1056ms,0.0V 138.1199ms,0.0
+ 138.1200ms,3.3V 138.1255ms,3.3
+ 138.1256ms,0.0V 138.1399ms,0.0
+ 138.1400ms,3.3V 138.1455ms,3.3
+ 138.1456ms,0.0V 138.1599ms,0.0
+ 138.1600ms,3.3V 138.1655ms,3.3
+ 138.1656ms,0.0V 138.1799ms,0.0
+ 138.1800ms,3.3V 138.1855ms,3.3
+ 138.1856ms,0.0V 138.1999ms,0.0
+ 138.2000ms,3.3V 138.2055ms,3.3
+ 138.2056ms,0.0V 138.2199ms,0.0
+ 138.2200ms,3.3V 138.2255ms,3.3
+ 138.2256ms,0.0V 138.2399ms,0.0
+ 138.2400ms,3.3V 138.2455ms,3.3
+ 138.2456ms,0.0V 138.2599ms,0.0
+ 138.2600ms,3.3V 138.2655ms,3.3
+ 138.2656ms,0.0V 138.2799ms,0.0
+ 138.2800ms,3.3V 138.2855ms,3.3
+ 138.2856ms,0.0V 138.2999ms,0.0
+ 138.3000ms,3.3V 138.3055ms,3.3
+ 138.3056ms,0.0V 138.3199ms,0.0
+ 138.3200ms,3.3V 138.3255ms,3.3
+ 138.3256ms,0.0V 138.3399ms,0.0
+ 138.3400ms,3.3V 138.3455ms,3.3
+ 138.3456ms,0.0V 138.3599ms,0.0
+ 138.3600ms,3.3V 138.3655ms,3.3
+ 138.3656ms,0.0V 138.3799ms,0.0
+ 138.3800ms,3.3V 138.3855ms,3.3
+ 138.3856ms,0.0V 138.3999ms,0.0
+ 138.4000ms,3.3V 138.4055ms,3.3
+ 138.4056ms,0.0V 138.4199ms,0.0
+ 138.4200ms,3.3V 138.4255ms,3.3
+ 138.4256ms,0.0V 138.4399ms,0.0
+ 138.4400ms,3.3V 138.4455ms,3.3
+ 138.4456ms,0.0V 138.4599ms,0.0
+ 138.4600ms,3.3V 138.4655ms,3.3
+ 138.4656ms,0.0V 138.4799ms,0.0
+ 138.4800ms,3.3V 138.4855ms,3.3
+ 138.4856ms,0.0V 138.4999ms,0.0
+ 138.5000ms,3.3V 138.5055ms,3.3
+ 138.5056ms,0.0V 138.5199ms,0.0
+ 138.5200ms,3.3V 138.5255ms,3.3
+ 138.5256ms,0.0V 138.5399ms,0.0
+ 138.5400ms,3.3V 138.5455ms,3.3
+ 138.5456ms,0.0V 138.5599ms,0.0
+ 138.5600ms,3.3V 138.5655ms,3.3
+ 138.5656ms,0.0V 138.5799ms,0.0
+ 138.5800ms,3.3V 138.5855ms,3.3
+ 138.5856ms,0.0V 138.5999ms,0.0
+ 138.6000ms,3.3V 138.6055ms,3.3
+ 138.6056ms,0.0V 138.6199ms,0.0
+ 138.6200ms,3.3V 138.6255ms,3.3
+ 138.6256ms,0.0V 138.6399ms,0.0
+ 138.6400ms,3.3V 138.6455ms,3.3
+ 138.6456ms,0.0V 138.6599ms,0.0
+ 138.6600ms,3.3V 138.6655ms,3.3
+ 138.6656ms,0.0V 138.6799ms,0.0
+ 138.6800ms,3.3V 138.6855ms,3.3
+ 138.6856ms,0.0V 138.6999ms,0.0
+ 138.7000ms,3.3V 138.7055ms,3.3
+ 138.7056ms,0.0V 138.7199ms,0.0
+ 138.7200ms,3.3V 138.7255ms,3.3
+ 138.7256ms,0.0V 138.7399ms,0.0
+ 138.7400ms,3.3V 138.7455ms,3.3
+ 138.7456ms,0.0V 138.7599ms,0.0
+ 138.7600ms,3.3V 138.7655ms,3.3
+ 138.7656ms,0.0V 138.7799ms,0.0
+ 138.7800ms,3.3V 138.7855ms,3.3
+ 138.7856ms,0.0V 138.7999ms,0.0
+ 138.8000ms,3.3V 138.8055ms,3.3
+ 138.8056ms,0.0V 138.8199ms,0.0
+ 138.8200ms,3.3V 138.8255ms,3.3
+ 138.8256ms,0.0V 138.8399ms,0.0
+ 138.8400ms,3.3V 138.8455ms,3.3
+ 138.8456ms,0.0V 138.8599ms,0.0
+ 138.8600ms,3.3V 138.8655ms,3.3
+ 138.8656ms,0.0V 138.8799ms,0.0
+ 138.8800ms,3.3V 138.8855ms,3.3
+ 138.8856ms,0.0V 138.8999ms,0.0
+ 138.9000ms,3.3V 138.9055ms,3.3
+ 138.9056ms,0.0V 138.9199ms,0.0
+ 138.9200ms,3.3V 138.9255ms,3.3
+ 138.9256ms,0.0V 138.9399ms,0.0
+ 138.9400ms,3.3V 138.9455ms,3.3
+ 138.9456ms,0.0V 138.9599ms,0.0
+ 138.9600ms,3.3V 138.9655ms,3.3
+ 138.9656ms,0.0V 138.9799ms,0.0
+ 138.9800ms,3.3V 138.9855ms,3.3
+ 138.9856ms,0.0V 138.9999ms,0.0
+ 139.0000ms,3.3V 139.0055ms,3.3
+ 139.0056ms,0.0V 139.0199ms,0.0
+ 139.0200ms,3.3V 139.0255ms,3.3
+ 139.0256ms,0.0V 139.0399ms,0.0
+ 139.0400ms,3.3V 139.0455ms,3.3
+ 139.0456ms,0.0V 139.0599ms,0.0
+ 139.0600ms,3.3V 139.0655ms,3.3
+ 139.0656ms,0.0V 139.0799ms,0.0
+ 139.0800ms,3.3V 139.0855ms,3.3
+ 139.0856ms,0.0V 139.0999ms,0.0
+ 139.1000ms,3.3V 139.1055ms,3.3
+ 139.1056ms,0.0V 139.1199ms,0.0
+ 139.1200ms,3.3V 139.1255ms,3.3
+ 139.1256ms,0.0V 139.1399ms,0.0
+ 139.1400ms,3.3V 139.1455ms,3.3
+ 139.1456ms,0.0V 139.1599ms,0.0
+ 139.1600ms,3.3V 139.1655ms,3.3
+ 139.1656ms,0.0V 139.1799ms,0.0
+ 139.1800ms,3.3V 139.1855ms,3.3
+ 139.1856ms,0.0V 139.1999ms,0.0
+ 139.2000ms,3.3V 139.2055ms,3.3
+ 139.2056ms,0.0V 139.2199ms,0.0
+ 139.2200ms,3.3V 139.2255ms,3.3
+ 139.2256ms,0.0V 139.2399ms,0.0
+ 139.2400ms,3.3V 139.2455ms,3.3
+ 139.2456ms,0.0V 139.2599ms,0.0
+ 139.2600ms,3.3V 139.2655ms,3.3
+ 139.2656ms,0.0V 139.2799ms,0.0
+ 139.2800ms,3.3V 139.2855ms,3.3
+ 139.2856ms,0.0V 139.2999ms,0.0
+ 139.3000ms,3.3V 139.3055ms,3.3
+ 139.3056ms,0.0V 139.3199ms,0.0
+ 139.3200ms,3.3V 139.3255ms,3.3
+ 139.3256ms,0.0V 139.3399ms,0.0
+ 139.3400ms,3.3V 139.3455ms,3.3
+ 139.3456ms,0.0V 139.3599ms,0.0
+ 139.3600ms,3.3V 139.3655ms,3.3
+ 139.3656ms,0.0V 139.3799ms,0.0
+ 139.3800ms,3.3V 139.3855ms,3.3
+ 139.3856ms,0.0V 139.3999ms,0.0
+ 139.4000ms,3.3V 139.4055ms,3.3
+ 139.4056ms,0.0V 139.4199ms,0.0
+ 139.4200ms,3.3V 139.4255ms,3.3
+ 139.4256ms,0.0V 139.4399ms,0.0
+ 139.4400ms,3.3V 139.4455ms,3.3
+ 139.4456ms,0.0V 139.4599ms,0.0
+ 139.4600ms,3.3V 139.4655ms,3.3
+ 139.4656ms,0.0V 139.4799ms,0.0
+ 139.4800ms,3.3V 139.4855ms,3.3
+ 139.4856ms,0.0V 139.4999ms,0.0
+ 139.5000ms,3.3V 139.5055ms,3.3
+ 139.5056ms,0.0V 139.5199ms,0.0
+ 139.5200ms,3.3V 139.5255ms,3.3
+ 139.5256ms,0.0V 139.5399ms,0.0
+ 139.5400ms,3.3V 139.5455ms,3.3
+ 139.5456ms,0.0V 139.5599ms,0.0
+ 139.5600ms,3.3V 139.5655ms,3.3
+ 139.5656ms,0.0V 139.5799ms,0.0
+ 139.5800ms,3.3V 139.5855ms,3.3
+ 139.5856ms,0.0V 139.5999ms,0.0
+ 139.6000ms,3.3V 139.6055ms,3.3
+ 139.6056ms,0.0V 139.6199ms,0.0
+ 139.6200ms,3.3V 139.6255ms,3.3
+ 139.6256ms,0.0V 139.6399ms,0.0
+ 139.6400ms,3.3V 139.6455ms,3.3
+ 139.6456ms,0.0V 139.6599ms,0.0
+ 139.6600ms,3.3V 139.6655ms,3.3
+ 139.6656ms,0.0V 139.6799ms,0.0
+ 139.6800ms,3.3V 139.6855ms,3.3
+ 139.6856ms,0.0V 139.6999ms,0.0
+ 139.7000ms,3.3V 139.7055ms,3.3
+ 139.7056ms,0.0V 139.7199ms,0.0
+ 139.7200ms,3.3V 139.7255ms,3.3
+ 139.7256ms,0.0V 139.7399ms,0.0
+ 139.7400ms,3.3V 139.7455ms,3.3
+ 139.7456ms,0.0V 139.7599ms,0.0
+ 139.7600ms,3.3V 139.7655ms,3.3
+ 139.7656ms,0.0V 139.7799ms,0.0
+ 139.7800ms,3.3V 139.7855ms,3.3
+ 139.7856ms,0.0V 139.7999ms,0.0
+ 139.8000ms,3.3V 139.8055ms,3.3
+ 139.8056ms,0.0V 139.8199ms,0.0
+ 139.8200ms,3.3V 139.8255ms,3.3
+ 139.8256ms,0.0V 139.8399ms,0.0
+ 139.8400ms,3.3V 139.8455ms,3.3
+ 139.8456ms,0.0V 139.8599ms,0.0
+ 139.8600ms,3.3V 139.8655ms,3.3
+ 139.8656ms,0.0V 139.8799ms,0.0
+ 139.8800ms,3.3V 139.8855ms,3.3
+ 139.8856ms,0.0V 139.8999ms,0.0
+ 139.9000ms,3.3V 139.9055ms,3.3
+ 139.9056ms,0.0V 139.9199ms,0.0
+ 139.9200ms,3.3V 139.9255ms,3.3
+ 139.9256ms,0.0V 139.9399ms,0.0
+ 139.9400ms,3.3V 139.9455ms,3.3
+ 139.9456ms,0.0V 139.9599ms,0.0
+ 139.9600ms,3.3V 139.9655ms,3.3
+ 139.9656ms,0.0V 139.9799ms,0.0
+ 139.9800ms,3.3V 139.9855ms,3.3
+ 139.9856ms,0.0V 139.9999ms,0.0
+ 140.0000ms,3.3V 140.0055ms,3.3
+ 140.0056ms,0.0V 140.0199ms,0.0
+ 140.0200ms,3.3V 140.0255ms,3.3
+ 140.0256ms,0.0V 140.0399ms,0.0
+ 140.0400ms,3.3V 140.0455ms,3.3
+ 140.0456ms,0.0V 140.0599ms,0.0
+ 140.0600ms,3.3V 140.0655ms,3.3
+ 140.0656ms,0.0V 140.0799ms,0.0
+ 140.0800ms,3.3V 140.0855ms,3.3
+ 140.0856ms,0.0V 140.0999ms,0.0
+ 140.1000ms,3.3V 140.1055ms,3.3
+ 140.1056ms,0.0V 140.1199ms,0.0
+ 140.1200ms,3.3V 140.1255ms,3.3
+ 140.1256ms,0.0V 140.1399ms,0.0
+ 140.1400ms,3.3V 140.1455ms,3.3
+ 140.1456ms,0.0V 140.1599ms,0.0
+ 140.1600ms,3.3V 140.1655ms,3.3
+ 140.1656ms,0.0V 140.1799ms,0.0
+ 140.1800ms,3.3V 140.1855ms,3.3
+ 140.1856ms,0.0V 140.1999ms,0.0
+ 140.2000ms,3.3V 140.2055ms,3.3
+ 140.2056ms,0.0V 140.2199ms,0.0
+ 140.2200ms,3.3V 140.2255ms,3.3
+ 140.2256ms,0.0V 140.2399ms,0.0
+ 140.2400ms,3.3V 140.2455ms,3.3
+ 140.2456ms,0.0V 140.2599ms,0.0
+ 140.2600ms,3.3V 140.2655ms,3.3
+ 140.2656ms,0.0V 140.2799ms,0.0
+ 140.2800ms,3.3V 140.2855ms,3.3
+ 140.2856ms,0.0V 140.2999ms,0.0
+ 140.3000ms,3.3V 140.3055ms,3.3
+ 140.3056ms,0.0V 140.3199ms,0.0
+ 140.3200ms,3.3V 140.3255ms,3.3
+ 140.3256ms,0.0V 140.3399ms,0.0
+ 140.3400ms,3.3V 140.3455ms,3.3
+ 140.3456ms,0.0V 140.3599ms,0.0
+ 140.3600ms,3.3V 140.3657ms,3.3
+ 140.3658ms,0.0V 140.3799ms,0.0
+ 140.3800ms,3.3V 140.3857ms,3.3
+ 140.3858ms,0.0V 140.3999ms,0.0
+ 140.4000ms,3.3V 140.4057ms,3.3
+ 140.4058ms,0.0V 140.4199ms,0.0
+ 140.4200ms,3.3V 140.4257ms,3.3
+ 140.4258ms,0.0V 140.4399ms,0.0
+ 140.4400ms,3.3V 140.4457ms,3.3
+ 140.4458ms,0.0V 140.4599ms,0.0
+ 140.4600ms,3.3V 140.4657ms,3.3
+ 140.4658ms,0.0V 140.4799ms,0.0
+ 140.4800ms,3.3V 140.4857ms,3.3
+ 140.4858ms,0.0V 140.4999ms,0.0
+ 140.5000ms,3.3V 140.5057ms,3.3
+ 140.5058ms,0.0V 140.5199ms,0.0
+ 140.5200ms,3.3V 140.5257ms,3.3
+ 140.5258ms,0.0V 140.5399ms,0.0
+ 140.5400ms,3.3V 140.5457ms,3.3
+ 140.5458ms,0.0V 140.5599ms,0.0
+ 140.5600ms,3.3V 140.5657ms,3.3
+ 140.5658ms,0.0V 140.5799ms,0.0
+ 140.5800ms,3.3V 140.5857ms,3.3
+ 140.5858ms,0.0V 140.5999ms,0.0
+ 140.6000ms,3.3V 140.6057ms,3.3
+ 140.6058ms,0.0V 140.6199ms,0.0
+ 140.6200ms,3.3V 140.6257ms,3.3
+ 140.6258ms,0.0V 140.6399ms,0.0
+ 140.6400ms,3.3V 140.6457ms,3.3
+ 140.6458ms,0.0V 140.6599ms,0.0
+ 140.6600ms,3.3V 140.6657ms,3.3
+ 140.6658ms,0.0V 140.6799ms,0.0
+ 140.6800ms,3.3V 140.6857ms,3.3
+ 140.6858ms,0.0V 140.6999ms,0.0
+ 140.7000ms,3.3V 140.7057ms,3.3
+ 140.7058ms,0.0V 140.7199ms,0.0
+ 140.7200ms,3.3V 140.7257ms,3.3
+ 140.7258ms,0.0V 140.7399ms,0.0
+ 140.7400ms,3.3V 140.7457ms,3.3
+ 140.7458ms,0.0V 140.7599ms,0.0
+ 140.7600ms,3.3V 140.7657ms,3.3
+ 140.7658ms,0.0V 140.7799ms,0.0
+ 140.7800ms,3.3V 140.7857ms,3.3
+ 140.7858ms,0.0V 140.7999ms,0.0
+ 140.8000ms,3.3V 140.8057ms,3.3
+ 140.8058ms,0.0V 140.8199ms,0.0
+ 140.8200ms,3.3V 140.8257ms,3.3
+ 140.8258ms,0.0V 140.8399ms,0.0
+ 140.8400ms,3.3V 140.8457ms,3.3
+ 140.8458ms,0.0V 140.8599ms,0.0
+ 140.8600ms,3.3V 140.8657ms,3.3
+ 140.8658ms,0.0V 140.8799ms,0.0
+ 140.8800ms,3.3V 140.8857ms,3.3
+ 140.8858ms,0.0V 140.8999ms,0.0
+ 140.9000ms,3.3V 140.9057ms,3.3
+ 140.9058ms,0.0V 140.9199ms,0.0
+ 140.9200ms,3.3V 140.9257ms,3.3
+ 140.9258ms,0.0V 140.9399ms,0.0
+ 140.9400ms,3.3V 140.9457ms,3.3
+ 140.9458ms,0.0V 140.9599ms,0.0
+ 140.9600ms,3.3V 140.9657ms,3.3
+ 140.9658ms,0.0V 140.9799ms,0.0
+ 140.9800ms,3.3V 140.9857ms,3.3
+ 140.9858ms,0.0V 140.9999ms,0.0
+ 141.0000ms,3.3V 141.0057ms,3.3
+ 141.0058ms,0.0V 141.0199ms,0.0
+ 141.0200ms,3.3V 141.0257ms,3.3
+ 141.0258ms,0.0V 141.0399ms,0.0
+ 141.0400ms,3.3V 141.0457ms,3.3
+ 141.0458ms,0.0V 141.0599ms,0.0
+ 141.0600ms,3.3V 141.0657ms,3.3
+ 141.0658ms,0.0V 141.0799ms,0.0
+ 141.0800ms,3.3V 141.0857ms,3.3
+ 141.0858ms,0.0V 141.0999ms,0.0
+ 141.1000ms,3.3V 141.1057ms,3.3
+ 141.1058ms,0.0V 141.1199ms,0.0
+ 141.1200ms,3.3V 141.1257ms,3.3
+ 141.1258ms,0.0V 141.1399ms,0.0
+ 141.1400ms,3.3V 141.1457ms,3.3
+ 141.1458ms,0.0V 141.1599ms,0.0
+ 141.1600ms,3.3V 141.1657ms,3.3
+ 141.1658ms,0.0V 141.1799ms,0.0
+ 141.1800ms,3.3V 141.1857ms,3.3
+ 141.1858ms,0.0V 141.1999ms,0.0
+ 141.2000ms,3.3V 141.2057ms,3.3
+ 141.2058ms,0.0V 141.2199ms,0.0
+ 141.2200ms,3.3V 141.2257ms,3.3
+ 141.2258ms,0.0V 141.2399ms,0.0
+ 141.2400ms,3.3V 141.2457ms,3.3
+ 141.2458ms,0.0V 141.2599ms,0.0
+ 141.2600ms,3.3V 141.2657ms,3.3
+ 141.2658ms,0.0V 141.2799ms,0.0
+ 141.2800ms,3.3V 141.2857ms,3.3
+ 141.2858ms,0.0V 141.2999ms,0.0
+ 141.3000ms,3.3V 141.3057ms,3.3
+ 141.3058ms,0.0V 141.3199ms,0.0
+ 141.3200ms,3.3V 141.3257ms,3.3
+ 141.3258ms,0.0V 141.3399ms,0.0
+ 141.3400ms,3.3V 141.3457ms,3.3
+ 141.3458ms,0.0V 141.3599ms,0.0
+ 141.3600ms,3.3V 141.3657ms,3.3
+ 141.3658ms,0.0V 141.3799ms,0.0
+ 141.3800ms,3.3V 141.3857ms,3.3
+ 141.3858ms,0.0V 141.3999ms,0.0
+ 141.4000ms,3.3V 141.4057ms,3.3
+ 141.4058ms,0.0V 141.4199ms,0.0
+ 141.4200ms,3.3V 141.4257ms,3.3
+ 141.4258ms,0.0V 141.4399ms,0.0
+ 141.4400ms,3.3V 141.4457ms,3.3
+ 141.4458ms,0.0V 141.4599ms,0.0
+ 141.4600ms,3.3V 141.4657ms,3.3
+ 141.4658ms,0.0V 141.4799ms,0.0
+ 141.4800ms,3.3V 141.4857ms,3.3
+ 141.4858ms,0.0V 141.4999ms,0.0
+ 141.5000ms,3.3V 141.5057ms,3.3
+ 141.5058ms,0.0V 141.5199ms,0.0
+ 141.5200ms,3.3V 141.5257ms,3.3
+ 141.5258ms,0.0V 141.5399ms,0.0
+ 141.5400ms,3.3V 141.5457ms,3.3
+ 141.5458ms,0.0V 141.5599ms,0.0
+ 141.5600ms,3.3V 141.5657ms,3.3
+ 141.5658ms,0.0V 141.5799ms,0.0
+ 141.5800ms,3.3V 141.5857ms,3.3
+ 141.5858ms,0.0V 141.5999ms,0.0
+ 141.6000ms,3.3V 141.6057ms,3.3
+ 141.6058ms,0.0V 141.6199ms,0.0
+ 141.6200ms,3.3V 141.6257ms,3.3
+ 141.6258ms,0.0V 141.6399ms,0.0
+ 141.6400ms,3.3V 141.6457ms,3.3
+ 141.6458ms,0.0V 141.6599ms,0.0
+ 141.6600ms,3.3V 141.6657ms,3.3
+ 141.6658ms,0.0V 141.6799ms,0.0
+ 141.6800ms,3.3V 141.6857ms,3.3
+ 141.6858ms,0.0V 141.6999ms,0.0
+ 141.7000ms,3.3V 141.7057ms,3.3
+ 141.7058ms,0.0V 141.7199ms,0.0
+ 141.7200ms,3.3V 141.7257ms,3.3
+ 141.7258ms,0.0V 141.7399ms,0.0
+ 141.7400ms,3.3V 141.7457ms,3.3
+ 141.7458ms,0.0V 141.7599ms,0.0
+ 141.7600ms,3.3V 141.7657ms,3.3
+ 141.7658ms,0.0V 141.7799ms,0.0
+ 141.7800ms,3.3V 141.7857ms,3.3
+ 141.7858ms,0.0V 141.7999ms,0.0
+ 141.8000ms,3.3V 141.8057ms,3.3
+ 141.8058ms,0.0V 141.8199ms,0.0
+ 141.8200ms,3.3V 141.8257ms,3.3
+ 141.8258ms,0.0V 141.8399ms,0.0
+ 141.8400ms,3.3V 141.8457ms,3.3
+ 141.8458ms,0.0V 141.8599ms,0.0
+ 141.8600ms,3.3V 141.8657ms,3.3
+ 141.8658ms,0.0V 141.8799ms,0.0
+ 141.8800ms,3.3V 141.8857ms,3.3
+ 141.8858ms,0.0V 141.8999ms,0.0
+ 141.9000ms,3.3V 141.9057ms,3.3
+ 141.9058ms,0.0V 141.9199ms,0.0
+ 141.9200ms,3.3V 141.9257ms,3.3
+ 141.9258ms,0.0V 141.9399ms,0.0
+ 141.9400ms,3.3V 141.9457ms,3.3
+ 141.9458ms,0.0V 141.9599ms,0.0
+ 141.9600ms,3.3V 141.9657ms,3.3
+ 141.9658ms,0.0V 141.9799ms,0.0
+ 141.9800ms,3.3V 141.9857ms,3.3
+ 141.9858ms,0.0V 141.9999ms,0.0
+ 142.0000ms,3.3V 142.0057ms,3.3
+ 142.0058ms,0.0V 142.0199ms,0.0
+ 142.0200ms,3.3V 142.0257ms,3.3
+ 142.0258ms,0.0V 142.0399ms,0.0
+ 142.0400ms,3.3V 142.0457ms,3.3
+ 142.0458ms,0.0V 142.0599ms,0.0
+ 142.0600ms,3.3V 142.0657ms,3.3
+ 142.0658ms,0.0V 142.0799ms,0.0
+ 142.0800ms,3.3V 142.0857ms,3.3
+ 142.0858ms,0.0V 142.0999ms,0.0
+ 142.1000ms,3.3V 142.1057ms,3.3
+ 142.1058ms,0.0V 142.1199ms,0.0
+ 142.1200ms,3.3V 142.1257ms,3.3
+ 142.1258ms,0.0V 142.1399ms,0.0
+ 142.1400ms,3.3V 142.1457ms,3.3
+ 142.1458ms,0.0V 142.1599ms,0.0
+ 142.1600ms,3.3V 142.1657ms,3.3
+ 142.1658ms,0.0V 142.1799ms,0.0
+ 142.1800ms,3.3V 142.1857ms,3.3
+ 142.1858ms,0.0V 142.1999ms,0.0
+ 142.2000ms,3.3V 142.2057ms,3.3
+ 142.2058ms,0.0V 142.2199ms,0.0
+ 142.2200ms,3.3V 142.2257ms,3.3
+ 142.2258ms,0.0V 142.2399ms,0.0
+ 142.2400ms,3.3V 142.2457ms,3.3
+ 142.2458ms,0.0V 142.2599ms,0.0
+ 142.2600ms,3.3V 142.2657ms,3.3
+ 142.2658ms,0.0V 142.2799ms,0.0
+ 142.2800ms,3.3V 142.2857ms,3.3
+ 142.2858ms,0.0V 142.2999ms,0.0
+ 142.3000ms,3.3V 142.3057ms,3.3
+ 142.3058ms,0.0V 142.3199ms,0.0
+ 142.3200ms,3.3V 142.3257ms,3.3
+ 142.3258ms,0.0V 142.3399ms,0.0
+ 142.3400ms,3.3V 142.3457ms,3.3
+ 142.3458ms,0.0V 142.3599ms,0.0
+ 142.3600ms,3.3V 142.3657ms,3.3
+ 142.3658ms,0.0V 142.3799ms,0.0
+ 142.3800ms,3.3V 142.3857ms,3.3
+ 142.3858ms,0.0V 142.3999ms,0.0
+ 142.4000ms,3.3V 142.4057ms,3.3
+ 142.4058ms,0.0V 142.4199ms,0.0
+ 142.4200ms,3.3V 142.4257ms,3.3
+ 142.4258ms,0.0V 142.4399ms,0.0
+ 142.4400ms,3.3V 142.4457ms,3.3
+ 142.4458ms,0.0V 142.4599ms,0.0
+ 142.4600ms,3.3V 142.4657ms,3.3
+ 142.4658ms,0.0V 142.4799ms,0.0
+ 142.4800ms,3.3V 142.4857ms,3.3
+ 142.4858ms,0.0V 142.4999ms,0.0
+ 142.5000ms,3.3V 142.5057ms,3.3
+ 142.5058ms,0.0V 142.5199ms,0.0
+ 142.5200ms,3.3V 142.5257ms,3.3
+ 142.5258ms,0.0V 142.5399ms,0.0
+ 142.5400ms,3.3V 142.5457ms,3.3
+ 142.5458ms,0.0V 142.5599ms,0.0
+ 142.5600ms,3.3V 142.5657ms,3.3
+ 142.5658ms,0.0V 142.5799ms,0.0
+ 142.5800ms,3.3V 142.5857ms,3.3
+ 142.5858ms,0.0V 142.5999ms,0.0
+ 142.6000ms,3.3V 142.6057ms,3.3
+ 142.6058ms,0.0V 142.6199ms,0.0
+ 142.6200ms,3.3V 142.6257ms,3.3
+ 142.6258ms,0.0V 142.6399ms,0.0
+ 142.6400ms,3.3V 142.6457ms,3.3
+ 142.6458ms,0.0V 142.6599ms,0.0
+ 142.6600ms,3.3V 142.6657ms,3.3
+ 142.6658ms,0.0V 142.6799ms,0.0
+ 142.6800ms,3.3V 142.6857ms,3.3
+ 142.6858ms,0.0V 142.6999ms,0.0
+ 142.7000ms,3.3V 142.7057ms,3.3
+ 142.7058ms,0.0V 142.7199ms,0.0
+ 142.7200ms,3.3V 142.7257ms,3.3
+ 142.7258ms,0.0V 142.7399ms,0.0
+ 142.7400ms,3.3V 142.7457ms,3.3
+ 142.7458ms,0.0V 142.7599ms,0.0
+ 142.7600ms,3.3V 142.7657ms,3.3
+ 142.7658ms,0.0V 142.7799ms,0.0
+ 142.7800ms,3.3V 142.7857ms,3.3
+ 142.7858ms,0.0V 142.7999ms,0.0
+ 142.8000ms,3.3V 142.8057ms,3.3
+ 142.8058ms,0.0V 142.8199ms,0.0
+ 142.8200ms,3.3V 142.8257ms,3.3
+ 142.8258ms,0.0V 142.8399ms,0.0
+ 142.8400ms,3.3V 142.8457ms,3.3
+ 142.8458ms,0.0V 142.8599ms,0.0
+ 142.8600ms,3.3V 142.8657ms,3.3
+ 142.8658ms,0.0V 142.8799ms,0.0
+ 142.8800ms,3.3V 142.8857ms,3.3
+ 142.8858ms,0.0V 142.8999ms,0.0
+ 142.9000ms,3.3V 142.9057ms,3.3
+ 142.9058ms,0.0V 142.9199ms,0.0
+ 142.9200ms,3.3V 142.9257ms,3.3
+ 142.9258ms,0.0V 142.9399ms,0.0
+ 142.9400ms,3.3V 142.9457ms,3.3
+ 142.9458ms,0.0V 142.9599ms,0.0
+ 142.9600ms,3.3V 142.9657ms,3.3
+ 142.9658ms,0.0V 142.9799ms,0.0
+ 142.9800ms,3.3V 142.9857ms,3.3
+ 142.9858ms,0.0V 142.9999ms,0.0
+ 143.0000ms,3.3V 143.0057ms,3.3
+ 143.0058ms,0.0V 143.0199ms,0.0
+ 143.0200ms,3.3V 143.0257ms,3.3
+ 143.0258ms,0.0V 143.0399ms,0.0
+ 143.0400ms,3.3V 143.0457ms,3.3
+ 143.0458ms,0.0V 143.0599ms,0.0
+ 143.0600ms,3.3V 143.0657ms,3.3
+ 143.0658ms,0.0V 143.0799ms,0.0
+ 143.0800ms,3.3V 143.0857ms,3.3
+ 143.0858ms,0.0V 143.0999ms,0.0
+ 143.1000ms,3.3V 143.1057ms,3.3
+ 143.1058ms,0.0V 143.1199ms,0.0
+ 143.1200ms,3.3V 143.1257ms,3.3
+ 143.1258ms,0.0V 143.1399ms,0.0
+ 143.1400ms,3.3V 143.1457ms,3.3
+ 143.1458ms,0.0V 143.1599ms,0.0
+ 143.1600ms,3.3V 143.1657ms,3.3
+ 143.1658ms,0.0V 143.1799ms,0.0
+ 143.1800ms,3.3V 143.1857ms,3.3
+ 143.1858ms,0.0V 143.1999ms,0.0
+ 143.2000ms,3.3V 143.2057ms,3.3
+ 143.2058ms,0.0V 143.2199ms,0.0
+ 143.2200ms,3.3V 143.2257ms,3.3
+ 143.2258ms,0.0V 143.2399ms,0.0
+ 143.2400ms,3.3V 143.2457ms,3.3
+ 143.2458ms,0.0V 143.2599ms,0.0
+ 143.2600ms,3.3V 143.2657ms,3.3
+ 143.2658ms,0.0V 143.2799ms,0.0
+ 143.2800ms,3.3V 143.2857ms,3.3
+ 143.2858ms,0.0V 143.2999ms,0.0
+ 143.3000ms,3.3V 143.3057ms,3.3
+ 143.3058ms,0.0V 143.3199ms,0.0
+ 143.3200ms,3.3V 143.3257ms,3.3
+ 143.3258ms,0.0V 143.3399ms,0.0
+ 143.3400ms,3.3V 143.3457ms,3.3
+ 143.3458ms,0.0V 143.3599ms,0.0
+ 143.3600ms,3.3V 143.3657ms,3.3
+ 143.3658ms,0.0V 143.3799ms,0.0
+ 143.3800ms,3.3V 143.3857ms,3.3
+ 143.3858ms,0.0V 143.3999ms,0.0
+ 143.4000ms,3.3V 143.4057ms,3.3
+ 143.4058ms,0.0V 143.4199ms,0.0
+ 143.4200ms,3.3V 143.4257ms,3.3
+ 143.4258ms,0.0V 143.4399ms,0.0
+ 143.4400ms,3.3V 143.4457ms,3.3
+ 143.4458ms,0.0V 143.4599ms,0.0
+ 143.4600ms,3.3V 143.4657ms,3.3
+ 143.4658ms,0.0V 143.4799ms,0.0
+ 143.4800ms,3.3V 143.4857ms,3.3
+ 143.4858ms,0.0V 143.4999ms,0.0
+ 143.5000ms,3.3V 143.5057ms,3.3
+ 143.5058ms,0.0V 143.5199ms,0.0
+ 143.5200ms,3.3V 143.5257ms,3.3
+ 143.5258ms,0.0V 143.5399ms,0.0
+ 143.5400ms,3.3V 143.5457ms,3.3
+ 143.5458ms,0.0V 143.5599ms,0.0
+ 143.5600ms,3.3V 143.5657ms,3.3
+ 143.5658ms,0.0V 143.5799ms,0.0
+ 143.5800ms,3.3V 143.5857ms,3.3
+ 143.5858ms,0.0V 143.5999ms,0.0
+ 143.6000ms,3.3V 143.6057ms,3.3
+ 143.6058ms,0.0V 143.6199ms,0.0
+ 143.6200ms,3.3V 143.6257ms,3.3
+ 143.6258ms,0.0V 143.6399ms,0.0
+ 143.6400ms,3.3V 143.6457ms,3.3
+ 143.6458ms,0.0V 143.6599ms,0.0
+ 143.6600ms,3.3V 143.6657ms,3.3
+ 143.6658ms,0.0V 143.6799ms,0.0
+ 143.6800ms,3.3V 143.6857ms,3.3
+ 143.6858ms,0.0V 143.6999ms,0.0
+ 143.7000ms,3.3V 143.7057ms,3.3
+ 143.7058ms,0.0V 143.7199ms,0.0
+ 143.7200ms,3.3V 143.7257ms,3.3
+ 143.7258ms,0.0V 143.7399ms,0.0
+ 143.7400ms,3.3V 143.7457ms,3.3
+ 143.7458ms,0.0V 143.7599ms,0.0
+ 143.7600ms,3.3V 143.7657ms,3.3
+ 143.7658ms,0.0V 143.7799ms,0.0
+ 143.7800ms,3.3V 143.7857ms,3.3
+ 143.7858ms,0.0V 143.7999ms,0.0
+ 143.8000ms,3.3V 143.8057ms,3.3
+ 143.8058ms,0.0V 143.8199ms,0.0
+ 143.8200ms,3.3V 143.8257ms,3.3
+ 143.8258ms,0.0V 143.8399ms,0.0
+ 143.8400ms,3.3V 143.8457ms,3.3
+ 143.8458ms,0.0V 143.8599ms,0.0
+ 143.8600ms,3.3V 143.8657ms,3.3
+ 143.8658ms,0.0V 143.8799ms,0.0
+ 143.8800ms,3.3V 143.8857ms,3.3
+ 143.8858ms,0.0V 143.8999ms,0.0
+ 143.9000ms,3.3V 143.9057ms,3.3
+ 143.9058ms,0.0V 143.9199ms,0.0
+ 143.9200ms,3.3V 143.9257ms,3.3
+ 143.9258ms,0.0V 143.9399ms,0.0
+ 143.9400ms,3.3V 143.9457ms,3.3
+ 143.9458ms,0.0V 143.9599ms,0.0
+ 143.9600ms,3.3V 143.9657ms,3.3
+ 143.9658ms,0.0V 143.9799ms,0.0
+ 143.9800ms,3.3V 143.9857ms,3.3
+ 143.9858ms,0.0V 143.9999ms,0.0
+ 144.0000ms,3.3V 144.0057ms,3.3
+ 144.0058ms,0.0V 144.0199ms,0.0
+ 144.0200ms,3.3V 144.0257ms,3.3
+ 144.0258ms,0.0V 144.0399ms,0.0
+ 144.0400ms,3.3V 144.0457ms,3.3
+ 144.0458ms,0.0V 144.0599ms,0.0
+ 144.0600ms,3.3V 144.0657ms,3.3
+ 144.0658ms,0.0V 144.0799ms,0.0
+ 144.0800ms,3.3V 144.0857ms,3.3
+ 144.0858ms,0.0V 144.0999ms,0.0
+ 144.1000ms,3.3V 144.1057ms,3.3
+ 144.1058ms,0.0V 144.1199ms,0.0
+ 144.1200ms,3.3V 144.1257ms,3.3
+ 144.1258ms,0.0V 144.1399ms,0.0
+ 144.1400ms,3.3V 144.1457ms,3.3
+ 144.1458ms,0.0V 144.1599ms,0.0
+ 144.1600ms,3.3V 144.1657ms,3.3
+ 144.1658ms,0.0V 144.1799ms,0.0
+ 144.1800ms,3.3V 144.1857ms,3.3
+ 144.1858ms,0.0V 144.1999ms,0.0
+ 144.2000ms,3.3V 144.2057ms,3.3
+ 144.2058ms,0.0V 144.2199ms,0.0
+ 144.2200ms,3.3V 144.2257ms,3.3
+ 144.2258ms,0.0V 144.2399ms,0.0
+ 144.2400ms,3.3V 144.2457ms,3.3
+ 144.2458ms,0.0V 144.2599ms,0.0
+ 144.2600ms,3.3V 144.2657ms,3.3
+ 144.2658ms,0.0V 144.2799ms,0.0
+ 144.2800ms,3.3V 144.2857ms,3.3
+ 144.2858ms,0.0V 144.2999ms,0.0
+ 144.3000ms,3.3V 144.3057ms,3.3
+ 144.3058ms,0.0V 144.3199ms,0.0
+ 144.3200ms,3.3V 144.3257ms,3.3
+ 144.3258ms,0.0V 144.3399ms,0.0
+ 144.3400ms,3.3V 144.3457ms,3.3
+ 144.3458ms,0.0V 144.3599ms,0.0
+ 144.3600ms,3.3V 144.3657ms,3.3
+ 144.3658ms,0.0V 144.3799ms,0.0
+ 144.3800ms,3.3V 144.3857ms,3.3
+ 144.3858ms,0.0V 144.3999ms,0.0
+ 144.4000ms,3.3V 144.4057ms,3.3
+ 144.4058ms,0.0V 144.4199ms,0.0
+ 144.4200ms,3.3V 144.4257ms,3.3
+ 144.4258ms,0.0V 144.4399ms,0.0
+ 144.4400ms,3.3V 144.4457ms,3.3
+ 144.4458ms,0.0V 144.4599ms,0.0
+ 144.4600ms,3.3V 144.4657ms,3.3
+ 144.4658ms,0.0V 144.4799ms,0.0
+ 144.4800ms,3.3V 144.4857ms,3.3
+ 144.4858ms,0.0V 144.4999ms,0.0
+ 144.5000ms,3.3V 144.5057ms,3.3
+ 144.5058ms,0.0V 144.5199ms,0.0
+ 144.5200ms,3.3V 144.5257ms,3.3
+ 144.5258ms,0.0V 144.5399ms,0.0
+ 144.5400ms,3.3V 144.5457ms,3.3
+ 144.5458ms,0.0V 144.5599ms,0.0
+ 144.5600ms,3.3V 144.5657ms,3.3
+ 144.5658ms,0.0V 144.5799ms,0.0
+ 144.5800ms,3.3V 144.5857ms,3.3
+ 144.5858ms,0.0V 144.5999ms,0.0
+ 144.6000ms,3.3V 144.6057ms,3.3
+ 144.6058ms,0.0V 144.6199ms,0.0
+ 144.6200ms,3.3V 144.6257ms,3.3
+ 144.6258ms,0.0V 144.6399ms,0.0
+ 144.6400ms,3.3V 144.6457ms,3.3
+ 144.6458ms,0.0V 144.6599ms,0.0
+ 144.6600ms,3.3V 144.6657ms,3.3
+ 144.6658ms,0.0V 144.6799ms,0.0
+ 144.6800ms,3.3V 144.6857ms,3.3
+ 144.6858ms,0.0V 144.6999ms,0.0
+ 144.7000ms,3.3V 144.7057ms,3.3
+ 144.7058ms,0.0V 144.7199ms,0.0
+ 144.7200ms,3.3V 144.7257ms,3.3
+ 144.7258ms,0.0V 144.7399ms,0.0
+ 144.7400ms,3.3V 144.7457ms,3.3
+ 144.7458ms,0.0V 144.7599ms,0.0
+ 144.7600ms,3.3V 144.7657ms,3.3
+ 144.7658ms,0.0V 144.7799ms,0.0
+ 144.7800ms,3.3V 144.7857ms,3.3
+ 144.7858ms,0.0V 144.7999ms,0.0
+ 144.8000ms,3.3V 144.8057ms,3.3
+ 144.8058ms,0.0V 144.8199ms,0.0
+ 144.8200ms,3.3V 144.8257ms,3.3
+ 144.8258ms,0.0V 144.8399ms,0.0
+ 144.8400ms,3.3V 144.8457ms,3.3
+ 144.8458ms,0.0V 144.8599ms,0.0
+ 144.8600ms,3.3V 144.8657ms,3.3
+ 144.8658ms,0.0V 144.8799ms,0.0
+ 144.8800ms,3.3V 144.8857ms,3.3
+ 144.8858ms,0.0V 144.8999ms,0.0
+ 144.9000ms,3.3V 144.9057ms,3.3
+ 144.9058ms,0.0V 144.9199ms,0.0
+ 144.9200ms,3.3V 144.9257ms,3.3
+ 144.9258ms,0.0V 144.9399ms,0.0
+ 144.9400ms,3.3V 144.9457ms,3.3
+ 144.9458ms,0.0V 144.9599ms,0.0
+ 144.9600ms,3.3V 144.9657ms,3.3
+ 144.9658ms,0.0V 144.9799ms,0.0
+ 144.9800ms,3.3V 144.9857ms,3.3
+ 144.9858ms,0.0V 144.9999ms,0.0
+ 145.0000ms,3.3V 145.0057ms,3.3
+ 145.0058ms,0.0V 145.0199ms,0.0
+ 145.0200ms,3.3V 145.0257ms,3.3
+ 145.0258ms,0.0V 145.0399ms,0.0
+ 145.0400ms,3.3V 145.0457ms,3.3
+ 145.0458ms,0.0V 145.0599ms,0.0
+ 145.0600ms,3.3V 145.0657ms,3.3
+ 145.0658ms,0.0V 145.0799ms,0.0
+ 145.0800ms,3.3V 145.0857ms,3.3
+ 145.0858ms,0.0V 145.0999ms,0.0
+ 145.1000ms,3.3V 145.1057ms,3.3
+ 145.1058ms,0.0V 145.1199ms,0.0
+ 145.1200ms,3.3V 145.1257ms,3.3
+ 145.1258ms,0.0V 145.1399ms,0.0
+ 145.1400ms,3.3V 145.1457ms,3.3
+ 145.1458ms,0.0V 145.1599ms,0.0
+ 145.1600ms,3.3V 145.1657ms,3.3
+ 145.1658ms,0.0V 145.1799ms,0.0
+ 145.1800ms,3.3V 145.1857ms,3.3
+ 145.1858ms,0.0V 145.1999ms,0.0
+ 145.2000ms,3.3V 145.2057ms,3.3
+ 145.2058ms,0.0V 145.2199ms,0.0
+ 145.2200ms,3.3V 145.2257ms,3.3
+ 145.2258ms,0.0V 145.2399ms,0.0
+ 145.2400ms,3.3V 145.2457ms,3.3
+ 145.2458ms,0.0V 145.2599ms,0.0
+ 145.2600ms,3.3V 145.2657ms,3.3
+ 145.2658ms,0.0V 145.2799ms,0.0
+ 145.2800ms,3.3V 145.2857ms,3.3
+ 145.2858ms,0.0V 145.2999ms,0.0
+ 145.3000ms,3.3V 145.3057ms,3.3
+ 145.3058ms,0.0V 145.3199ms,0.0
+ 145.3200ms,3.3V 145.3257ms,3.3
+ 145.3258ms,0.0V 145.3399ms,0.0
+ 145.3400ms,3.3V 145.3457ms,3.3
+ 145.3458ms,0.0V 145.3599ms,0.0
+ 145.3600ms,3.3V 145.3659ms,3.3
+ 145.3660ms,0.0V 145.3799ms,0.0
+ 145.3800ms,3.3V 145.3859ms,3.3
+ 145.3860ms,0.0V 145.3999ms,0.0
+ 145.4000ms,3.3V 145.4059ms,3.3
+ 145.4060ms,0.0V 145.4199ms,0.0
+ 145.4200ms,3.3V 145.4259ms,3.3
+ 145.4260ms,0.0V 145.4399ms,0.0
+ 145.4400ms,3.3V 145.4459ms,3.3
+ 145.4460ms,0.0V 145.4599ms,0.0
+ 145.4600ms,3.3V 145.4659ms,3.3
+ 145.4660ms,0.0V 145.4799ms,0.0
+ 145.4800ms,3.3V 145.4859ms,3.3
+ 145.4860ms,0.0V 145.4999ms,0.0
+ 145.5000ms,3.3V 145.5059ms,3.3
+ 145.5060ms,0.0V 145.5199ms,0.0
+ 145.5200ms,3.3V 145.5259ms,3.3
+ 145.5260ms,0.0V 145.5399ms,0.0
+ 145.5400ms,3.3V 145.5459ms,3.3
+ 145.5460ms,0.0V 145.5599ms,0.0
+ 145.5600ms,3.3V 145.5659ms,3.3
+ 145.5660ms,0.0V 145.5799ms,0.0
+ 145.5800ms,3.3V 145.5859ms,3.3
+ 145.5860ms,0.0V 145.5999ms,0.0
+ 145.6000ms,3.3V 145.6059ms,3.3
+ 145.6060ms,0.0V 145.6199ms,0.0
+ 145.6200ms,3.3V 145.6259ms,3.3
+ 145.6260ms,0.0V 145.6399ms,0.0
+ 145.6400ms,3.3V 145.6459ms,3.3
+ 145.6460ms,0.0V 145.6599ms,0.0
+ 145.6600ms,3.3V 145.6659ms,3.3
+ 145.6660ms,0.0V 145.6799ms,0.0
+ 145.6800ms,3.3V 145.6859ms,3.3
+ 145.6860ms,0.0V 145.6999ms,0.0
+ 145.7000ms,3.3V 145.7059ms,3.3
+ 145.7060ms,0.0V 145.7199ms,0.0
+ 145.7200ms,3.3V 145.7259ms,3.3
+ 145.7260ms,0.0V 145.7399ms,0.0
+ 145.7400ms,3.3V 145.7459ms,3.3
+ 145.7460ms,0.0V 145.7599ms,0.0
+ 145.7600ms,3.3V 145.7659ms,3.3
+ 145.7660ms,0.0V 145.7799ms,0.0
+ 145.7800ms,3.3V 145.7859ms,3.3
+ 145.7860ms,0.0V 145.7999ms,0.0
+ 145.8000ms,3.3V 145.8059ms,3.3
+ 145.8060ms,0.0V 145.8199ms,0.0
+ 145.8200ms,3.3V 145.8259ms,3.3
+ 145.8260ms,0.0V 145.8399ms,0.0
+ 145.8400ms,3.3V 145.8459ms,3.3
+ 145.8460ms,0.0V 145.8599ms,0.0
+ 145.8600ms,3.3V 145.8659ms,3.3
+ 145.8660ms,0.0V 145.8799ms,0.0
+ 145.8800ms,3.3V 145.8859ms,3.3
+ 145.8860ms,0.0V 145.8999ms,0.0
+ 145.9000ms,3.3V 145.9059ms,3.3
+ 145.9060ms,0.0V 145.9199ms,0.0
+ 145.9200ms,3.3V 145.9259ms,3.3
+ 145.9260ms,0.0V 145.9399ms,0.0
+ 145.9400ms,3.3V 145.9459ms,3.3
+ 145.9460ms,0.0V 145.9599ms,0.0
+ 145.9600ms,3.3V 145.9659ms,3.3
+ 145.9660ms,0.0V 145.9799ms,0.0
+ 145.9800ms,3.3V 145.9859ms,3.3
+ 145.9860ms,0.0V 145.9999ms,0.0
+ 146.0000ms,3.3V 146.0059ms,3.3
+ 146.0060ms,0.0V 146.0199ms,0.0
+ 146.0200ms,3.3V 146.0259ms,3.3
+ 146.0260ms,0.0V 146.0399ms,0.0
+ 146.0400ms,3.3V 146.0459ms,3.3
+ 146.0460ms,0.0V 146.0599ms,0.0
+ 146.0600ms,3.3V 146.0659ms,3.3
+ 146.0660ms,0.0V 146.0799ms,0.0
+ 146.0800ms,3.3V 146.0859ms,3.3
+ 146.0860ms,0.0V 146.0999ms,0.0
+ 146.1000ms,3.3V 146.1059ms,3.3
+ 146.1060ms,0.0V 146.1199ms,0.0
+ 146.1200ms,3.3V 146.1259ms,3.3
+ 146.1260ms,0.0V 146.1399ms,0.0
+ 146.1400ms,3.3V 146.1459ms,3.3
+ 146.1460ms,0.0V 146.1599ms,0.0
+ 146.1600ms,3.3V 146.1659ms,3.3
+ 146.1660ms,0.0V 146.1799ms,0.0
+ 146.1800ms,3.3V 146.1859ms,3.3
+ 146.1860ms,0.0V 146.1999ms,0.0
+ 146.2000ms,3.3V 146.2059ms,3.3
+ 146.2060ms,0.0V 146.2199ms,0.0
+ 146.2200ms,3.3V 146.2259ms,3.3
+ 146.2260ms,0.0V 146.2399ms,0.0
+ 146.2400ms,3.3V 146.2459ms,3.3
+ 146.2460ms,0.0V 146.2599ms,0.0
+ 146.2600ms,3.3V 146.2659ms,3.3
+ 146.2660ms,0.0V 146.2799ms,0.0
+ 146.2800ms,3.3V 146.2859ms,3.3
+ 146.2860ms,0.0V 146.2999ms,0.0
+ 146.3000ms,3.3V 146.3059ms,3.3
+ 146.3060ms,0.0V 146.3199ms,0.0
+ 146.3200ms,3.3V 146.3259ms,3.3
+ 146.3260ms,0.0V 146.3399ms,0.0
+ 146.3400ms,3.3V 146.3459ms,3.3
+ 146.3460ms,0.0V 146.3599ms,0.0
+ 146.3600ms,3.3V 146.3659ms,3.3
+ 146.3660ms,0.0V 146.3799ms,0.0
+ 146.3800ms,3.3V 146.3859ms,3.3
+ 146.3860ms,0.0V 146.3999ms,0.0
+ 146.4000ms,3.3V 146.4059ms,3.3
+ 146.4060ms,0.0V 146.4199ms,0.0
+ 146.4200ms,3.3V 146.4259ms,3.3
+ 146.4260ms,0.0V 146.4399ms,0.0
+ 146.4400ms,3.3V 146.4459ms,3.3
+ 146.4460ms,0.0V 146.4599ms,0.0
+ 146.4600ms,3.3V 146.4659ms,3.3
+ 146.4660ms,0.0V 146.4799ms,0.0
+ 146.4800ms,3.3V 146.4859ms,3.3
+ 146.4860ms,0.0V 146.4999ms,0.0
+ 146.5000ms,3.3V 146.5059ms,3.3
+ 146.5060ms,0.0V 146.5199ms,0.0
+ 146.5200ms,3.3V 146.5259ms,3.3
+ 146.5260ms,0.0V 146.5399ms,0.0
+ 146.5400ms,3.3V 146.5459ms,3.3
+ 146.5460ms,0.0V 146.5599ms,0.0
+ 146.5600ms,3.3V 146.5659ms,3.3
+ 146.5660ms,0.0V 146.5799ms,0.0
+ 146.5800ms,3.3V 146.5859ms,3.3
+ 146.5860ms,0.0V 146.5999ms,0.0
+ 146.6000ms,3.3V 146.6059ms,3.3
+ 146.6060ms,0.0V 146.6199ms,0.0
+ 146.6200ms,3.3V 146.6259ms,3.3
+ 146.6260ms,0.0V 146.6399ms,0.0
+ 146.6400ms,3.3V 146.6459ms,3.3
+ 146.6460ms,0.0V 146.6599ms,0.0
+ 146.6600ms,3.3V 146.6659ms,3.3
+ 146.6660ms,0.0V 146.6799ms,0.0
+ 146.6800ms,3.3V 146.6859ms,3.3
+ 146.6860ms,0.0V 146.6999ms,0.0
+ 146.7000ms,3.3V 146.7059ms,3.3
+ 146.7060ms,0.0V 146.7199ms,0.0
+ 146.7200ms,3.3V 146.7259ms,3.3
+ 146.7260ms,0.0V 146.7399ms,0.0
+ 146.7400ms,3.3V 146.7459ms,3.3
+ 146.7460ms,0.0V 146.7599ms,0.0
+ 146.7600ms,3.3V 146.7659ms,3.3
+ 146.7660ms,0.0V 146.7799ms,0.0
+ 146.7800ms,3.3V 146.7859ms,3.3
+ 146.7860ms,0.0V 146.7999ms,0.0
+ 146.8000ms,3.3V 146.8059ms,3.3
+ 146.8060ms,0.0V 146.8199ms,0.0
+ 146.8200ms,3.3V 146.8259ms,3.3
+ 146.8260ms,0.0V 146.8399ms,0.0
+ 146.8400ms,3.3V 146.8459ms,3.3
+ 146.8460ms,0.0V 146.8599ms,0.0
+ 146.8600ms,3.3V 146.8659ms,3.3
+ 146.8660ms,0.0V 146.8799ms,0.0
+ 146.8800ms,3.3V 146.8859ms,3.3
+ 146.8860ms,0.0V 146.8999ms,0.0
+ 146.9000ms,3.3V 146.9059ms,3.3
+ 146.9060ms,0.0V 146.9199ms,0.0
+ 146.9200ms,3.3V 146.9259ms,3.3
+ 146.9260ms,0.0V 146.9399ms,0.0
+ 146.9400ms,3.3V 146.9459ms,3.3
+ 146.9460ms,0.0V 146.9599ms,0.0
+ 146.9600ms,3.3V 146.9659ms,3.3
+ 146.9660ms,0.0V 146.9799ms,0.0
+ 146.9800ms,3.3V 146.9859ms,3.3
+ 146.9860ms,0.0V 146.9999ms,0.0
+ 147.0000ms,3.3V 147.0059ms,3.3
+ 147.0060ms,0.0V 147.0199ms,0.0
+ 147.0200ms,3.3V 147.0259ms,3.3
+ 147.0260ms,0.0V 147.0399ms,0.0
+ 147.0400ms,3.3V 147.0459ms,3.3
+ 147.0460ms,0.0V 147.0599ms,0.0
+ 147.0600ms,3.3V 147.0659ms,3.3
+ 147.0660ms,0.0V 147.0799ms,0.0
+ 147.0800ms,3.3V 147.0859ms,3.3
+ 147.0860ms,0.0V 147.0999ms,0.0
+ 147.1000ms,3.3V 147.1059ms,3.3
+ 147.1060ms,0.0V 147.1199ms,0.0
+ 147.1200ms,3.3V 147.1259ms,3.3
+ 147.1260ms,0.0V 147.1399ms,0.0
+ 147.1400ms,3.3V 147.1459ms,3.3
+ 147.1460ms,0.0V 147.1599ms,0.0
+ 147.1600ms,3.3V 147.1659ms,3.3
+ 147.1660ms,0.0V 147.1799ms,0.0
+ 147.1800ms,3.3V 147.1859ms,3.3
+ 147.1860ms,0.0V 147.1999ms,0.0
+ 147.2000ms,3.3V 147.2059ms,3.3
+ 147.2060ms,0.0V 147.2199ms,0.0
+ 147.2200ms,3.3V 147.2259ms,3.3
+ 147.2260ms,0.0V 147.2399ms,0.0
+ 147.2400ms,3.3V 147.2459ms,3.3
+ 147.2460ms,0.0V 147.2599ms,0.0
+ 147.2600ms,3.3V 147.2659ms,3.3
+ 147.2660ms,0.0V 147.2799ms,0.0
+ 147.2800ms,3.3V 147.2859ms,3.3
+ 147.2860ms,0.0V 147.2999ms,0.0
+ 147.3000ms,3.3V 147.3059ms,3.3
+ 147.3060ms,0.0V 147.3199ms,0.0
+ 147.3200ms,3.3V 147.3259ms,3.3
+ 147.3260ms,0.0V 147.3399ms,0.0
+ 147.3400ms,3.3V 147.3459ms,3.3
+ 147.3460ms,0.0V 147.3599ms,0.0
+ 147.3600ms,3.3V 147.3659ms,3.3
+ 147.3660ms,0.0V 147.3799ms,0.0
+ 147.3800ms,3.3V 147.3859ms,3.3
+ 147.3860ms,0.0V 147.3999ms,0.0
+ 147.4000ms,3.3V 147.4059ms,3.3
+ 147.4060ms,0.0V 147.4199ms,0.0
+ 147.4200ms,3.3V 147.4259ms,3.3
+ 147.4260ms,0.0V 147.4399ms,0.0
+ 147.4400ms,3.3V 147.4459ms,3.3
+ 147.4460ms,0.0V 147.4599ms,0.0
+ 147.4600ms,3.3V 147.4659ms,3.3
+ 147.4660ms,0.0V 147.4799ms,0.0
+ 147.4800ms,3.3V 147.4859ms,3.3
+ 147.4860ms,0.0V 147.4999ms,0.0
+ 147.5000ms,3.3V 147.5059ms,3.3
+ 147.5060ms,0.0V 147.5199ms,0.0
+ 147.5200ms,3.3V 147.5259ms,3.3
+ 147.5260ms,0.0V 147.5399ms,0.0
+ 147.5400ms,3.3V 147.5459ms,3.3
+ 147.5460ms,0.0V 147.5599ms,0.0
+ 147.5600ms,3.3V 147.5659ms,3.3
+ 147.5660ms,0.0V 147.5799ms,0.0
+ 147.5800ms,3.3V 147.5859ms,3.3
+ 147.5860ms,0.0V 147.5999ms,0.0
+ 147.6000ms,3.3V 147.6059ms,3.3
+ 147.6060ms,0.0V 147.6199ms,0.0
+ 147.6200ms,3.3V 147.6259ms,3.3
+ 147.6260ms,0.0V 147.6399ms,0.0
+ 147.6400ms,3.3V 147.6459ms,3.3
+ 147.6460ms,0.0V 147.6599ms,0.0
+ 147.6600ms,3.3V 147.6659ms,3.3
+ 147.6660ms,0.0V 147.6799ms,0.0
+ 147.6800ms,3.3V 147.6859ms,3.3
+ 147.6860ms,0.0V 147.6999ms,0.0
+ 147.7000ms,3.3V 147.7059ms,3.3
+ 147.7060ms,0.0V 147.7199ms,0.0
+ 147.7200ms,3.3V 147.7259ms,3.3
+ 147.7260ms,0.0V 147.7399ms,0.0
+ 147.7400ms,3.3V 147.7459ms,3.3
+ 147.7460ms,0.0V 147.7599ms,0.0
+ 147.7600ms,3.3V 147.7659ms,3.3
+ 147.7660ms,0.0V 147.7799ms,0.0
+ 147.7800ms,3.3V 147.7859ms,3.3
+ 147.7860ms,0.0V 147.7999ms,0.0
+ 147.8000ms,3.3V 147.8059ms,3.3
+ 147.8060ms,0.0V 147.8199ms,0.0
+ 147.8200ms,3.3V 147.8259ms,3.3
+ 147.8260ms,0.0V 147.8399ms,0.0
+ 147.8400ms,3.3V 147.8459ms,3.3
+ 147.8460ms,0.0V 147.8599ms,0.0
+ 147.8600ms,3.3V 147.8659ms,3.3
+ 147.8660ms,0.0V 147.8799ms,0.0
+ 147.8800ms,3.3V 147.8859ms,3.3
+ 147.8860ms,0.0V 147.8999ms,0.0
+ 147.9000ms,3.3V 147.9059ms,3.3
+ 147.9060ms,0.0V 147.9199ms,0.0
+ 147.9200ms,3.3V 147.9259ms,3.3
+ 147.9260ms,0.0V 147.9399ms,0.0
+ 147.9400ms,3.3V 147.9459ms,3.3
+ 147.9460ms,0.0V 147.9599ms,0.0
+ 147.9600ms,3.3V 147.9659ms,3.3
+ 147.9660ms,0.0V 147.9799ms,0.0
+ 147.9800ms,3.3V 147.9859ms,3.3
+ 147.9860ms,0.0V 147.9999ms,0.0
+ 148.0000ms,3.3V 148.0059ms,3.3
+ 148.0060ms,0.0V 148.0199ms,0.0
+ 148.0200ms,3.3V 148.0259ms,3.3
+ 148.0260ms,0.0V 148.0399ms,0.0
+ 148.0400ms,3.3V 148.0459ms,3.3
+ 148.0460ms,0.0V 148.0599ms,0.0
+ 148.0600ms,3.3V 148.0659ms,3.3
+ 148.0660ms,0.0V 148.0799ms,0.0
+ 148.0800ms,3.3V 148.0859ms,3.3
+ 148.0860ms,0.0V 148.0999ms,0.0
+ 148.1000ms,3.3V 148.1059ms,3.3
+ 148.1060ms,0.0V 148.1199ms,0.0
+ 148.1200ms,3.3V 148.1259ms,3.3
+ 148.1260ms,0.0V 148.1399ms,0.0
+ 148.1400ms,3.3V 148.1459ms,3.3
+ 148.1460ms,0.0V 148.1599ms,0.0
+ 148.1600ms,3.3V 148.1659ms,3.3
+ 148.1660ms,0.0V 148.1799ms,0.0
+ 148.1800ms,3.3V 148.1859ms,3.3
+ 148.1860ms,0.0V 148.1999ms,0.0
+ 148.2000ms,3.3V 148.2059ms,3.3
+ 148.2060ms,0.0V 148.2199ms,0.0
+ 148.2200ms,3.3V 148.2259ms,3.3
+ 148.2260ms,0.0V 148.2399ms,0.0
+ 148.2400ms,3.3V 148.2459ms,3.3
+ 148.2460ms,0.0V 148.2599ms,0.0
+ 148.2600ms,3.3V 148.2659ms,3.3
+ 148.2660ms,0.0V 148.2799ms,0.0
+ 148.2800ms,3.3V 148.2859ms,3.3
+ 148.2860ms,0.0V 148.2999ms,0.0
+ 148.3000ms,3.3V 148.3059ms,3.3
+ 148.3060ms,0.0V 148.3199ms,0.0
+ 148.3200ms,3.3V 148.3259ms,3.3
+ 148.3260ms,0.0V 148.3399ms,0.0
+ 148.3400ms,3.3V 148.3459ms,3.3
+ 148.3460ms,0.0V 148.3599ms,0.0
+ 148.3600ms,3.3V 148.3659ms,3.3
+ 148.3660ms,0.0V 148.3799ms,0.0
+ 148.3800ms,3.3V 148.3859ms,3.3
+ 148.3860ms,0.0V 148.3999ms,0.0
+ 148.4000ms,3.3V 148.4059ms,3.3
+ 148.4060ms,0.0V 148.4199ms,0.0
+ 148.4200ms,3.3V 148.4259ms,3.3
+ 148.4260ms,0.0V 148.4399ms,0.0
+ 148.4400ms,3.3V 148.4459ms,3.3
+ 148.4460ms,0.0V 148.4599ms,0.0
+ 148.4600ms,3.3V 148.4659ms,3.3
+ 148.4660ms,0.0V 148.4799ms,0.0
+ 148.4800ms,3.3V 148.4859ms,3.3
+ 148.4860ms,0.0V 148.4999ms,0.0
+ 148.5000ms,3.3V 148.5059ms,3.3
+ 148.5060ms,0.0V 148.5199ms,0.0
+ 148.5200ms,3.3V 148.5259ms,3.3
+ 148.5260ms,0.0V 148.5399ms,0.0
+ 148.5400ms,3.3V 148.5459ms,3.3
+ 148.5460ms,0.0V 148.5599ms,0.0
+ 148.5600ms,3.3V 148.5659ms,3.3
+ 148.5660ms,0.0V 148.5799ms,0.0
+ 148.5800ms,3.3V 148.5859ms,3.3
+ 148.5860ms,0.0V 148.5999ms,0.0
+ 148.6000ms,3.3V 148.6059ms,3.3
+ 148.6060ms,0.0V 148.6199ms,0.0
+ 148.6200ms,3.3V 148.6259ms,3.3
+ 148.6260ms,0.0V 148.6399ms,0.0
+ 148.6400ms,3.3V 148.6459ms,3.3
+ 148.6460ms,0.0V 148.6599ms,0.0
+ 148.6600ms,3.3V 148.6659ms,3.3
+ 148.6660ms,0.0V 148.6799ms,0.0
+ 148.6800ms,3.3V 148.6859ms,3.3
+ 148.6860ms,0.0V 148.6999ms,0.0
+ 148.7000ms,3.3V 148.7059ms,3.3
+ 148.7060ms,0.0V 148.7199ms,0.0
+ 148.7200ms,3.3V 148.7259ms,3.3
+ 148.7260ms,0.0V 148.7399ms,0.0
+ 148.7400ms,3.3V 148.7459ms,3.3
+ 148.7460ms,0.0V 148.7599ms,0.0
+ 148.7600ms,3.3V 148.7659ms,3.3
+ 148.7660ms,0.0V 148.7799ms,0.0
+ 148.7800ms,3.3V 148.7859ms,3.3
+ 148.7860ms,0.0V 148.7999ms,0.0
+ 148.8000ms,3.3V 148.8059ms,3.3
+ 148.8060ms,0.0V 148.8199ms,0.0
+ 148.8200ms,3.3V 148.8259ms,3.3
+ 148.8260ms,0.0V 148.8399ms,0.0
+ 148.8400ms,3.3V 148.8459ms,3.3
+ 148.8460ms,0.0V 148.8599ms,0.0
+ 148.8600ms,3.3V 148.8659ms,3.3
+ 148.8660ms,0.0V 148.8799ms,0.0
+ 148.8800ms,3.3V 148.8859ms,3.3
+ 148.8860ms,0.0V 148.8999ms,0.0
+ 148.9000ms,3.3V 148.9059ms,3.3
+ 148.9060ms,0.0V 148.9199ms,0.0
+ 148.9200ms,3.3V 148.9259ms,3.3
+ 148.9260ms,0.0V 148.9399ms,0.0
+ 148.9400ms,3.3V 148.9459ms,3.3
+ 148.9460ms,0.0V 148.9599ms,0.0
+ 148.9600ms,3.3V 148.9659ms,3.3
+ 148.9660ms,0.0V 148.9799ms,0.0
+ 148.9800ms,3.3V 148.9859ms,3.3
+ 148.9860ms,0.0V 148.9999ms,0.0
+ 149.0000ms,3.3V 149.0059ms,3.3
+ 149.0060ms,0.0V 149.0199ms,0.0
+ 149.0200ms,3.3V 149.0259ms,3.3
+ 149.0260ms,0.0V 149.0399ms,0.0
+ 149.0400ms,3.3V 149.0459ms,3.3
+ 149.0460ms,0.0V 149.0599ms,0.0
+ 149.0600ms,3.3V 149.0659ms,3.3
+ 149.0660ms,0.0V 149.0799ms,0.0
+ 149.0800ms,3.3V 149.0859ms,3.3
+ 149.0860ms,0.0V 149.0999ms,0.0
+ 149.1000ms,3.3V 149.1059ms,3.3
+ 149.1060ms,0.0V 149.1199ms,0.0
+ 149.1200ms,3.3V 149.1259ms,3.3
+ 149.1260ms,0.0V 149.1399ms,0.0
+ 149.1400ms,3.3V 149.1459ms,3.3
+ 149.1460ms,0.0V 149.1599ms,0.0
+ 149.1600ms,3.3V 149.1659ms,3.3
+ 149.1660ms,0.0V 149.1799ms,0.0
+ 149.1800ms,3.3V 149.1859ms,3.3
+ 149.1860ms,0.0V 149.1999ms,0.0
+ 149.2000ms,3.3V 149.2059ms,3.3
+ 149.2060ms,0.0V 149.2199ms,0.0
+ 149.2200ms,3.3V 149.2259ms,3.3
+ 149.2260ms,0.0V 149.2399ms,0.0
+ 149.2400ms,3.3V 149.2459ms,3.3
+ 149.2460ms,0.0V 149.2599ms,0.0
+ 149.2600ms,3.3V 149.2659ms,3.3
+ 149.2660ms,0.0V 149.2799ms,0.0
+ 149.2800ms,3.3V 149.2859ms,3.3
+ 149.2860ms,0.0V 149.2999ms,0.0
+ 149.3000ms,3.3V 149.3059ms,3.3
+ 149.3060ms,0.0V 149.3199ms,0.0
+ 149.3200ms,3.3V 149.3259ms,3.3
+ 149.3260ms,0.0V 149.3399ms,0.0
+ 149.3400ms,3.3V 149.3459ms,3.3
+ 149.3460ms,0.0V 149.3599ms,0.0
+ 149.3600ms,3.3V 149.3659ms,3.3
+ 149.3660ms,0.0V 149.3799ms,0.0
+ 149.3800ms,3.3V 149.3859ms,3.3
+ 149.3860ms,0.0V 149.3999ms,0.0
+ 149.4000ms,3.3V 149.4059ms,3.3
+ 149.4060ms,0.0V 149.4199ms,0.0
+ 149.4200ms,3.3V 149.4259ms,3.3
+ 149.4260ms,0.0V 149.4399ms,0.0
+ 149.4400ms,3.3V 149.4459ms,3.3
+ 149.4460ms,0.0V 149.4599ms,0.0
+ 149.4600ms,3.3V 149.4659ms,3.3
+ 149.4660ms,0.0V 149.4799ms,0.0
+ 149.4800ms,3.3V 149.4859ms,3.3
+ 149.4860ms,0.0V 149.4999ms,0.0
+ 149.5000ms,3.3V 149.5059ms,3.3
+ 149.5060ms,0.0V 149.5199ms,0.0
+ 149.5200ms,3.3V 149.5259ms,3.3
+ 149.5260ms,0.0V 149.5399ms,0.0
+ 149.5400ms,3.3V 149.5459ms,3.3
+ 149.5460ms,0.0V 149.5599ms,0.0
+ 149.5600ms,3.3V 149.5659ms,3.3
+ 149.5660ms,0.0V 149.5799ms,0.0
+ 149.5800ms,3.3V 149.5859ms,3.3
+ 149.5860ms,0.0V 149.5999ms,0.0
+ 149.6000ms,3.3V 149.6059ms,3.3
+ 149.6060ms,0.0V 149.6199ms,0.0
+ 149.6200ms,3.3V 149.6259ms,3.3
+ 149.6260ms,0.0V 149.6399ms,0.0
+ 149.6400ms,3.3V 149.6459ms,3.3
+ 149.6460ms,0.0V 149.6599ms,0.0
+ 149.6600ms,3.3V 149.6659ms,3.3
+ 149.6660ms,0.0V 149.6799ms,0.0
+ 149.6800ms,3.3V 149.6859ms,3.3
+ 149.6860ms,0.0V 149.6999ms,0.0
+ 149.7000ms,3.3V 149.7059ms,3.3
+ 149.7060ms,0.0V 149.7199ms,0.0
+ 149.7200ms,3.3V 149.7259ms,3.3
+ 149.7260ms,0.0V 149.7399ms,0.0
+ 149.7400ms,3.3V 149.7459ms,3.3
+ 149.7460ms,0.0V 149.7599ms,0.0
+ 149.7600ms,3.3V 149.7659ms,3.3
+ 149.7660ms,0.0V 149.7799ms,0.0
+ 149.7800ms,3.3V 149.7859ms,3.3
+ 149.7860ms,0.0V 149.7999ms,0.0
+ 149.8000ms,3.3V 149.8059ms,3.3
+ 149.8060ms,0.0V 149.8199ms,0.0
+ 149.8200ms,3.3V 149.8259ms,3.3
+ 149.8260ms,0.0V 149.8399ms,0.0
+ 149.8400ms,3.3V 149.8459ms,3.3
+ 149.8460ms,0.0V 149.8599ms,0.0
+ 149.8600ms,3.3V 149.8659ms,3.3
+ 149.8660ms,0.0V 149.8799ms,0.0
+ 149.8800ms,3.3V 149.8859ms,3.3
+ 149.8860ms,0.0V 149.8999ms,0.0
+ 149.9000ms,3.3V 149.9059ms,3.3
+ 149.9060ms,0.0V 149.9199ms,0.0
+ 149.9200ms,3.3V 149.9259ms,3.3
+ 149.9260ms,0.0V 149.9399ms,0.0
+ 149.9400ms,3.3V 149.9459ms,3.3
+ 149.9460ms,0.0V 149.9599ms,0.0
+ 149.9600ms,3.3V 149.9659ms,3.3
+ 149.9660ms,0.0V 149.9799ms,0.0
+ 149.9800ms,3.3V 149.9859ms,3.3
+ 149.9860ms,0.0V 149.9999ms,0.0
+ 150.0000ms,3.3V 150.0059ms,3.3
+ 150.0060ms,0.0V 150.0199ms,0.0
+ 150.0200ms,3.3V 150.0259ms,3.3
+ 150.0260ms,0.0V 150.0399ms,0.0
+ 150.0400ms,3.3V 150.0459ms,3.3
+ 150.0460ms,0.0V 150.0599ms,0.0
+ 150.0600ms,3.3V 150.0659ms,3.3
+ 150.0660ms,0.0V 150.0799ms,0.0
+ 150.0800ms,3.3V 150.0859ms,3.3
+ 150.0860ms,0.0V 150.0999ms,0.0
+ 150.1000ms,3.3V 150.1059ms,3.3
+ 150.1060ms,0.0V 150.1199ms,0.0
+ 150.1200ms,3.3V 150.1259ms,3.3
+ 150.1260ms,0.0V 150.1399ms,0.0
+ 150.1400ms,3.3V 150.1459ms,3.3
+ 150.1460ms,0.0V 150.1599ms,0.0
+ 150.1600ms,3.3V 150.1659ms,3.3
+ 150.1660ms,0.0V 150.1799ms,0.0
+ 150.1800ms,3.3V 150.1859ms,3.3
+ 150.1860ms,0.0V 150.1999ms,0.0
+ 150.2000ms,3.3V 150.2059ms,3.3
+ 150.2060ms,0.0V 150.2199ms,0.0
+ 150.2200ms,3.3V 150.2259ms,3.3
+ 150.2260ms,0.0V 150.2399ms,0.0
+ 150.2400ms,3.3V 150.2459ms,3.3
+ 150.2460ms,0.0V 150.2599ms,0.0
+ 150.2600ms,3.3V 150.2659ms,3.3
+ 150.2660ms,0.0V 150.2799ms,0.0
+ 150.2800ms,3.3V 150.2859ms,3.3
+ 150.2860ms,0.0V 150.2999ms,0.0
+ 150.3000ms,3.3V 150.3059ms,3.3
+ 150.3060ms,0.0V 150.3199ms,0.0
+ 150.3200ms,3.3V 150.3259ms,3.3
+ 150.3260ms,0.0V 150.3399ms,0.0
+ 150.3400ms,3.3V 150.3459ms,3.3
+ 150.3460ms,0.0V 150.3599ms,0.0
+ 150.3600ms,3.3V 150.3661ms,3.3
+ 150.3662ms,0.0V 150.3799ms,0.0
+ 150.3800ms,3.3V 150.3861ms,3.3
+ 150.3862ms,0.0V 150.3999ms,0.0
+ 150.4000ms,3.3V 150.4061ms,3.3
+ 150.4062ms,0.0V 150.4199ms,0.0
+ 150.4200ms,3.3V 150.4261ms,3.3
+ 150.4262ms,0.0V 150.4399ms,0.0
+ 150.4400ms,3.3V 150.4461ms,3.3
+ 150.4462ms,0.0V 150.4599ms,0.0
+ 150.4600ms,3.3V 150.4661ms,3.3
+ 150.4662ms,0.0V 150.4799ms,0.0
+ 150.4800ms,3.3V 150.4861ms,3.3
+ 150.4862ms,0.0V 150.4999ms,0.0
+ 150.5000ms,3.3V 150.5061ms,3.3
+ 150.5062ms,0.0V 150.5199ms,0.0
+ 150.5200ms,3.3V 150.5261ms,3.3
+ 150.5262ms,0.0V 150.5399ms,0.0
+ 150.5400ms,3.3V 150.5461ms,3.3
+ 150.5462ms,0.0V 150.5599ms,0.0
+ 150.5600ms,3.3V 150.5661ms,3.3
+ 150.5662ms,0.0V 150.5799ms,0.0
+ 150.5800ms,3.3V 150.5861ms,3.3
+ 150.5862ms,0.0V 150.5999ms,0.0
+ 150.6000ms,3.3V 150.6061ms,3.3
+ 150.6062ms,0.0V 150.6199ms,0.0
+ 150.6200ms,3.3V 150.6261ms,3.3
+ 150.6262ms,0.0V 150.6399ms,0.0
+ 150.6400ms,3.3V 150.6461ms,3.3
+ 150.6462ms,0.0V 150.6599ms,0.0
+ 150.6600ms,3.3V 150.6661ms,3.3
+ 150.6662ms,0.0V 150.6799ms,0.0
+ 150.6800ms,3.3V 150.6861ms,3.3
+ 150.6862ms,0.0V 150.6999ms,0.0
+ 150.7000ms,3.3V 150.7061ms,3.3
+ 150.7062ms,0.0V 150.7199ms,0.0
+ 150.7200ms,3.3V 150.7261ms,3.3
+ 150.7262ms,0.0V 150.7399ms,0.0
+ 150.7400ms,3.3V 150.7461ms,3.3
+ 150.7462ms,0.0V 150.7599ms,0.0
+ 150.7600ms,3.3V 150.7661ms,3.3
+ 150.7662ms,0.0V 150.7799ms,0.0
+ 150.7800ms,3.3V 150.7861ms,3.3
+ 150.7862ms,0.0V 150.7999ms,0.0
+ 150.8000ms,3.3V 150.8061ms,3.3
+ 150.8062ms,0.0V 150.8199ms,0.0
+ 150.8200ms,3.3V 150.8261ms,3.3
+ 150.8262ms,0.0V 150.8399ms,0.0
+ 150.8400ms,3.3V 150.8461ms,3.3
+ 150.8462ms,0.0V 150.8599ms,0.0
+ 150.8600ms,3.3V 150.8661ms,3.3
+ 150.8662ms,0.0V 150.8799ms,0.0
+ 150.8800ms,3.3V 150.8861ms,3.3
+ 150.8862ms,0.0V 150.8999ms,0.0
+ 150.9000ms,3.3V 150.9061ms,3.3
+ 150.9062ms,0.0V 150.9199ms,0.0
+ 150.9200ms,3.3V 150.9261ms,3.3
+ 150.9262ms,0.0V 150.9399ms,0.0
+ 150.9400ms,3.3V 150.9461ms,3.3
+ 150.9462ms,0.0V 150.9599ms,0.0
+ 150.9600ms,3.3V 150.9661ms,3.3
+ 150.9662ms,0.0V 150.9799ms,0.0
+ 150.9800ms,3.3V 150.9861ms,3.3
+ 150.9862ms,0.0V 150.9999ms,0.0
+ 151.0000ms,3.3V 151.0061ms,3.3
+ 151.0062ms,0.0V 151.0199ms,0.0
+ 151.0200ms,3.3V 151.0261ms,3.3
+ 151.0262ms,0.0V 151.0399ms,0.0
+ 151.0400ms,3.3V 151.0461ms,3.3
+ 151.0462ms,0.0V 151.0599ms,0.0
+ 151.0600ms,3.3V 151.0661ms,3.3
+ 151.0662ms,0.0V 151.0799ms,0.0
+ 151.0800ms,3.3V 151.0861ms,3.3
+ 151.0862ms,0.0V 151.0999ms,0.0
+ 151.1000ms,3.3V 151.1061ms,3.3
+ 151.1062ms,0.0V 151.1199ms,0.0
+ 151.1200ms,3.3V 151.1261ms,3.3
+ 151.1262ms,0.0V 151.1399ms,0.0
+ 151.1400ms,3.3V 151.1461ms,3.3
+ 151.1462ms,0.0V 151.1599ms,0.0
+ 151.1600ms,3.3V 151.1661ms,3.3
+ 151.1662ms,0.0V 151.1799ms,0.0
+ 151.1800ms,3.3V 151.1861ms,3.3
+ 151.1862ms,0.0V 151.1999ms,0.0
+ 151.2000ms,3.3V 151.2061ms,3.3
+ 151.2062ms,0.0V 151.2199ms,0.0
+ 151.2200ms,3.3V 151.2261ms,3.3
+ 151.2262ms,0.0V 151.2399ms,0.0
+ 151.2400ms,3.3V 151.2461ms,3.3
+ 151.2462ms,0.0V 151.2599ms,0.0
+ 151.2600ms,3.3V 151.2661ms,3.3
+ 151.2662ms,0.0V 151.2799ms,0.0
+ 151.2800ms,3.3V 151.2861ms,3.3
+ 151.2862ms,0.0V 151.2999ms,0.0
+ 151.3000ms,3.3V 151.3061ms,3.3
+ 151.3062ms,0.0V 151.3199ms,0.0
+ 151.3200ms,3.3V 151.3261ms,3.3
+ 151.3262ms,0.0V 151.3399ms,0.0
+ 151.3400ms,3.3V 151.3461ms,3.3
+ 151.3462ms,0.0V 151.3599ms,0.0
+ 151.3600ms,3.3V 151.3661ms,3.3
+ 151.3662ms,0.0V 151.3799ms,0.0
+ 151.3800ms,3.3V 151.3861ms,3.3
+ 151.3862ms,0.0V 151.3999ms,0.0
+ 151.4000ms,3.3V 151.4061ms,3.3
+ 151.4062ms,0.0V 151.4199ms,0.0
+ 151.4200ms,3.3V 151.4261ms,3.3
+ 151.4262ms,0.0V 151.4399ms,0.0
+ 151.4400ms,3.3V 151.4461ms,3.3
+ 151.4462ms,0.0V 151.4599ms,0.0
+ 151.4600ms,3.3V 151.4661ms,3.3
+ 151.4662ms,0.0V 151.4799ms,0.0
+ 151.4800ms,3.3V 151.4861ms,3.3
+ 151.4862ms,0.0V 151.4999ms,0.0
+ 151.5000ms,3.3V 151.5061ms,3.3
+ 151.5062ms,0.0V 151.5199ms,0.0
+ 151.5200ms,3.3V 151.5261ms,3.3
+ 151.5262ms,0.0V 151.5399ms,0.0
+ 151.5400ms,3.3V 151.5461ms,3.3
+ 151.5462ms,0.0V 151.5599ms,0.0
+ 151.5600ms,3.3V 151.5661ms,3.3
+ 151.5662ms,0.0V 151.5799ms,0.0
+ 151.5800ms,3.3V 151.5861ms,3.3
+ 151.5862ms,0.0V 151.5999ms,0.0
+ 151.6000ms,3.3V 151.6061ms,3.3
+ 151.6062ms,0.0V 151.6199ms,0.0
+ 151.6200ms,3.3V 151.6261ms,3.3
+ 151.6262ms,0.0V 151.6399ms,0.0
+ 151.6400ms,3.3V 151.6461ms,3.3
+ 151.6462ms,0.0V 151.6599ms,0.0
+ 151.6600ms,3.3V 151.6661ms,3.3
+ 151.6662ms,0.0V 151.6799ms,0.0
+ 151.6800ms,3.3V 151.6861ms,3.3
+ 151.6862ms,0.0V 151.6999ms,0.0
+ 151.7000ms,3.3V 151.7061ms,3.3
+ 151.7062ms,0.0V 151.7199ms,0.0
+ 151.7200ms,3.3V 151.7261ms,3.3
+ 151.7262ms,0.0V 151.7399ms,0.0
+ 151.7400ms,3.3V 151.7461ms,3.3
+ 151.7462ms,0.0V 151.7599ms,0.0
+ 151.7600ms,3.3V 151.7661ms,3.3
+ 151.7662ms,0.0V 151.7799ms,0.0
+ 151.7800ms,3.3V 151.7861ms,3.3
+ 151.7862ms,0.0V 151.7999ms,0.0
+ 151.8000ms,3.3V 151.8061ms,3.3
+ 151.8062ms,0.0V 151.8199ms,0.0
+ 151.8200ms,3.3V 151.8261ms,3.3
+ 151.8262ms,0.0V 151.8399ms,0.0
+ 151.8400ms,3.3V 151.8461ms,3.3
+ 151.8462ms,0.0V 151.8599ms,0.0
+ 151.8600ms,3.3V 151.8661ms,3.3
+ 151.8662ms,0.0V 151.8799ms,0.0
+ 151.8800ms,3.3V 151.8861ms,3.3
+ 151.8862ms,0.0V 151.8999ms,0.0
+ 151.9000ms,3.3V 151.9061ms,3.3
+ 151.9062ms,0.0V 151.9199ms,0.0
+ 151.9200ms,3.3V 151.9261ms,3.3
+ 151.9262ms,0.0V 151.9399ms,0.0
+ 151.9400ms,3.3V 151.9461ms,3.3
+ 151.9462ms,0.0V 151.9599ms,0.0
+ 151.9600ms,3.3V 151.9661ms,3.3
+ 151.9662ms,0.0V 151.9799ms,0.0
+ 151.9800ms,3.3V 151.9861ms,3.3
+ 151.9862ms,0.0V 151.9999ms,0.0
+ 152.0000ms,3.3V 152.0061ms,3.3
+ 152.0062ms,0.0V 152.0199ms,0.0
+ 152.0200ms,3.3V 152.0261ms,3.3
+ 152.0262ms,0.0V 152.0399ms,0.0
+ 152.0400ms,3.3V 152.0461ms,3.3
+ 152.0462ms,0.0V 152.0599ms,0.0
+ 152.0600ms,3.3V 152.0661ms,3.3
+ 152.0662ms,0.0V 152.0799ms,0.0
+ 152.0800ms,3.3V 152.0861ms,3.3
+ 152.0862ms,0.0V 152.0999ms,0.0
+ 152.1000ms,3.3V 152.1061ms,3.3
+ 152.1062ms,0.0V 152.1199ms,0.0
+ 152.1200ms,3.3V 152.1261ms,3.3
+ 152.1262ms,0.0V 152.1399ms,0.0
+ 152.1400ms,3.3V 152.1461ms,3.3
+ 152.1462ms,0.0V 152.1599ms,0.0
+ 152.1600ms,3.3V 152.1661ms,3.3
+ 152.1662ms,0.0V 152.1799ms,0.0
+ 152.1800ms,3.3V 152.1861ms,3.3
+ 152.1862ms,0.0V 152.1999ms,0.0
+ 152.2000ms,3.3V 152.2061ms,3.3
+ 152.2062ms,0.0V 152.2199ms,0.0
+ 152.2200ms,3.3V 152.2261ms,3.3
+ 152.2262ms,0.0V 152.2399ms,0.0
+ 152.2400ms,3.3V 152.2461ms,3.3
+ 152.2462ms,0.0V 152.2599ms,0.0
+ 152.2600ms,3.3V 152.2661ms,3.3
+ 152.2662ms,0.0V 152.2799ms,0.0
+ 152.2800ms,3.3V 152.2861ms,3.3
+ 152.2862ms,0.0V 152.2999ms,0.0
+ 152.3000ms,3.3V 152.3061ms,3.3
+ 152.3062ms,0.0V 152.3199ms,0.0
+ 152.3200ms,3.3V 152.3261ms,3.3
+ 152.3262ms,0.0V 152.3399ms,0.0
+ 152.3400ms,3.3V 152.3461ms,3.3
+ 152.3462ms,0.0V 152.3599ms,0.0
+ 152.3600ms,3.3V 152.3661ms,3.3
+ 152.3662ms,0.0V 152.3799ms,0.0
+ 152.3800ms,3.3V 152.3861ms,3.3
+ 152.3862ms,0.0V 152.3999ms,0.0
+ 152.4000ms,3.3V 152.4061ms,3.3
+ 152.4062ms,0.0V 152.4199ms,0.0
+ 152.4200ms,3.3V 152.4261ms,3.3
+ 152.4262ms,0.0V 152.4399ms,0.0
+ 152.4400ms,3.3V 152.4461ms,3.3
+ 152.4462ms,0.0V 152.4599ms,0.0
+ 152.4600ms,3.3V 152.4661ms,3.3
+ 152.4662ms,0.0V 152.4799ms,0.0
+ 152.4800ms,3.3V 152.4861ms,3.3
+ 152.4862ms,0.0V 152.4999ms,0.0
+ 152.5000ms,3.3V 152.5061ms,3.3
+ 152.5062ms,0.0V 152.5199ms,0.0
+ 152.5200ms,3.3V 152.5261ms,3.3
+ 152.5262ms,0.0V 152.5399ms,0.0
+ 152.5400ms,3.3V 152.5461ms,3.3
+ 152.5462ms,0.0V 152.5599ms,0.0
+ 152.5600ms,3.3V 152.5661ms,3.3
+ 152.5662ms,0.0V 152.5799ms,0.0
+ 152.5800ms,3.3V 152.5861ms,3.3
+ 152.5862ms,0.0V 152.5999ms,0.0
+ 152.6000ms,3.3V 152.6061ms,3.3
+ 152.6062ms,0.0V 152.6199ms,0.0
+ 152.6200ms,3.3V 152.6261ms,3.3
+ 152.6262ms,0.0V 152.6399ms,0.0
+ 152.6400ms,3.3V 152.6461ms,3.3
+ 152.6462ms,0.0V 152.6599ms,0.0
+ 152.6600ms,3.3V 152.6661ms,3.3
+ 152.6662ms,0.0V 152.6799ms,0.0
+ 152.6800ms,3.3V 152.6861ms,3.3
+ 152.6862ms,0.0V 152.6999ms,0.0
+ 152.7000ms,3.3V 152.7061ms,3.3
+ 152.7062ms,0.0V 152.7199ms,0.0
+ 152.7200ms,3.3V 152.7261ms,3.3
+ 152.7262ms,0.0V 152.7399ms,0.0
+ 152.7400ms,3.3V 152.7461ms,3.3
+ 152.7462ms,0.0V 152.7599ms,0.0
+ 152.7600ms,3.3V 152.7661ms,3.3
+ 152.7662ms,0.0V 152.7799ms,0.0
+ 152.7800ms,3.3V 152.7861ms,3.3
+ 152.7862ms,0.0V 152.7999ms,0.0
+ 152.8000ms,3.3V 152.8061ms,3.3
+ 152.8062ms,0.0V 152.8199ms,0.0
+ 152.8200ms,3.3V 152.8261ms,3.3
+ 152.8262ms,0.0V 152.8399ms,0.0
+ 152.8400ms,3.3V 152.8461ms,3.3
+ 152.8462ms,0.0V 152.8599ms,0.0
+ 152.8600ms,3.3V 152.8661ms,3.3
+ 152.8662ms,0.0V 152.8799ms,0.0
+ 152.8800ms,3.3V 152.8861ms,3.3
+ 152.8862ms,0.0V 152.8999ms,0.0
+ 152.9000ms,3.3V 152.9061ms,3.3
+ 152.9062ms,0.0V 152.9199ms,0.0
+ 152.9200ms,3.3V 152.9261ms,3.3
+ 152.9262ms,0.0V 152.9399ms,0.0
+ 152.9400ms,3.3V 152.9461ms,3.3
+ 152.9462ms,0.0V 152.9599ms,0.0
+ 152.9600ms,3.3V 152.9661ms,3.3
+ 152.9662ms,0.0V 152.9799ms,0.0
+ 152.9800ms,3.3V 152.9861ms,3.3
+ 152.9862ms,0.0V 152.9999ms,0.0
+ 153.0000ms,3.3V 153.0061ms,3.3
+ 153.0062ms,0.0V 153.0199ms,0.0
+ 153.0200ms,3.3V 153.0261ms,3.3
+ 153.0262ms,0.0V 153.0399ms,0.0
+ 153.0400ms,3.3V 153.0461ms,3.3
+ 153.0462ms,0.0V 153.0599ms,0.0
+ 153.0600ms,3.3V 153.0661ms,3.3
+ 153.0662ms,0.0V 153.0799ms,0.0
+ 153.0800ms,3.3V 153.0861ms,3.3
+ 153.0862ms,0.0V 153.0999ms,0.0
+ 153.1000ms,3.3V 153.1061ms,3.3
+ 153.1062ms,0.0V 153.1199ms,0.0
+ 153.1200ms,3.3V 153.1261ms,3.3
+ 153.1262ms,0.0V 153.1399ms,0.0
+ 153.1400ms,3.3V 153.1461ms,3.3
+ 153.1462ms,0.0V 153.1599ms,0.0
+ 153.1600ms,3.3V 153.1661ms,3.3
+ 153.1662ms,0.0V 153.1799ms,0.0
+ 153.1800ms,3.3V 153.1861ms,3.3
+ 153.1862ms,0.0V 153.1999ms,0.0
+ 153.2000ms,3.3V 153.2061ms,3.3
+ 153.2062ms,0.0V 153.2199ms,0.0
+ 153.2200ms,3.3V 153.2261ms,3.3
+ 153.2262ms,0.0V 153.2399ms,0.0
+ 153.2400ms,3.3V 153.2461ms,3.3
+ 153.2462ms,0.0V 153.2599ms,0.0
+ 153.2600ms,3.3V 153.2661ms,3.3
+ 153.2662ms,0.0V 153.2799ms,0.0
+ 153.2800ms,3.3V 153.2861ms,3.3
+ 153.2862ms,0.0V 153.2999ms,0.0
+ 153.3000ms,3.3V 153.3061ms,3.3
+ 153.3062ms,0.0V 153.3199ms,0.0
+ 153.3200ms,3.3V 153.3261ms,3.3
+ 153.3262ms,0.0V 153.3399ms,0.0
+ 153.3400ms,3.3V 153.3461ms,3.3
+ 153.3462ms,0.0V 153.3599ms,0.0
+ 153.3600ms,3.3V 153.3661ms,3.3
+ 153.3662ms,0.0V 153.3799ms,0.0
+ 153.3800ms,3.3V 153.3861ms,3.3
+ 153.3862ms,0.0V 153.3999ms,0.0
+ 153.4000ms,3.3V 153.4061ms,3.3
+ 153.4062ms,0.0V 153.4199ms,0.0
+ 153.4200ms,3.3V 153.4261ms,3.3
+ 153.4262ms,0.0V 153.4399ms,0.0
+ 153.4400ms,3.3V 153.4461ms,3.3
+ 153.4462ms,0.0V 153.4599ms,0.0
+ 153.4600ms,3.3V 153.4661ms,3.3
+ 153.4662ms,0.0V 153.4799ms,0.0
+ 153.4800ms,3.3V 153.4861ms,3.3
+ 153.4862ms,0.0V 153.4999ms,0.0
+ 153.5000ms,3.3V 153.5061ms,3.3
+ 153.5062ms,0.0V 153.5199ms,0.0
+ 153.5200ms,3.3V 153.5261ms,3.3
+ 153.5262ms,0.0V 153.5399ms,0.0
+ 153.5400ms,3.3V 153.5461ms,3.3
+ 153.5462ms,0.0V 153.5599ms,0.0
+ 153.5600ms,3.3V 153.5661ms,3.3
+ 153.5662ms,0.0V 153.5799ms,0.0
+ 153.5800ms,3.3V 153.5861ms,3.3
+ 153.5862ms,0.0V 153.5999ms,0.0
+ 153.6000ms,3.3V 153.6061ms,3.3
+ 153.6062ms,0.0V 153.6199ms,0.0
+ 153.6200ms,3.3V 153.6261ms,3.3
+ 153.6262ms,0.0V 153.6399ms,0.0
+ 153.6400ms,3.3V 153.6461ms,3.3
+ 153.6462ms,0.0V 153.6599ms,0.0
+ 153.6600ms,3.3V 153.6661ms,3.3
+ 153.6662ms,0.0V 153.6799ms,0.0
+ 153.6800ms,3.3V 153.6861ms,3.3
+ 153.6862ms,0.0V 153.6999ms,0.0
+ 153.7000ms,3.3V 153.7061ms,3.3
+ 153.7062ms,0.0V 153.7199ms,0.0
+ 153.7200ms,3.3V 153.7261ms,3.3
+ 153.7262ms,0.0V 153.7399ms,0.0
+ 153.7400ms,3.3V 153.7461ms,3.3
+ 153.7462ms,0.0V 153.7599ms,0.0
+ 153.7600ms,3.3V 153.7661ms,3.3
+ 153.7662ms,0.0V 153.7799ms,0.0
+ 153.7800ms,3.3V 153.7861ms,3.3
+ 153.7862ms,0.0V 153.7999ms,0.0
+ 153.8000ms,3.3V 153.8061ms,3.3
+ 153.8062ms,0.0V 153.8199ms,0.0
+ 153.8200ms,3.3V 153.8261ms,3.3
+ 153.8262ms,0.0V 153.8399ms,0.0
+ 153.8400ms,3.3V 153.8461ms,3.3
+ 153.8462ms,0.0V 153.8599ms,0.0
+ 153.8600ms,3.3V 153.8661ms,3.3
+ 153.8662ms,0.0V 153.8799ms,0.0
+ 153.8800ms,3.3V 153.8861ms,3.3
+ 153.8862ms,0.0V 153.8999ms,0.0
+ 153.9000ms,3.3V 153.9061ms,3.3
+ 153.9062ms,0.0V 153.9199ms,0.0
+ 153.9200ms,3.3V 153.9261ms,3.3
+ 153.9262ms,0.0V 153.9399ms,0.0
+ 153.9400ms,3.3V 153.9461ms,3.3
+ 153.9462ms,0.0V 153.9599ms,0.0
+ 153.9600ms,3.3V 153.9661ms,3.3
+ 153.9662ms,0.0V 153.9799ms,0.0
+ 153.9800ms,3.3V 153.9861ms,3.3
+ 153.9862ms,0.0V 153.9999ms,0.0
+ 154.0000ms,3.3V 154.0061ms,3.3
+ 154.0062ms,0.0V 154.0199ms,0.0
+ 154.0200ms,3.3V 154.0261ms,3.3
+ 154.0262ms,0.0V 154.0399ms,0.0
+ 154.0400ms,3.3V 154.0461ms,3.3
+ 154.0462ms,0.0V 154.0599ms,0.0
+ 154.0600ms,3.3V 154.0661ms,3.3
+ 154.0662ms,0.0V 154.0799ms,0.0
+ 154.0800ms,3.3V 154.0861ms,3.3
+ 154.0862ms,0.0V 154.0999ms,0.0
+ 154.1000ms,3.3V 154.1061ms,3.3
+ 154.1062ms,0.0V 154.1199ms,0.0
+ 154.1200ms,3.3V 154.1261ms,3.3
+ 154.1262ms,0.0V 154.1399ms,0.0
+ 154.1400ms,3.3V 154.1461ms,3.3
+ 154.1462ms,0.0V 154.1599ms,0.0
+ 154.1600ms,3.3V 154.1661ms,3.3
+ 154.1662ms,0.0V 154.1799ms,0.0
+ 154.1800ms,3.3V 154.1861ms,3.3
+ 154.1862ms,0.0V 154.1999ms,0.0
+ 154.2000ms,3.3V 154.2061ms,3.3
+ 154.2062ms,0.0V 154.2199ms,0.0
+ 154.2200ms,3.3V 154.2261ms,3.3
+ 154.2262ms,0.0V 154.2399ms,0.0
+ 154.2400ms,3.3V 154.2461ms,3.3
+ 154.2462ms,0.0V 154.2599ms,0.0
+ 154.2600ms,3.3V 154.2661ms,3.3
+ 154.2662ms,0.0V 154.2799ms,0.0
+ 154.2800ms,3.3V 154.2861ms,3.3
+ 154.2862ms,0.0V 154.2999ms,0.0
+ 154.3000ms,3.3V 154.3061ms,3.3
+ 154.3062ms,0.0V 154.3199ms,0.0
+ 154.3200ms,3.3V 154.3261ms,3.3
+ 154.3262ms,0.0V 154.3399ms,0.0
+ 154.3400ms,3.3V 154.3461ms,3.3
+ 154.3462ms,0.0V 154.3599ms,0.0
+ 154.3600ms,3.3V 154.3661ms,3.3
+ 154.3662ms,0.0V 154.3799ms,0.0
+ 154.3800ms,3.3V 154.3861ms,3.3
+ 154.3862ms,0.0V 154.3999ms,0.0
+ 154.4000ms,3.3V 154.4061ms,3.3
+ 154.4062ms,0.0V 154.4199ms,0.0
+ 154.4200ms,3.3V 154.4261ms,3.3
+ 154.4262ms,0.0V 154.4399ms,0.0
+ 154.4400ms,3.3V 154.4461ms,3.3
+ 154.4462ms,0.0V 154.4599ms,0.0
+ 154.4600ms,3.3V 154.4661ms,3.3
+ 154.4662ms,0.0V 154.4799ms,0.0
+ 154.4800ms,3.3V 154.4861ms,3.3
+ 154.4862ms,0.0V 154.4999ms,0.0
+ 154.5000ms,3.3V 154.5061ms,3.3
+ 154.5062ms,0.0V 154.5199ms,0.0
+ 154.5200ms,3.3V 154.5261ms,3.3
+ 154.5262ms,0.0V 154.5399ms,0.0
+ 154.5400ms,3.3V 154.5461ms,3.3
+ 154.5462ms,0.0V 154.5599ms,0.0
+ 154.5600ms,3.3V 154.5661ms,3.3
+ 154.5662ms,0.0V 154.5799ms,0.0
+ 154.5800ms,3.3V 154.5861ms,3.3
+ 154.5862ms,0.0V 154.5999ms,0.0
+ 154.6000ms,3.3V 154.6061ms,3.3
+ 154.6062ms,0.0V 154.6199ms,0.0
+ 154.6200ms,3.3V 154.6261ms,3.3
+ 154.6262ms,0.0V 154.6399ms,0.0
+ 154.6400ms,3.3V 154.6461ms,3.3
+ 154.6462ms,0.0V 154.6599ms,0.0
+ 154.6600ms,3.3V 154.6661ms,3.3
+ 154.6662ms,0.0V 154.6799ms,0.0
+ 154.6800ms,3.3V 154.6861ms,3.3
+ 154.6862ms,0.0V 154.6999ms,0.0
+ 154.7000ms,3.3V 154.7061ms,3.3
+ 154.7062ms,0.0V 154.7199ms,0.0
+ 154.7200ms,3.3V 154.7261ms,3.3
+ 154.7262ms,0.0V 154.7399ms,0.0
+ 154.7400ms,3.3V 154.7461ms,3.3
+ 154.7462ms,0.0V 154.7599ms,0.0
+ 154.7600ms,3.3V 154.7661ms,3.3
+ 154.7662ms,0.0V 154.7799ms,0.0
+ 154.7800ms,3.3V 154.7861ms,3.3
+ 154.7862ms,0.0V 154.7999ms,0.0
+ 154.8000ms,3.3V 154.8061ms,3.3
+ 154.8062ms,0.0V 154.8199ms,0.0
+ 154.8200ms,3.3V 154.8261ms,3.3
+ 154.8262ms,0.0V 154.8399ms,0.0
+ 154.8400ms,3.3V 154.8461ms,3.3
+ 154.8462ms,0.0V 154.8599ms,0.0
+ 154.8600ms,3.3V 154.8661ms,3.3
+ 154.8662ms,0.0V 154.8799ms,0.0
+ 154.8800ms,3.3V 154.8861ms,3.3
+ 154.8862ms,0.0V 154.8999ms,0.0
+ 154.9000ms,3.3V 154.9061ms,3.3
+ 154.9062ms,0.0V 154.9199ms,0.0
+ 154.9200ms,3.3V 154.9261ms,3.3
+ 154.9262ms,0.0V 154.9399ms,0.0
+ 154.9400ms,3.3V 154.9461ms,3.3
+ 154.9462ms,0.0V 154.9599ms,0.0
+ 154.9600ms,3.3V 154.9661ms,3.3
+ 154.9662ms,0.0V 154.9799ms,0.0
+ 154.9800ms,3.3V 154.9861ms,3.3
+ 154.9862ms,0.0V 154.9999ms,0.0
+ 155.0000ms,3.3V 155.0061ms,3.3
+ 155.0062ms,0.0V 155.0199ms,0.0
+ 155.0200ms,3.3V 155.0261ms,3.3
+ 155.0262ms,0.0V 155.0399ms,0.0
+ 155.0400ms,3.3V 155.0461ms,3.3
+ 155.0462ms,0.0V 155.0599ms,0.0
+ 155.0600ms,3.3V 155.0661ms,3.3
+ 155.0662ms,0.0V 155.0799ms,0.0
+ 155.0800ms,3.3V 155.0861ms,3.3
+ 155.0862ms,0.0V 155.0999ms,0.0
+ 155.1000ms,3.3V 155.1061ms,3.3
+ 155.1062ms,0.0V 155.1199ms,0.0
+ 155.1200ms,3.3V 155.1261ms,3.3
+ 155.1262ms,0.0V 155.1399ms,0.0
+ 155.1400ms,3.3V 155.1461ms,3.3
+ 155.1462ms,0.0V 155.1599ms,0.0
+ 155.1600ms,3.3V 155.1661ms,3.3
+ 155.1662ms,0.0V 155.1799ms,0.0
+ 155.1800ms,3.3V 155.1861ms,3.3
+ 155.1862ms,0.0V 155.1999ms,0.0
+ 155.2000ms,3.3V 155.2061ms,3.3
+ 155.2062ms,0.0V 155.2199ms,0.0
+ 155.2200ms,3.3V 155.2261ms,3.3
+ 155.2262ms,0.0V 155.2399ms,0.0
+ 155.2400ms,3.3V 155.2461ms,3.3
+ 155.2462ms,0.0V 155.2599ms,0.0
+ 155.2600ms,3.3V 155.2661ms,3.3
+ 155.2662ms,0.0V 155.2799ms,0.0
+ 155.2800ms,3.3V 155.2861ms,3.3
+ 155.2862ms,0.0V 155.2999ms,0.0
+ 155.3000ms,3.3V 155.3061ms,3.3
+ 155.3062ms,0.0V 155.3199ms,0.0
+ 155.3200ms,3.3V 155.3261ms,3.3
+ 155.3262ms,0.0V 155.3399ms,0.0
+ 155.3400ms,3.3V 155.3461ms,3.3
+ 155.3462ms,0.0V 155.3599ms,0.0
+ 155.3600ms,3.3V 155.3663ms,3.3
+ 155.3664ms,0.0V 155.3799ms,0.0
+ 155.3800ms,3.3V 155.3863ms,3.3
+ 155.3864ms,0.0V 155.3999ms,0.0
+ 155.4000ms,3.3V 155.4063ms,3.3
+ 155.4064ms,0.0V 155.4199ms,0.0
+ 155.4200ms,3.3V 155.4263ms,3.3
+ 155.4264ms,0.0V 155.4399ms,0.0
+ 155.4400ms,3.3V 155.4463ms,3.3
+ 155.4464ms,0.0V 155.4599ms,0.0
+ 155.4600ms,3.3V 155.4663ms,3.3
+ 155.4664ms,0.0V 155.4799ms,0.0
+ 155.4800ms,3.3V 155.4863ms,3.3
+ 155.4864ms,0.0V 155.4999ms,0.0
+ 155.5000ms,3.3V 155.5063ms,3.3
+ 155.5064ms,0.0V 155.5199ms,0.0
+ 155.5200ms,3.3V 155.5263ms,3.3
+ 155.5264ms,0.0V 155.5399ms,0.0
+ 155.5400ms,3.3V 155.5463ms,3.3
+ 155.5464ms,0.0V 155.5599ms,0.0
+ 155.5600ms,3.3V 155.5663ms,3.3
+ 155.5664ms,0.0V 155.5799ms,0.0
+ 155.5800ms,3.3V 155.5863ms,3.3
+ 155.5864ms,0.0V 155.5999ms,0.0
+ 155.6000ms,3.3V 155.6063ms,3.3
+ 155.6064ms,0.0V 155.6199ms,0.0
+ 155.6200ms,3.3V 155.6263ms,3.3
+ 155.6264ms,0.0V 155.6399ms,0.0
+ 155.6400ms,3.3V 155.6463ms,3.3
+ 155.6464ms,0.0V 155.6599ms,0.0
+ 155.6600ms,3.3V 155.6663ms,3.3
+ 155.6664ms,0.0V 155.6799ms,0.0
+ 155.6800ms,3.3V 155.6863ms,3.3
+ 155.6864ms,0.0V 155.6999ms,0.0
+ 155.7000ms,3.3V 155.7063ms,3.3
+ 155.7064ms,0.0V 155.7199ms,0.0
+ 155.7200ms,3.3V 155.7263ms,3.3
+ 155.7264ms,0.0V 155.7399ms,0.0
+ 155.7400ms,3.3V 155.7463ms,3.3
+ 155.7464ms,0.0V 155.7599ms,0.0
+ 155.7600ms,3.3V 155.7663ms,3.3
+ 155.7664ms,0.0V 155.7799ms,0.0
+ 155.7800ms,3.3V 155.7863ms,3.3
+ 155.7864ms,0.0V 155.7999ms,0.0
+ 155.8000ms,3.3V 155.8063ms,3.3
+ 155.8064ms,0.0V 155.8199ms,0.0
+ 155.8200ms,3.3V 155.8263ms,3.3
+ 155.8264ms,0.0V 155.8399ms,0.0
+ 155.8400ms,3.3V 155.8463ms,3.3
+ 155.8464ms,0.0V 155.8599ms,0.0
+ 155.8600ms,3.3V 155.8663ms,3.3
+ 155.8664ms,0.0V 155.8799ms,0.0
+ 155.8800ms,3.3V 155.8863ms,3.3
+ 155.8864ms,0.0V 155.8999ms,0.0
+ 155.9000ms,3.3V 155.9063ms,3.3
+ 155.9064ms,0.0V 155.9199ms,0.0
+ 155.9200ms,3.3V 155.9263ms,3.3
+ 155.9264ms,0.0V 155.9399ms,0.0
+ 155.9400ms,3.3V 155.9463ms,3.3
+ 155.9464ms,0.0V 155.9599ms,0.0
+ 155.9600ms,3.3V 155.9663ms,3.3
+ 155.9664ms,0.0V 155.9799ms,0.0
+ 155.9800ms,3.3V 155.9863ms,3.3
+ 155.9864ms,0.0V 155.9999ms,0.0
+ 156.0000ms,3.3V 156.0063ms,3.3
+ 156.0064ms,0.0V 156.0199ms,0.0
+ 156.0200ms,3.3V 156.0263ms,3.3
+ 156.0264ms,0.0V 156.0399ms,0.0
+ 156.0400ms,3.3V 156.0463ms,3.3
+ 156.0464ms,0.0V 156.0599ms,0.0
+ 156.0600ms,3.3V 156.0663ms,3.3
+ 156.0664ms,0.0V 156.0799ms,0.0
+ 156.0800ms,3.3V 156.0863ms,3.3
+ 156.0864ms,0.0V 156.0999ms,0.0
+ 156.1000ms,3.3V 156.1063ms,3.3
+ 156.1064ms,0.0V 156.1199ms,0.0
+ 156.1200ms,3.3V 156.1263ms,3.3
+ 156.1264ms,0.0V 156.1399ms,0.0
+ 156.1400ms,3.3V 156.1463ms,3.3
+ 156.1464ms,0.0V 156.1599ms,0.0
+ 156.1600ms,3.3V 156.1663ms,3.3
+ 156.1664ms,0.0V 156.1799ms,0.0
+ 156.1800ms,3.3V 156.1863ms,3.3
+ 156.1864ms,0.0V 156.1999ms,0.0
+ 156.2000ms,3.3V 156.2063ms,3.3
+ 156.2064ms,0.0V 156.2199ms,0.0
+ 156.2200ms,3.3V 156.2263ms,3.3
+ 156.2264ms,0.0V 156.2399ms,0.0
+ 156.2400ms,3.3V 156.2463ms,3.3
+ 156.2464ms,0.0V 156.2599ms,0.0
+ 156.2600ms,3.3V 156.2663ms,3.3
+ 156.2664ms,0.0V 156.2799ms,0.0
+ 156.2800ms,3.3V 156.2863ms,3.3
+ 156.2864ms,0.0V 156.2999ms,0.0
+ 156.3000ms,3.3V 156.3063ms,3.3
+ 156.3064ms,0.0V 156.3199ms,0.0
+ 156.3200ms,3.3V 156.3263ms,3.3
+ 156.3264ms,0.0V 156.3399ms,0.0
+ 156.3400ms,3.3V 156.3463ms,3.3
+ 156.3464ms,0.0V 156.3599ms,0.0
+ 156.3600ms,3.3V 156.3663ms,3.3
+ 156.3664ms,0.0V 156.3799ms,0.0
+ 156.3800ms,3.3V 156.3863ms,3.3
+ 156.3864ms,0.0V 156.3999ms,0.0
+ 156.4000ms,3.3V 156.4063ms,3.3
+ 156.4064ms,0.0V 156.4199ms,0.0
+ 156.4200ms,3.3V 156.4263ms,3.3
+ 156.4264ms,0.0V 156.4399ms,0.0
+ 156.4400ms,3.3V 156.4463ms,3.3
+ 156.4464ms,0.0V 156.4599ms,0.0
+ 156.4600ms,3.3V 156.4663ms,3.3
+ 156.4664ms,0.0V 156.4799ms,0.0
+ 156.4800ms,3.3V 156.4863ms,3.3
+ 156.4864ms,0.0V 156.4999ms,0.0
+ 156.5000ms,3.3V 156.5063ms,3.3
+ 156.5064ms,0.0V 156.5199ms,0.0
+ 156.5200ms,3.3V 156.5263ms,3.3
+ 156.5264ms,0.0V 156.5399ms,0.0
+ 156.5400ms,3.3V 156.5463ms,3.3
+ 156.5464ms,0.0V 156.5599ms,0.0
+ 156.5600ms,3.3V 156.5663ms,3.3
+ 156.5664ms,0.0V 156.5799ms,0.0
+ 156.5800ms,3.3V 156.5863ms,3.3
+ 156.5864ms,0.0V 156.5999ms,0.0
+ 156.6000ms,3.3V 156.6063ms,3.3
+ 156.6064ms,0.0V 156.6199ms,0.0
+ 156.6200ms,3.3V 156.6263ms,3.3
+ 156.6264ms,0.0V 156.6399ms,0.0
+ 156.6400ms,3.3V 156.6463ms,3.3
+ 156.6464ms,0.0V 156.6599ms,0.0
+ 156.6600ms,3.3V 156.6663ms,3.3
+ 156.6664ms,0.0V 156.6799ms,0.0
+ 156.6800ms,3.3V 156.6863ms,3.3
+ 156.6864ms,0.0V 156.6999ms,0.0
+ 156.7000ms,3.3V 156.7063ms,3.3
+ 156.7064ms,0.0V 156.7199ms,0.0
+ 156.7200ms,3.3V 156.7263ms,3.3
+ 156.7264ms,0.0V 156.7399ms,0.0
+ 156.7400ms,3.3V 156.7463ms,3.3
+ 156.7464ms,0.0V 156.7599ms,0.0
+ 156.7600ms,3.3V 156.7663ms,3.3
+ 156.7664ms,0.0V 156.7799ms,0.0
+ 156.7800ms,3.3V 156.7863ms,3.3
+ 156.7864ms,0.0V 156.7999ms,0.0
+ 156.8000ms,3.3V 156.8063ms,3.3
+ 156.8064ms,0.0V 156.8199ms,0.0
+ 156.8200ms,3.3V 156.8263ms,3.3
+ 156.8264ms,0.0V 156.8399ms,0.0
+ 156.8400ms,3.3V 156.8463ms,3.3
+ 156.8464ms,0.0V 156.8599ms,0.0
+ 156.8600ms,3.3V 156.8663ms,3.3
+ 156.8664ms,0.0V 156.8799ms,0.0
+ 156.8800ms,3.3V 156.8863ms,3.3
+ 156.8864ms,0.0V 156.8999ms,0.0
+ 156.9000ms,3.3V 156.9063ms,3.3
+ 156.9064ms,0.0V 156.9199ms,0.0
+ 156.9200ms,3.3V 156.9263ms,3.3
+ 156.9264ms,0.0V 156.9399ms,0.0
+ 156.9400ms,3.3V 156.9463ms,3.3
+ 156.9464ms,0.0V 156.9599ms,0.0
+ 156.9600ms,3.3V 156.9663ms,3.3
+ 156.9664ms,0.0V 156.9799ms,0.0
+ 156.9800ms,3.3V 156.9863ms,3.3
+ 156.9864ms,0.0V 156.9999ms,0.0
+ 157.0000ms,3.3V 157.0063ms,3.3
+ 157.0064ms,0.0V 157.0199ms,0.0
+ 157.0200ms,3.3V 157.0263ms,3.3
+ 157.0264ms,0.0V 157.0399ms,0.0
+ 157.0400ms,3.3V 157.0463ms,3.3
+ 157.0464ms,0.0V 157.0599ms,0.0
+ 157.0600ms,3.3V 157.0663ms,3.3
+ 157.0664ms,0.0V 157.0799ms,0.0
+ 157.0800ms,3.3V 157.0863ms,3.3
+ 157.0864ms,0.0V 157.0999ms,0.0
+ 157.1000ms,3.3V 157.1063ms,3.3
+ 157.1064ms,0.0V 157.1199ms,0.0
+ 157.1200ms,3.3V 157.1263ms,3.3
+ 157.1264ms,0.0V 157.1399ms,0.0
+ 157.1400ms,3.3V 157.1463ms,3.3
+ 157.1464ms,0.0V 157.1599ms,0.0
+ 157.1600ms,3.3V 157.1663ms,3.3
+ 157.1664ms,0.0V 157.1799ms,0.0
+ 157.1800ms,3.3V 157.1863ms,3.3
+ 157.1864ms,0.0V 157.1999ms,0.0
+ 157.2000ms,3.3V 157.2063ms,3.3
+ 157.2064ms,0.0V 157.2199ms,0.0
+ 157.2200ms,3.3V 157.2263ms,3.3
+ 157.2264ms,0.0V 157.2399ms,0.0
+ 157.2400ms,3.3V 157.2463ms,3.3
+ 157.2464ms,0.0V 157.2599ms,0.0
+ 157.2600ms,3.3V 157.2663ms,3.3
+ 157.2664ms,0.0V 157.2799ms,0.0
+ 157.2800ms,3.3V 157.2863ms,3.3
+ 157.2864ms,0.0V 157.2999ms,0.0
+ 157.3000ms,3.3V 157.3063ms,3.3
+ 157.3064ms,0.0V 157.3199ms,0.0
+ 157.3200ms,3.3V 157.3263ms,3.3
+ 157.3264ms,0.0V 157.3399ms,0.0
+ 157.3400ms,3.3V 157.3463ms,3.3
+ 157.3464ms,0.0V 157.3599ms,0.0
+ 157.3600ms,3.3V 157.3663ms,3.3
+ 157.3664ms,0.0V 157.3799ms,0.0
+ 157.3800ms,3.3V 157.3863ms,3.3
+ 157.3864ms,0.0V 157.3999ms,0.0
+ 157.4000ms,3.3V 157.4063ms,3.3
+ 157.4064ms,0.0V 157.4199ms,0.0
+ 157.4200ms,3.3V 157.4263ms,3.3
+ 157.4264ms,0.0V 157.4399ms,0.0
+ 157.4400ms,3.3V 157.4463ms,3.3
+ 157.4464ms,0.0V 157.4599ms,0.0
+ 157.4600ms,3.3V 157.4663ms,3.3
+ 157.4664ms,0.0V 157.4799ms,0.0
+ 157.4800ms,3.3V 157.4863ms,3.3
+ 157.4864ms,0.0V 157.4999ms,0.0
+ 157.5000ms,3.3V 157.5063ms,3.3
+ 157.5064ms,0.0V 157.5199ms,0.0
+ 157.5200ms,3.3V 157.5263ms,3.3
+ 157.5264ms,0.0V 157.5399ms,0.0
+ 157.5400ms,3.3V 157.5463ms,3.3
+ 157.5464ms,0.0V 157.5599ms,0.0
+ 157.5600ms,3.3V 157.5663ms,3.3
+ 157.5664ms,0.0V 157.5799ms,0.0
+ 157.5800ms,3.3V 157.5863ms,3.3
+ 157.5864ms,0.0V 157.5999ms,0.0
+ 157.6000ms,3.3V 157.6063ms,3.3
+ 157.6064ms,0.0V 157.6199ms,0.0
+ 157.6200ms,3.3V 157.6263ms,3.3
+ 157.6264ms,0.0V 157.6399ms,0.0
+ 157.6400ms,3.3V 157.6463ms,3.3
+ 157.6464ms,0.0V 157.6599ms,0.0
+ 157.6600ms,3.3V 157.6663ms,3.3
+ 157.6664ms,0.0V 157.6799ms,0.0
+ 157.6800ms,3.3V 157.6863ms,3.3
+ 157.6864ms,0.0V 157.6999ms,0.0
+ 157.7000ms,3.3V 157.7063ms,3.3
+ 157.7064ms,0.0V 157.7199ms,0.0
+ 157.7200ms,3.3V 157.7263ms,3.3
+ 157.7264ms,0.0V 157.7399ms,0.0
+ 157.7400ms,3.3V 157.7463ms,3.3
+ 157.7464ms,0.0V 157.7599ms,0.0
+ 157.7600ms,3.3V 157.7663ms,3.3
+ 157.7664ms,0.0V 157.7799ms,0.0
+ 157.7800ms,3.3V 157.7863ms,3.3
+ 157.7864ms,0.0V 157.7999ms,0.0
+ 157.8000ms,3.3V 157.8063ms,3.3
+ 157.8064ms,0.0V 157.8199ms,0.0
+ 157.8200ms,3.3V 157.8263ms,3.3
+ 157.8264ms,0.0V 157.8399ms,0.0
+ 157.8400ms,3.3V 157.8463ms,3.3
+ 157.8464ms,0.0V 157.8599ms,0.0
+ 157.8600ms,3.3V 157.8663ms,3.3
+ 157.8664ms,0.0V 157.8799ms,0.0
+ 157.8800ms,3.3V 157.8863ms,3.3
+ 157.8864ms,0.0V 157.8999ms,0.0
+ 157.9000ms,3.3V 157.9063ms,3.3
+ 157.9064ms,0.0V 157.9199ms,0.0
+ 157.9200ms,3.3V 157.9263ms,3.3
+ 157.9264ms,0.0V 157.9399ms,0.0
+ 157.9400ms,3.3V 157.9463ms,3.3
+ 157.9464ms,0.0V 157.9599ms,0.0
+ 157.9600ms,3.3V 157.9663ms,3.3
+ 157.9664ms,0.0V 157.9799ms,0.0
+ 157.9800ms,3.3V 157.9863ms,3.3
+ 157.9864ms,0.0V 157.9999ms,0.0
+ 158.0000ms,3.3V 158.0063ms,3.3
+ 158.0064ms,0.0V 158.0199ms,0.0
+ 158.0200ms,3.3V 158.0263ms,3.3
+ 158.0264ms,0.0V 158.0399ms,0.0
+ 158.0400ms,3.3V 158.0463ms,3.3
+ 158.0464ms,0.0V 158.0599ms,0.0
+ 158.0600ms,3.3V 158.0663ms,3.3
+ 158.0664ms,0.0V 158.0799ms,0.0
+ 158.0800ms,3.3V 158.0863ms,3.3
+ 158.0864ms,0.0V 158.0999ms,0.0
+ 158.1000ms,3.3V 158.1063ms,3.3
+ 158.1064ms,0.0V 158.1199ms,0.0
+ 158.1200ms,3.3V 158.1263ms,3.3
+ 158.1264ms,0.0V 158.1399ms,0.0
+ 158.1400ms,3.3V 158.1463ms,3.3
+ 158.1464ms,0.0V 158.1599ms,0.0
+ 158.1600ms,3.3V 158.1663ms,3.3
+ 158.1664ms,0.0V 158.1799ms,0.0
+ 158.1800ms,3.3V 158.1863ms,3.3
+ 158.1864ms,0.0V 158.1999ms,0.0
+ 158.2000ms,3.3V 158.2063ms,3.3
+ 158.2064ms,0.0V 158.2199ms,0.0
+ 158.2200ms,3.3V 158.2263ms,3.3
+ 158.2264ms,0.0V 158.2399ms,0.0
+ 158.2400ms,3.3V 158.2463ms,3.3
+ 158.2464ms,0.0V 158.2599ms,0.0
+ 158.2600ms,3.3V 158.2663ms,3.3
+ 158.2664ms,0.0V 158.2799ms,0.0
+ 158.2800ms,3.3V 158.2863ms,3.3
+ 158.2864ms,0.0V 158.2999ms,0.0
+ 158.3000ms,3.3V 158.3063ms,3.3
+ 158.3064ms,0.0V 158.3199ms,0.0
+ 158.3200ms,3.3V 158.3263ms,3.3
+ 158.3264ms,0.0V 158.3399ms,0.0
+ 158.3400ms,3.3V 158.3463ms,3.3
+ 158.3464ms,0.0V 158.3599ms,0.0
+ 158.3600ms,3.3V 158.3663ms,3.3
+ 158.3664ms,0.0V 158.3799ms,0.0
+ 158.3800ms,3.3V 158.3863ms,3.3
+ 158.3864ms,0.0V 158.3999ms,0.0
+ 158.4000ms,3.3V 158.4063ms,3.3
+ 158.4064ms,0.0V 158.4199ms,0.0
+ 158.4200ms,3.3V 158.4263ms,3.3
+ 158.4264ms,0.0V 158.4399ms,0.0
+ 158.4400ms,3.3V 158.4463ms,3.3
+ 158.4464ms,0.0V 158.4599ms,0.0
+ 158.4600ms,3.3V 158.4663ms,3.3
+ 158.4664ms,0.0V 158.4799ms,0.0
+ 158.4800ms,3.3V 158.4863ms,3.3
+ 158.4864ms,0.0V 158.4999ms,0.0
+ 158.5000ms,3.3V 158.5063ms,3.3
+ 158.5064ms,0.0V 158.5199ms,0.0
+ 158.5200ms,3.3V 158.5263ms,3.3
+ 158.5264ms,0.0V 158.5399ms,0.0
+ 158.5400ms,3.3V 158.5463ms,3.3
+ 158.5464ms,0.0V 158.5599ms,0.0
+ 158.5600ms,3.3V 158.5663ms,3.3
+ 158.5664ms,0.0V 158.5799ms,0.0
+ 158.5800ms,3.3V 158.5863ms,3.3
+ 158.5864ms,0.0V 158.5999ms,0.0
+ 158.6000ms,3.3V 158.6063ms,3.3
+ 158.6064ms,0.0V 158.6199ms,0.0
+ 158.6200ms,3.3V 158.6263ms,3.3
+ 158.6264ms,0.0V 158.6399ms,0.0
+ 158.6400ms,3.3V 158.6463ms,3.3
+ 158.6464ms,0.0V 158.6599ms,0.0
+ 158.6600ms,3.3V 158.6663ms,3.3
+ 158.6664ms,0.0V 158.6799ms,0.0
+ 158.6800ms,3.3V 158.6863ms,3.3
+ 158.6864ms,0.0V 158.6999ms,0.0
+ 158.7000ms,3.3V 158.7063ms,3.3
+ 158.7064ms,0.0V 158.7199ms,0.0
+ 158.7200ms,3.3V 158.7263ms,3.3
+ 158.7264ms,0.0V 158.7399ms,0.0
+ 158.7400ms,3.3V 158.7463ms,3.3
+ 158.7464ms,0.0V 158.7599ms,0.0
+ 158.7600ms,3.3V 158.7663ms,3.3
+ 158.7664ms,0.0V 158.7799ms,0.0
+ 158.7800ms,3.3V 158.7863ms,3.3
+ 158.7864ms,0.0V 158.7999ms,0.0
+ 158.8000ms,3.3V 158.8063ms,3.3
+ 158.8064ms,0.0V 158.8199ms,0.0
+ 158.8200ms,3.3V 158.8263ms,3.3
+ 158.8264ms,0.0V 158.8399ms,0.0
+ 158.8400ms,3.3V 158.8463ms,3.3
+ 158.8464ms,0.0V 158.8599ms,0.0
+ 158.8600ms,3.3V 158.8663ms,3.3
+ 158.8664ms,0.0V 158.8799ms,0.0
+ 158.8800ms,3.3V 158.8863ms,3.3
+ 158.8864ms,0.0V 158.8999ms,0.0
+ 158.9000ms,3.3V 158.9063ms,3.3
+ 158.9064ms,0.0V 158.9199ms,0.0
+ 158.9200ms,3.3V 158.9263ms,3.3
+ 158.9264ms,0.0V 158.9399ms,0.0
+ 158.9400ms,3.3V 158.9463ms,3.3
+ 158.9464ms,0.0V 158.9599ms,0.0
+ 158.9600ms,3.3V 158.9663ms,3.3
+ 158.9664ms,0.0V 158.9799ms,0.0
+ 158.9800ms,3.3V 158.9863ms,3.3
+ 158.9864ms,0.0V 158.9999ms,0.0
+ 159.0000ms,3.3V 159.0063ms,3.3
+ 159.0064ms,0.0V 159.0199ms,0.0
+ 159.0200ms,3.3V 159.0263ms,3.3
+ 159.0264ms,0.0V 159.0399ms,0.0
+ 159.0400ms,3.3V 159.0463ms,3.3
+ 159.0464ms,0.0V 159.0599ms,0.0
+ 159.0600ms,3.3V 159.0663ms,3.3
+ 159.0664ms,0.0V 159.0799ms,0.0
+ 159.0800ms,3.3V 159.0863ms,3.3
+ 159.0864ms,0.0V 159.0999ms,0.0
+ 159.1000ms,3.3V 159.1063ms,3.3
+ 159.1064ms,0.0V 159.1199ms,0.0
+ 159.1200ms,3.3V 159.1263ms,3.3
+ 159.1264ms,0.0V 159.1399ms,0.0
+ 159.1400ms,3.3V 159.1463ms,3.3
+ 159.1464ms,0.0V 159.1599ms,0.0
+ 159.1600ms,3.3V 159.1663ms,3.3
+ 159.1664ms,0.0V 159.1799ms,0.0
+ 159.1800ms,3.3V 159.1863ms,3.3
+ 159.1864ms,0.0V 159.1999ms,0.0
+ 159.2000ms,3.3V 159.2063ms,3.3
+ 159.2064ms,0.0V 159.2199ms,0.0
+ 159.2200ms,3.3V 159.2263ms,3.3
+ 159.2264ms,0.0V 159.2399ms,0.0
+ 159.2400ms,3.3V 159.2463ms,3.3
+ 159.2464ms,0.0V 159.2599ms,0.0
+ 159.2600ms,3.3V 159.2663ms,3.3
+ 159.2664ms,0.0V 159.2799ms,0.0
+ 159.2800ms,3.3V 159.2863ms,3.3
+ 159.2864ms,0.0V 159.2999ms,0.0
+ 159.3000ms,3.3V 159.3063ms,3.3
+ 159.3064ms,0.0V 159.3199ms,0.0
+ 159.3200ms,3.3V 159.3263ms,3.3
+ 159.3264ms,0.0V 159.3399ms,0.0
+ 159.3400ms,3.3V 159.3463ms,3.3
+ 159.3464ms,0.0V 159.3599ms,0.0
+ 159.3600ms,3.3V 159.3663ms,3.3
+ 159.3664ms,0.0V 159.3799ms,0.0
+ 159.3800ms,3.3V 159.3863ms,3.3
+ 159.3864ms,0.0V 159.3999ms,0.0
+ 159.4000ms,3.3V 159.4063ms,3.3
+ 159.4064ms,0.0V 159.4199ms,0.0
+ 159.4200ms,3.3V 159.4263ms,3.3
+ 159.4264ms,0.0V 159.4399ms,0.0
+ 159.4400ms,3.3V 159.4463ms,3.3
+ 159.4464ms,0.0V 159.4599ms,0.0
+ 159.4600ms,3.3V 159.4663ms,3.3
+ 159.4664ms,0.0V 159.4799ms,0.0
+ 159.4800ms,3.3V 159.4863ms,3.3
+ 159.4864ms,0.0V 159.4999ms,0.0
+ 159.5000ms,3.3V 159.5063ms,3.3
+ 159.5064ms,0.0V 159.5199ms,0.0
+ 159.5200ms,3.3V 159.5263ms,3.3
+ 159.5264ms,0.0V 159.5399ms,0.0
+ 159.5400ms,3.3V 159.5463ms,3.3
+ 159.5464ms,0.0V 159.5599ms,0.0
+ 159.5600ms,3.3V 159.5663ms,3.3
+ 159.5664ms,0.0V 159.5799ms,0.0
+ 159.5800ms,3.3V 159.5863ms,3.3
+ 159.5864ms,0.0V 159.5999ms,0.0
+ 159.6000ms,3.3V 159.6063ms,3.3
+ 159.6064ms,0.0V 159.6199ms,0.0
+ 159.6200ms,3.3V 159.6263ms,3.3
+ 159.6264ms,0.0V 159.6399ms,0.0
+ 159.6400ms,3.3V 159.6463ms,3.3
+ 159.6464ms,0.0V 159.6599ms,0.0
+ 159.6600ms,3.3V 159.6663ms,3.3
+ 159.6664ms,0.0V 159.6799ms,0.0
+ 159.6800ms,3.3V 159.6863ms,3.3
+ 159.6864ms,0.0V 159.6999ms,0.0
+ 159.7000ms,3.3V 159.7063ms,3.3
+ 159.7064ms,0.0V 159.7199ms,0.0
+ 159.7200ms,3.3V 159.7263ms,3.3
+ 159.7264ms,0.0V 159.7399ms,0.0
+ 159.7400ms,3.3V 159.7463ms,3.3
+ 159.7464ms,0.0V 159.7599ms,0.0
+ 159.7600ms,3.3V 159.7663ms,3.3
+ 159.7664ms,0.0V 159.7799ms,0.0
+ 159.7800ms,3.3V 159.7863ms,3.3
+ 159.7864ms,0.0V 159.7999ms,0.0
+ 159.8000ms,3.3V 159.8063ms,3.3
+ 159.8064ms,0.0V 159.8199ms,0.0
+ 159.8200ms,3.3V 159.8263ms,3.3
+ 159.8264ms,0.0V 159.8399ms,0.0
+ 159.8400ms,3.3V 159.8463ms,3.3
+ 159.8464ms,0.0V 159.8599ms,0.0
+ 159.8600ms,3.3V 159.8663ms,3.3
+ 159.8664ms,0.0V 159.8799ms,0.0
+ 159.8800ms,3.3V 159.8863ms,3.3
+ 159.8864ms,0.0V 159.8999ms,0.0
+ 159.9000ms,3.3V 159.9063ms,3.3
+ 159.9064ms,0.0V 159.9199ms,0.0
+ 159.9200ms,3.3V 159.9263ms,3.3
+ 159.9264ms,0.0V 159.9399ms,0.0
+ 159.9400ms,3.3V 159.9463ms,3.3
+ 159.9464ms,0.0V 159.9599ms,0.0
+ 159.9600ms,3.3V 159.9663ms,3.3
+ 159.9664ms,0.0V 159.9799ms,0.0
+ 159.9800ms,3.3V 159.9863ms,3.3
+ 159.9864ms,0.0V 159.9999ms,0.0
+ 160.0000ms,3.3V 160.0063ms,3.3
+ 160.0064ms,0.0V 160.0199ms,0.0
+ 160.0200ms,3.3V 160.0263ms,3.3
+ 160.0264ms,0.0V 160.0399ms,0.0
+ 160.0400ms,3.3V 160.0463ms,3.3
+ 160.0464ms,0.0V 160.0599ms,0.0
+ 160.0600ms,3.3V 160.0663ms,3.3
+ 160.0664ms,0.0V 160.0799ms,0.0
+ 160.0800ms,3.3V 160.0863ms,3.3
+ 160.0864ms,0.0V 160.0999ms,0.0
+ 160.1000ms,3.3V 160.1063ms,3.3
+ 160.1064ms,0.0V 160.1199ms,0.0
+ 160.1200ms,3.3V 160.1263ms,3.3
+ 160.1264ms,0.0V 160.1399ms,0.0
+ 160.1400ms,3.3V 160.1463ms,3.3
+ 160.1464ms,0.0V 160.1599ms,0.0
+ 160.1600ms,3.3V 160.1663ms,3.3
+ 160.1664ms,0.0V 160.1799ms,0.0
+ 160.1800ms,3.3V 160.1863ms,3.3
+ 160.1864ms,0.0V 160.1999ms,0.0
+ 160.2000ms,3.3V 160.2063ms,3.3
+ 160.2064ms,0.0V 160.2199ms,0.0
+ 160.2200ms,3.3V 160.2263ms,3.3
+ 160.2264ms,0.0V 160.2399ms,0.0
+ 160.2400ms,3.3V 160.2463ms,3.3
+ 160.2464ms,0.0V 160.2599ms,0.0
+ 160.2600ms,3.3V 160.2663ms,3.3
+ 160.2664ms,0.0V 160.2799ms,0.0
+ 160.2800ms,3.3V 160.2863ms,3.3
+ 160.2864ms,0.0V 160.2999ms,0.0
+ 160.3000ms,3.3V 160.3063ms,3.3
+ 160.3064ms,0.0V 160.3199ms,0.0
+ 160.3200ms,3.3V 160.3263ms,3.3
+ 160.3264ms,0.0V 160.3399ms,0.0
+ 160.3400ms,3.3V 160.3463ms,3.3
+ 160.3464ms,0.0V 160.3599ms,0.0
+ 160.3600ms,3.3V 160.3665ms,3.3
+ 160.3666ms,0.0V 160.3799ms,0.0
+ 160.3800ms,3.3V 160.3865ms,3.3
+ 160.3866ms,0.0V 160.3999ms,0.0
+ 160.4000ms,3.3V 160.4065ms,3.3
+ 160.4066ms,0.0V 160.4199ms,0.0
+ 160.4200ms,3.3V 160.4265ms,3.3
+ 160.4266ms,0.0V 160.4399ms,0.0
+ 160.4400ms,3.3V 160.4465ms,3.3
+ 160.4466ms,0.0V 160.4599ms,0.0
+ 160.4600ms,3.3V 160.4665ms,3.3
+ 160.4666ms,0.0V 160.4799ms,0.0
+ 160.4800ms,3.3V 160.4865ms,3.3
+ 160.4866ms,0.0V 160.4999ms,0.0
+ 160.5000ms,3.3V 160.5065ms,3.3
+ 160.5066ms,0.0V 160.5199ms,0.0
+ 160.5200ms,3.3V 160.5265ms,3.3
+ 160.5266ms,0.0V 160.5399ms,0.0
+ 160.5400ms,3.3V 160.5465ms,3.3
+ 160.5466ms,0.0V 160.5599ms,0.0
+ 160.5600ms,3.3V 160.5665ms,3.3
+ 160.5666ms,0.0V 160.5799ms,0.0
+ 160.5800ms,3.3V 160.5865ms,3.3
+ 160.5866ms,0.0V 160.5999ms,0.0
+ 160.6000ms,3.3V 160.6065ms,3.3
+ 160.6066ms,0.0V 160.6199ms,0.0
+ 160.6200ms,3.3V 160.6265ms,3.3
+ 160.6266ms,0.0V 160.6399ms,0.0
+ 160.6400ms,3.3V 160.6465ms,3.3
+ 160.6466ms,0.0V 160.6599ms,0.0
+ 160.6600ms,3.3V 160.6665ms,3.3
+ 160.6666ms,0.0V 160.6799ms,0.0
+ 160.6800ms,3.3V 160.6865ms,3.3
+ 160.6866ms,0.0V 160.6999ms,0.0
+ 160.7000ms,3.3V 160.7065ms,3.3
+ 160.7066ms,0.0V 160.7199ms,0.0
+ 160.7200ms,3.3V 160.7265ms,3.3
+ 160.7266ms,0.0V 160.7399ms,0.0
+ 160.7400ms,3.3V 160.7465ms,3.3
+ 160.7466ms,0.0V 160.7599ms,0.0
+ 160.7600ms,3.3V 160.7665ms,3.3
+ 160.7666ms,0.0V 160.7799ms,0.0
+ 160.7800ms,3.3V 160.7865ms,3.3
+ 160.7866ms,0.0V 160.7999ms,0.0
+ 160.8000ms,3.3V 160.8065ms,3.3
+ 160.8066ms,0.0V 160.8199ms,0.0
+ 160.8200ms,3.3V 160.8265ms,3.3
+ 160.8266ms,0.0V 160.8399ms,0.0
+ 160.8400ms,3.3V 160.8465ms,3.3
+ 160.8466ms,0.0V 160.8599ms,0.0
+ 160.8600ms,3.3V 160.8665ms,3.3
+ 160.8666ms,0.0V 160.8799ms,0.0
+ 160.8800ms,3.3V 160.8865ms,3.3
+ 160.8866ms,0.0V 160.8999ms,0.0
+ 160.9000ms,3.3V 160.9065ms,3.3
+ 160.9066ms,0.0V 160.9199ms,0.0
+ 160.9200ms,3.3V 160.9265ms,3.3
+ 160.9266ms,0.0V 160.9399ms,0.0
+ 160.9400ms,3.3V 160.9465ms,3.3
+ 160.9466ms,0.0V 160.9599ms,0.0
+ 160.9600ms,3.3V 160.9665ms,3.3
+ 160.9666ms,0.0V 160.9799ms,0.0
+ 160.9800ms,3.3V 160.9865ms,3.3
+ 160.9866ms,0.0V 160.9999ms,0.0
+ 161.0000ms,3.3V 161.0065ms,3.3
+ 161.0066ms,0.0V 161.0199ms,0.0
+ 161.0200ms,3.3V 161.0265ms,3.3
+ 161.0266ms,0.0V 161.0399ms,0.0
+ 161.0400ms,3.3V 161.0465ms,3.3
+ 161.0466ms,0.0V 161.0599ms,0.0
+ 161.0600ms,3.3V 161.0665ms,3.3
+ 161.0666ms,0.0V 161.0799ms,0.0
+ 161.0800ms,3.3V 161.0865ms,3.3
+ 161.0866ms,0.0V 161.0999ms,0.0
+ 161.1000ms,3.3V 161.1065ms,3.3
+ 161.1066ms,0.0V 161.1199ms,0.0
+ 161.1200ms,3.3V 161.1265ms,3.3
+ 161.1266ms,0.0V 161.1399ms,0.0
+ 161.1400ms,3.3V 161.1465ms,3.3
+ 161.1466ms,0.0V 161.1599ms,0.0
+ 161.1600ms,3.3V 161.1665ms,3.3
+ 161.1666ms,0.0V 161.1799ms,0.0
+ 161.1800ms,3.3V 161.1865ms,3.3
+ 161.1866ms,0.0V 161.1999ms,0.0
+ 161.2000ms,3.3V 161.2065ms,3.3
+ 161.2066ms,0.0V 161.2199ms,0.0
+ 161.2200ms,3.3V 161.2265ms,3.3
+ 161.2266ms,0.0V 161.2399ms,0.0
+ 161.2400ms,3.3V 161.2465ms,3.3
+ 161.2466ms,0.0V 161.2599ms,0.0
+ 161.2600ms,3.3V 161.2665ms,3.3
+ 161.2666ms,0.0V 161.2799ms,0.0
+ 161.2800ms,3.3V 161.2865ms,3.3
+ 161.2866ms,0.0V 161.2999ms,0.0
+ 161.3000ms,3.3V 161.3065ms,3.3
+ 161.3066ms,0.0V 161.3199ms,0.0
+ 161.3200ms,3.3V 161.3265ms,3.3
+ 161.3266ms,0.0V 161.3399ms,0.0
+ 161.3400ms,3.3V 161.3465ms,3.3
+ 161.3466ms,0.0V 161.3599ms,0.0
+ 161.3600ms,3.3V 161.3665ms,3.3
+ 161.3666ms,0.0V 161.3799ms,0.0
+ 161.3800ms,3.3V 161.3865ms,3.3
+ 161.3866ms,0.0V 161.3999ms,0.0
+ 161.4000ms,3.3V 161.4065ms,3.3
+ 161.4066ms,0.0V 161.4199ms,0.0
+ 161.4200ms,3.3V 161.4265ms,3.3
+ 161.4266ms,0.0V 161.4399ms,0.0
+ 161.4400ms,3.3V 161.4465ms,3.3
+ 161.4466ms,0.0V 161.4599ms,0.0
+ 161.4600ms,3.3V 161.4665ms,3.3
+ 161.4666ms,0.0V 161.4799ms,0.0
+ 161.4800ms,3.3V 161.4865ms,3.3
+ 161.4866ms,0.0V 161.4999ms,0.0
+ 161.5000ms,3.3V 161.5065ms,3.3
+ 161.5066ms,0.0V 161.5199ms,0.0
+ 161.5200ms,3.3V 161.5265ms,3.3
+ 161.5266ms,0.0V 161.5399ms,0.0
+ 161.5400ms,3.3V 161.5465ms,3.3
+ 161.5466ms,0.0V 161.5599ms,0.0
+ 161.5600ms,3.3V 161.5665ms,3.3
+ 161.5666ms,0.0V 161.5799ms,0.0
+ 161.5800ms,3.3V 161.5865ms,3.3
+ 161.5866ms,0.0V 161.5999ms,0.0
+ 161.6000ms,3.3V 161.6065ms,3.3
+ 161.6066ms,0.0V 161.6199ms,0.0
+ 161.6200ms,3.3V 161.6265ms,3.3
+ 161.6266ms,0.0V 161.6399ms,0.0
+ 161.6400ms,3.3V 161.6465ms,3.3
+ 161.6466ms,0.0V 161.6599ms,0.0
+ 161.6600ms,3.3V 161.6665ms,3.3
+ 161.6666ms,0.0V 161.6799ms,0.0
+ 161.6800ms,3.3V 161.6865ms,3.3
+ 161.6866ms,0.0V 161.6999ms,0.0
+ 161.7000ms,3.3V 161.7065ms,3.3
+ 161.7066ms,0.0V 161.7199ms,0.0
+ 161.7200ms,3.3V 161.7265ms,3.3
+ 161.7266ms,0.0V 161.7399ms,0.0
+ 161.7400ms,3.3V 161.7465ms,3.3
+ 161.7466ms,0.0V 161.7599ms,0.0
+ 161.7600ms,3.3V 161.7665ms,3.3
+ 161.7666ms,0.0V 161.7799ms,0.0
+ 161.7800ms,3.3V 161.7865ms,3.3
+ 161.7866ms,0.0V 161.7999ms,0.0
+ 161.8000ms,3.3V 161.8065ms,3.3
+ 161.8066ms,0.0V 161.8199ms,0.0
+ 161.8200ms,3.3V 161.8265ms,3.3
+ 161.8266ms,0.0V 161.8399ms,0.0
+ 161.8400ms,3.3V 161.8465ms,3.3
+ 161.8466ms,0.0V 161.8599ms,0.0
+ 161.8600ms,3.3V 161.8665ms,3.3
+ 161.8666ms,0.0V 161.8799ms,0.0
+ 161.8800ms,3.3V 161.8865ms,3.3
+ 161.8866ms,0.0V 161.8999ms,0.0
+ 161.9000ms,3.3V 161.9065ms,3.3
+ 161.9066ms,0.0V 161.9199ms,0.0
+ 161.9200ms,3.3V 161.9265ms,3.3
+ 161.9266ms,0.0V 161.9399ms,0.0
+ 161.9400ms,3.3V 161.9465ms,3.3
+ 161.9466ms,0.0V 161.9599ms,0.0
+ 161.9600ms,3.3V 161.9665ms,3.3
+ 161.9666ms,0.0V 161.9799ms,0.0
+ 161.9800ms,3.3V 161.9865ms,3.3
+ 161.9866ms,0.0V 161.9999ms,0.0
+ 162.0000ms,3.3V 162.0065ms,3.3
+ 162.0066ms,0.0V 162.0199ms,0.0
+ 162.0200ms,3.3V 162.0265ms,3.3
+ 162.0266ms,0.0V 162.0399ms,0.0
+ 162.0400ms,3.3V 162.0465ms,3.3
+ 162.0466ms,0.0V 162.0599ms,0.0
+ 162.0600ms,3.3V 162.0665ms,3.3
+ 162.0666ms,0.0V 162.0799ms,0.0
+ 162.0800ms,3.3V 162.0865ms,3.3
+ 162.0866ms,0.0V 162.0999ms,0.0
+ 162.1000ms,3.3V 162.1065ms,3.3
+ 162.1066ms,0.0V 162.1199ms,0.0
+ 162.1200ms,3.3V 162.1265ms,3.3
+ 162.1266ms,0.0V 162.1399ms,0.0
+ 162.1400ms,3.3V 162.1465ms,3.3
+ 162.1466ms,0.0V 162.1599ms,0.0
+ 162.1600ms,3.3V 162.1665ms,3.3
+ 162.1666ms,0.0V 162.1799ms,0.0
+ 162.1800ms,3.3V 162.1865ms,3.3
+ 162.1866ms,0.0V 162.1999ms,0.0
+ 162.2000ms,3.3V 162.2065ms,3.3
+ 162.2066ms,0.0V 162.2199ms,0.0
+ 162.2200ms,3.3V 162.2265ms,3.3
+ 162.2266ms,0.0V 162.2399ms,0.0
+ 162.2400ms,3.3V 162.2465ms,3.3
+ 162.2466ms,0.0V 162.2599ms,0.0
+ 162.2600ms,3.3V 162.2665ms,3.3
+ 162.2666ms,0.0V 162.2799ms,0.0
+ 162.2800ms,3.3V 162.2865ms,3.3
+ 162.2866ms,0.0V 162.2999ms,0.0
+ 162.3000ms,3.3V 162.3065ms,3.3
+ 162.3066ms,0.0V 162.3199ms,0.0
+ 162.3200ms,3.3V 162.3265ms,3.3
+ 162.3266ms,0.0V 162.3399ms,0.0
+ 162.3400ms,3.3V 162.3465ms,3.3
+ 162.3466ms,0.0V 162.3599ms,0.0
+ 162.3600ms,3.3V 162.3665ms,3.3
+ 162.3666ms,0.0V 162.3799ms,0.0
+ 162.3800ms,3.3V 162.3865ms,3.3
+ 162.3866ms,0.0V 162.3999ms,0.0
+ 162.4000ms,3.3V 162.4065ms,3.3
+ 162.4066ms,0.0V 162.4199ms,0.0
+ 162.4200ms,3.3V 162.4265ms,3.3
+ 162.4266ms,0.0V 162.4399ms,0.0
+ 162.4400ms,3.3V 162.4465ms,3.3
+ 162.4466ms,0.0V 162.4599ms,0.0
+ 162.4600ms,3.3V 162.4665ms,3.3
+ 162.4666ms,0.0V 162.4799ms,0.0
+ 162.4800ms,3.3V 162.4865ms,3.3
+ 162.4866ms,0.0V 162.4999ms,0.0
+ 162.5000ms,3.3V 162.5065ms,3.3
+ 162.5066ms,0.0V 162.5199ms,0.0
+ 162.5200ms,3.3V 162.5265ms,3.3
+ 162.5266ms,0.0V 162.5399ms,0.0
+ 162.5400ms,3.3V 162.5465ms,3.3
+ 162.5466ms,0.0V 162.5599ms,0.0
+ 162.5600ms,3.3V 162.5665ms,3.3
+ 162.5666ms,0.0V 162.5799ms,0.0
+ 162.5800ms,3.3V 162.5865ms,3.3
+ 162.5866ms,0.0V 162.5999ms,0.0
+ 162.6000ms,3.3V 162.6065ms,3.3
+ 162.6066ms,0.0V 162.6199ms,0.0
+ 162.6200ms,3.3V 162.6265ms,3.3
+ 162.6266ms,0.0V 162.6399ms,0.0
+ 162.6400ms,3.3V 162.6465ms,3.3
+ 162.6466ms,0.0V 162.6599ms,0.0
+ 162.6600ms,3.3V 162.6665ms,3.3
+ 162.6666ms,0.0V 162.6799ms,0.0
+ 162.6800ms,3.3V 162.6865ms,3.3
+ 162.6866ms,0.0V 162.6999ms,0.0
+ 162.7000ms,3.3V 162.7065ms,3.3
+ 162.7066ms,0.0V 162.7199ms,0.0
+ 162.7200ms,3.3V 162.7265ms,3.3
+ 162.7266ms,0.0V 162.7399ms,0.0
+ 162.7400ms,3.3V 162.7465ms,3.3
+ 162.7466ms,0.0V 162.7599ms,0.0
+ 162.7600ms,3.3V 162.7665ms,3.3
+ 162.7666ms,0.0V 162.7799ms,0.0
+ 162.7800ms,3.3V 162.7865ms,3.3
+ 162.7866ms,0.0V 162.7999ms,0.0
+ 162.8000ms,3.3V 162.8065ms,3.3
+ 162.8066ms,0.0V 162.8199ms,0.0
+ 162.8200ms,3.3V 162.8265ms,3.3
+ 162.8266ms,0.0V 162.8399ms,0.0
+ 162.8400ms,3.3V 162.8465ms,3.3
+ 162.8466ms,0.0V 162.8599ms,0.0
+ 162.8600ms,3.3V 162.8665ms,3.3
+ 162.8666ms,0.0V 162.8799ms,0.0
+ 162.8800ms,3.3V 162.8865ms,3.3
+ 162.8866ms,0.0V 162.8999ms,0.0
+ 162.9000ms,3.3V 162.9065ms,3.3
+ 162.9066ms,0.0V 162.9199ms,0.0
+ 162.9200ms,3.3V 162.9265ms,3.3
+ 162.9266ms,0.0V 162.9399ms,0.0
+ 162.9400ms,3.3V 162.9465ms,3.3
+ 162.9466ms,0.0V 162.9599ms,0.0
+ 162.9600ms,3.3V 162.9665ms,3.3
+ 162.9666ms,0.0V 162.9799ms,0.0
+ 162.9800ms,3.3V 162.9865ms,3.3
+ 162.9866ms,0.0V 162.9999ms,0.0
+ 163.0000ms,3.3V 163.0065ms,3.3
+ 163.0066ms,0.0V 163.0199ms,0.0
+ 163.0200ms,3.3V 163.0265ms,3.3
+ 163.0266ms,0.0V 163.0399ms,0.0
+ 163.0400ms,3.3V 163.0465ms,3.3
+ 163.0466ms,0.0V 163.0599ms,0.0
+ 163.0600ms,3.3V 163.0665ms,3.3
+ 163.0666ms,0.0V 163.0799ms,0.0
+ 163.0800ms,3.3V 163.0865ms,3.3
+ 163.0866ms,0.0V 163.0999ms,0.0
+ 163.1000ms,3.3V 163.1065ms,3.3
+ 163.1066ms,0.0V 163.1199ms,0.0
+ 163.1200ms,3.3V 163.1265ms,3.3
+ 163.1266ms,0.0V 163.1399ms,0.0
+ 163.1400ms,3.3V 163.1465ms,3.3
+ 163.1466ms,0.0V 163.1599ms,0.0
+ 163.1600ms,3.3V 163.1665ms,3.3
+ 163.1666ms,0.0V 163.1799ms,0.0
+ 163.1800ms,3.3V 163.1865ms,3.3
+ 163.1866ms,0.0V 163.1999ms,0.0
+ 163.2000ms,3.3V 163.2065ms,3.3
+ 163.2066ms,0.0V 163.2199ms,0.0
+ 163.2200ms,3.3V 163.2265ms,3.3
+ 163.2266ms,0.0V 163.2399ms,0.0
+ 163.2400ms,3.3V 163.2465ms,3.3
+ 163.2466ms,0.0V 163.2599ms,0.0
+ 163.2600ms,3.3V 163.2665ms,3.3
+ 163.2666ms,0.0V 163.2799ms,0.0
+ 163.2800ms,3.3V 163.2865ms,3.3
+ 163.2866ms,0.0V 163.2999ms,0.0
+ 163.3000ms,3.3V 163.3065ms,3.3
+ 163.3066ms,0.0V 163.3199ms,0.0
+ 163.3200ms,3.3V 163.3265ms,3.3
+ 163.3266ms,0.0V 163.3399ms,0.0
+ 163.3400ms,3.3V 163.3465ms,3.3
+ 163.3466ms,0.0V 163.3599ms,0.0
+ 163.3600ms,3.3V 163.3665ms,3.3
+ 163.3666ms,0.0V 163.3799ms,0.0
+ 163.3800ms,3.3V 163.3865ms,3.3
+ 163.3866ms,0.0V 163.3999ms,0.0
+ 163.4000ms,3.3V 163.4065ms,3.3
+ 163.4066ms,0.0V 163.4199ms,0.0
+ 163.4200ms,3.3V 163.4265ms,3.3
+ 163.4266ms,0.0V 163.4399ms,0.0
+ 163.4400ms,3.3V 163.4465ms,3.3
+ 163.4466ms,0.0V 163.4599ms,0.0
+ 163.4600ms,3.3V 163.4665ms,3.3
+ 163.4666ms,0.0V 163.4799ms,0.0
+ 163.4800ms,3.3V 163.4865ms,3.3
+ 163.4866ms,0.0V 163.4999ms,0.0
+ 163.5000ms,3.3V 163.5065ms,3.3
+ 163.5066ms,0.0V 163.5199ms,0.0
+ 163.5200ms,3.3V 163.5265ms,3.3
+ 163.5266ms,0.0V 163.5399ms,0.0
+ 163.5400ms,3.3V 163.5465ms,3.3
+ 163.5466ms,0.0V 163.5599ms,0.0
+ 163.5600ms,3.3V 163.5665ms,3.3
+ 163.5666ms,0.0V 163.5799ms,0.0
+ 163.5800ms,3.3V 163.5865ms,3.3
+ 163.5866ms,0.0V 163.5999ms,0.0
+ 163.6000ms,3.3V 163.6065ms,3.3
+ 163.6066ms,0.0V 163.6199ms,0.0
+ 163.6200ms,3.3V 163.6265ms,3.3
+ 163.6266ms,0.0V 163.6399ms,0.0
+ 163.6400ms,3.3V 163.6465ms,3.3
+ 163.6466ms,0.0V 163.6599ms,0.0
+ 163.6600ms,3.3V 163.6665ms,3.3
+ 163.6666ms,0.0V 163.6799ms,0.0
+ 163.6800ms,3.3V 163.6865ms,3.3
+ 163.6866ms,0.0V 163.6999ms,0.0
+ 163.7000ms,3.3V 163.7065ms,3.3
+ 163.7066ms,0.0V 163.7199ms,0.0
+ 163.7200ms,3.3V 163.7265ms,3.3
+ 163.7266ms,0.0V 163.7399ms,0.0
+ 163.7400ms,3.3V 163.7465ms,3.3
+ 163.7466ms,0.0V 163.7599ms,0.0
+ 163.7600ms,3.3V 163.7665ms,3.3
+ 163.7666ms,0.0V 163.7799ms,0.0
+ 163.7800ms,3.3V 163.7865ms,3.3
+ 163.7866ms,0.0V 163.7999ms,0.0
+ 163.8000ms,3.3V 163.8065ms,3.3
+ 163.8066ms,0.0V 163.8199ms,0.0
+ 163.8200ms,3.3V 163.8265ms,3.3
+ 163.8266ms,0.0V 163.8399ms,0.0
+ 163.8400ms,3.3V 163.8465ms,3.3
+ 163.8466ms,0.0V 163.8599ms,0.0
+ 163.8600ms,3.3V 163.8665ms,3.3
+ 163.8666ms,0.0V 163.8799ms,0.0
+ 163.8800ms,3.3V 163.8865ms,3.3
+ 163.8866ms,0.0V 163.8999ms,0.0
+ 163.9000ms,3.3V 163.9065ms,3.3
+ 163.9066ms,0.0V 163.9199ms,0.0
+ 163.9200ms,3.3V 163.9265ms,3.3
+ 163.9266ms,0.0V 163.9399ms,0.0
+ 163.9400ms,3.3V 163.9465ms,3.3
+ 163.9466ms,0.0V 163.9599ms,0.0
+ 163.9600ms,3.3V 163.9665ms,3.3
+ 163.9666ms,0.0V 163.9799ms,0.0
+ 163.9800ms,3.3V 163.9865ms,3.3
+ 163.9866ms,0.0V 163.9999ms,0.0
+ 164.0000ms,3.3V 164.0065ms,3.3
+ 164.0066ms,0.0V 164.0199ms,0.0
+ 164.0200ms,3.3V 164.0265ms,3.3
+ 164.0266ms,0.0V 164.0399ms,0.0
+ 164.0400ms,3.3V 164.0465ms,3.3
+ 164.0466ms,0.0V 164.0599ms,0.0
+ 164.0600ms,3.3V 164.0665ms,3.3
+ 164.0666ms,0.0V 164.0799ms,0.0
+ 164.0800ms,3.3V 164.0865ms,3.3
+ 164.0866ms,0.0V 164.0999ms,0.0
+ 164.1000ms,3.3V 164.1065ms,3.3
+ 164.1066ms,0.0V 164.1199ms,0.0
+ 164.1200ms,3.3V 164.1265ms,3.3
+ 164.1266ms,0.0V 164.1399ms,0.0
+ 164.1400ms,3.3V 164.1465ms,3.3
+ 164.1466ms,0.0V 164.1599ms,0.0
+ 164.1600ms,3.3V 164.1665ms,3.3
+ 164.1666ms,0.0V 164.1799ms,0.0
+ 164.1800ms,3.3V 164.1865ms,3.3
+ 164.1866ms,0.0V 164.1999ms,0.0
+ 164.2000ms,3.3V 164.2065ms,3.3
+ 164.2066ms,0.0V 164.2199ms,0.0
+ 164.2200ms,3.3V 164.2265ms,3.3
+ 164.2266ms,0.0V 164.2399ms,0.0
+ 164.2400ms,3.3V 164.2465ms,3.3
+ 164.2466ms,0.0V 164.2599ms,0.0
+ 164.2600ms,3.3V 164.2665ms,3.3
+ 164.2666ms,0.0V 164.2799ms,0.0
+ 164.2800ms,3.3V 164.2865ms,3.3
+ 164.2866ms,0.0V 164.2999ms,0.0
+ 164.3000ms,3.3V 164.3065ms,3.3
+ 164.3066ms,0.0V 164.3199ms,0.0
+ 164.3200ms,3.3V 164.3265ms,3.3
+ 164.3266ms,0.0V 164.3399ms,0.0
+ 164.3400ms,3.3V 164.3465ms,3.3
+ 164.3466ms,0.0V 164.3599ms,0.0
+ 164.3600ms,3.3V 164.3665ms,3.3
+ 164.3666ms,0.0V 164.3799ms,0.0
+ 164.3800ms,3.3V 164.3865ms,3.3
+ 164.3866ms,0.0V 164.3999ms,0.0
+ 164.4000ms,3.3V 164.4065ms,3.3
+ 164.4066ms,0.0V 164.4199ms,0.0
+ 164.4200ms,3.3V 164.4265ms,3.3
+ 164.4266ms,0.0V 164.4399ms,0.0
+ 164.4400ms,3.3V 164.4465ms,3.3
+ 164.4466ms,0.0V 164.4599ms,0.0
+ 164.4600ms,3.3V 164.4665ms,3.3
+ 164.4666ms,0.0V 164.4799ms,0.0
+ 164.4800ms,3.3V 164.4865ms,3.3
+ 164.4866ms,0.0V 164.4999ms,0.0
+ 164.5000ms,3.3V 164.5065ms,3.3
+ 164.5066ms,0.0V 164.5199ms,0.0
+ 164.5200ms,3.3V 164.5265ms,3.3
+ 164.5266ms,0.0V 164.5399ms,0.0
+ 164.5400ms,3.3V 164.5465ms,3.3
+ 164.5466ms,0.0V 164.5599ms,0.0
+ 164.5600ms,3.3V 164.5665ms,3.3
+ 164.5666ms,0.0V 164.5799ms,0.0
+ 164.5800ms,3.3V 164.5865ms,3.3
+ 164.5866ms,0.0V 164.5999ms,0.0
+ 164.6000ms,3.3V 164.6065ms,3.3
+ 164.6066ms,0.0V 164.6199ms,0.0
+ 164.6200ms,3.3V 164.6265ms,3.3
+ 164.6266ms,0.0V 164.6399ms,0.0
+ 164.6400ms,3.3V 164.6465ms,3.3
+ 164.6466ms,0.0V 164.6599ms,0.0
+ 164.6600ms,3.3V 164.6665ms,3.3
+ 164.6666ms,0.0V 164.6799ms,0.0
+ 164.6800ms,3.3V 164.6865ms,3.3
+ 164.6866ms,0.0V 164.6999ms,0.0
+ 164.7000ms,3.3V 164.7065ms,3.3
+ 164.7066ms,0.0V 164.7199ms,0.0
+ 164.7200ms,3.3V 164.7265ms,3.3
+ 164.7266ms,0.0V 164.7399ms,0.0
+ 164.7400ms,3.3V 164.7465ms,3.3
+ 164.7466ms,0.0V 164.7599ms,0.0
+ 164.7600ms,3.3V 164.7665ms,3.3
+ 164.7666ms,0.0V 164.7799ms,0.0
+ 164.7800ms,3.3V 164.7865ms,3.3
+ 164.7866ms,0.0V 164.7999ms,0.0
+ 164.8000ms,3.3V 164.8065ms,3.3
+ 164.8066ms,0.0V 164.8199ms,0.0
+ 164.8200ms,3.3V 164.8265ms,3.3
+ 164.8266ms,0.0V 164.8399ms,0.0
+ 164.8400ms,3.3V 164.8465ms,3.3
+ 164.8466ms,0.0V 164.8599ms,0.0
+ 164.8600ms,3.3V 164.8665ms,3.3
+ 164.8666ms,0.0V 164.8799ms,0.0
+ 164.8800ms,3.3V 164.8865ms,3.3
+ 164.8866ms,0.0V 164.8999ms,0.0
+ 164.9000ms,3.3V 164.9065ms,3.3
+ 164.9066ms,0.0V 164.9199ms,0.0
+ 164.9200ms,3.3V 164.9265ms,3.3
+ 164.9266ms,0.0V 164.9399ms,0.0
+ 164.9400ms,3.3V 164.9465ms,3.3
+ 164.9466ms,0.0V 164.9599ms,0.0
+ 164.9600ms,3.3V 164.9665ms,3.3
+ 164.9666ms,0.0V 164.9799ms,0.0
+ 164.9800ms,3.3V 164.9865ms,3.3
+ 164.9866ms,0.0V 164.9999ms,0.0
+ 165.0000ms,3.3V 165.0065ms,3.3
+ 165.0066ms,0.0V 165.0199ms,0.0
+ 165.0200ms,3.3V 165.0265ms,3.3
+ 165.0266ms,0.0V 165.0399ms,0.0
+ 165.0400ms,3.3V 165.0465ms,3.3
+ 165.0466ms,0.0V 165.0599ms,0.0
+ 165.0600ms,3.3V 165.0665ms,3.3
+ 165.0666ms,0.0V 165.0799ms,0.0
+ 165.0800ms,3.3V 165.0865ms,3.3
+ 165.0866ms,0.0V 165.0999ms,0.0
+ 165.1000ms,3.3V 165.1065ms,3.3
+ 165.1066ms,0.0V 165.1199ms,0.0
+ 165.1200ms,3.3V 165.1265ms,3.3
+ 165.1266ms,0.0V 165.1399ms,0.0
+ 165.1400ms,3.3V 165.1465ms,3.3
+ 165.1466ms,0.0V 165.1599ms,0.0
+ 165.1600ms,3.3V 165.1665ms,3.3
+ 165.1666ms,0.0V 165.1799ms,0.0
+ 165.1800ms,3.3V 165.1865ms,3.3
+ 165.1866ms,0.0V 165.1999ms,0.0
+ 165.2000ms,3.3V 165.2065ms,3.3
+ 165.2066ms,0.0V 165.2199ms,0.0
+ 165.2200ms,3.3V 165.2265ms,3.3
+ 165.2266ms,0.0V 165.2399ms,0.0
+ 165.2400ms,3.3V 165.2465ms,3.3
+ 165.2466ms,0.0V 165.2599ms,0.0
+ 165.2600ms,3.3V 165.2665ms,3.3
+ 165.2666ms,0.0V 165.2799ms,0.0
+ 165.2800ms,3.3V 165.2865ms,3.3
+ 165.2866ms,0.0V 165.2999ms,0.0
+ 165.3000ms,3.3V 165.3065ms,3.3
+ 165.3066ms,0.0V 165.3199ms,0.0
+ 165.3200ms,3.3V 165.3265ms,3.3
+ 165.3266ms,0.0V 165.3399ms,0.0
+ 165.3400ms,3.3V 165.3465ms,3.3
+ 165.3466ms,0.0V 165.3599ms,0.0
+ 165.3600ms,3.3V 165.3667ms,3.3
+ 165.3668ms,0.0V 165.3799ms,0.0
+ 165.3800ms,3.3V 165.3867ms,3.3
+ 165.3868ms,0.0V 165.3999ms,0.0
+ 165.4000ms,3.3V 165.4067ms,3.3
+ 165.4068ms,0.0V 165.4199ms,0.0
+ 165.4200ms,3.3V 165.4267ms,3.3
+ 165.4268ms,0.0V 165.4399ms,0.0
+ 165.4400ms,3.3V 165.4467ms,3.3
+ 165.4468ms,0.0V 165.4599ms,0.0
+ 165.4600ms,3.3V 165.4667ms,3.3
+ 165.4668ms,0.0V 165.4799ms,0.0
+ 165.4800ms,3.3V 165.4867ms,3.3
+ 165.4868ms,0.0V 165.4999ms,0.0
+ 165.5000ms,3.3V 165.5067ms,3.3
+ 165.5068ms,0.0V 165.5199ms,0.0
+ 165.5200ms,3.3V 165.5267ms,3.3
+ 165.5268ms,0.0V 165.5399ms,0.0
+ 165.5400ms,3.3V 165.5467ms,3.3
+ 165.5468ms,0.0V 165.5599ms,0.0
+ 165.5600ms,3.3V 165.5667ms,3.3
+ 165.5668ms,0.0V 165.5799ms,0.0
+ 165.5800ms,3.3V 165.5867ms,3.3
+ 165.5868ms,0.0V 165.5999ms,0.0
+ 165.6000ms,3.3V 165.6067ms,3.3
+ 165.6068ms,0.0V 165.6199ms,0.0
+ 165.6200ms,3.3V 165.6267ms,3.3
+ 165.6268ms,0.0V 165.6399ms,0.0
+ 165.6400ms,3.3V 165.6467ms,3.3
+ 165.6468ms,0.0V 165.6599ms,0.0
+ 165.6600ms,3.3V 165.6667ms,3.3
+ 165.6668ms,0.0V 165.6799ms,0.0
+ 165.6800ms,3.3V 165.6867ms,3.3
+ 165.6868ms,0.0V 165.6999ms,0.0
+ 165.7000ms,3.3V 165.7067ms,3.3
+ 165.7068ms,0.0V 165.7199ms,0.0
+ 165.7200ms,3.3V 165.7267ms,3.3
+ 165.7268ms,0.0V 165.7399ms,0.0
+ 165.7400ms,3.3V 165.7467ms,3.3
+ 165.7468ms,0.0V 165.7599ms,0.0
+ 165.7600ms,3.3V 165.7667ms,3.3
+ 165.7668ms,0.0V 165.7799ms,0.0
+ 165.7800ms,3.3V 165.7867ms,3.3
+ 165.7868ms,0.0V 165.7999ms,0.0
+ 165.8000ms,3.3V 165.8067ms,3.3
+ 165.8068ms,0.0V 165.8199ms,0.0
+ 165.8200ms,3.3V 165.8267ms,3.3
+ 165.8268ms,0.0V 165.8399ms,0.0
+ 165.8400ms,3.3V 165.8467ms,3.3
+ 165.8468ms,0.0V 165.8599ms,0.0
+ 165.8600ms,3.3V 165.8667ms,3.3
+ 165.8668ms,0.0V 165.8799ms,0.0
+ 165.8800ms,3.3V 165.8867ms,3.3
+ 165.8868ms,0.0V 165.8999ms,0.0
+ 165.9000ms,3.3V 165.9067ms,3.3
+ 165.9068ms,0.0V 165.9199ms,0.0
+ 165.9200ms,3.3V 165.9267ms,3.3
+ 165.9268ms,0.0V 165.9399ms,0.0
+ 165.9400ms,3.3V 165.9467ms,3.3
+ 165.9468ms,0.0V 165.9599ms,0.0
+ 165.9600ms,3.3V 165.9667ms,3.3
+ 165.9668ms,0.0V 165.9799ms,0.0
+ 165.9800ms,3.3V 165.9867ms,3.3
+ 165.9868ms,0.0V 165.9999ms,0.0
+ 166.0000ms,3.3V 166.0067ms,3.3
+ 166.0068ms,0.0V 166.0199ms,0.0
+ 166.0200ms,3.3V 166.0267ms,3.3
+ 166.0268ms,0.0V 166.0399ms,0.0
+ 166.0400ms,3.3V 166.0467ms,3.3
+ 166.0468ms,0.0V 166.0599ms,0.0
+ 166.0600ms,3.3V 166.0667ms,3.3
+ 166.0668ms,0.0V 166.0799ms,0.0
+ 166.0800ms,3.3V 166.0867ms,3.3
+ 166.0868ms,0.0V 166.0999ms,0.0
+ 166.1000ms,3.3V 166.1067ms,3.3
+ 166.1068ms,0.0V 166.1199ms,0.0
+ 166.1200ms,3.3V 166.1267ms,3.3
+ 166.1268ms,0.0V 166.1399ms,0.0
+ 166.1400ms,3.3V 166.1467ms,3.3
+ 166.1468ms,0.0V 166.1599ms,0.0
+ 166.1600ms,3.3V 166.1667ms,3.3
+ 166.1668ms,0.0V 166.1799ms,0.0
+ 166.1800ms,3.3V 166.1867ms,3.3
+ 166.1868ms,0.0V 166.1999ms,0.0
+ 166.2000ms,3.3V 166.2067ms,3.3
+ 166.2068ms,0.0V 166.2199ms,0.0
+ 166.2200ms,3.3V 166.2267ms,3.3
+ 166.2268ms,0.0V 166.2399ms,0.0
+ 166.2400ms,3.3V 166.2467ms,3.3
+ 166.2468ms,0.0V 166.2599ms,0.0
+ 166.2600ms,3.3V 166.2667ms,3.3
+ 166.2668ms,0.0V 166.2799ms,0.0
+ 166.2800ms,3.3V 166.2867ms,3.3
+ 166.2868ms,0.0V 166.2999ms,0.0
+ 166.3000ms,3.3V 166.3067ms,3.3
+ 166.3068ms,0.0V 166.3199ms,0.0
+ 166.3200ms,3.3V 166.3267ms,3.3
+ 166.3268ms,0.0V 166.3399ms,0.0
+ 166.3400ms,3.3V 166.3467ms,3.3
+ 166.3468ms,0.0V 166.3599ms,0.0
+ 166.3600ms,3.3V 166.3667ms,3.3
+ 166.3668ms,0.0V 166.3799ms,0.0
+ 166.3800ms,3.3V 166.3867ms,3.3
+ 166.3868ms,0.0V 166.3999ms,0.0
+ 166.4000ms,3.3V 166.4067ms,3.3
+ 166.4068ms,0.0V 166.4199ms,0.0
+ 166.4200ms,3.3V 166.4267ms,3.3
+ 166.4268ms,0.0V 166.4399ms,0.0
+ 166.4400ms,3.3V 166.4467ms,3.3
+ 166.4468ms,0.0V 166.4599ms,0.0
+ 166.4600ms,3.3V 166.4667ms,3.3
+ 166.4668ms,0.0V 166.4799ms,0.0
+ 166.4800ms,3.3V 166.4867ms,3.3
+ 166.4868ms,0.0V 166.4999ms,0.0
+ 166.5000ms,3.3V 166.5067ms,3.3
+ 166.5068ms,0.0V 166.5199ms,0.0
+ 166.5200ms,3.3V 166.5267ms,3.3
+ 166.5268ms,0.0V 166.5399ms,0.0
+ 166.5400ms,3.3V 166.5467ms,3.3
+ 166.5468ms,0.0V 166.5599ms,0.0
+ 166.5600ms,3.3V 166.5667ms,3.3
+ 166.5668ms,0.0V 166.5799ms,0.0
+ 166.5800ms,3.3V 166.5867ms,3.3
+ 166.5868ms,0.0V 166.5999ms,0.0
+ 166.6000ms,3.3V 166.6067ms,3.3
+ 166.6068ms,0.0V 166.6199ms,0.0
+ 166.6200ms,3.3V 166.6267ms,3.3
+ 166.6268ms,0.0V 166.6399ms,0.0
+ 166.6400ms,3.3V 166.6467ms,3.3
+ 166.6468ms,0.0V 166.6599ms,0.0
+ 166.6600ms,3.3V 166.6667ms,3.3
+ 166.6668ms,0.0V 166.6799ms,0.0
+ 166.6800ms,3.3V 166.6867ms,3.3
+ 166.6868ms,0.0V 166.6999ms,0.0
+ 166.7000ms,3.3V 166.7067ms,3.3
+ 166.7068ms,0.0V 166.7199ms,0.0
+ 166.7200ms,3.3V 166.7267ms,3.3
+ 166.7268ms,0.0V 166.7399ms,0.0
+ 166.7400ms,3.3V 166.7467ms,3.3
+ 166.7468ms,0.0V 166.7599ms,0.0
+ 166.7600ms,3.3V 166.7667ms,3.3
+ 166.7668ms,0.0V 166.7799ms,0.0
+ 166.7800ms,3.3V 166.7867ms,3.3
+ 166.7868ms,0.0V 166.7999ms,0.0
+ 166.8000ms,3.3V 166.8067ms,3.3
+ 166.8068ms,0.0V 166.8199ms,0.0
+ 166.8200ms,3.3V 166.8267ms,3.3
+ 166.8268ms,0.0V 166.8399ms,0.0
+ 166.8400ms,3.3V 166.8467ms,3.3
+ 166.8468ms,0.0V 166.8599ms,0.0
+ 166.8600ms,3.3V 166.8667ms,3.3
+ 166.8668ms,0.0V 166.8799ms,0.0
+ 166.8800ms,3.3V 166.8867ms,3.3
+ 166.8868ms,0.0V 166.8999ms,0.0
+ 166.9000ms,3.3V 166.9067ms,3.3
+ 166.9068ms,0.0V 166.9199ms,0.0
+ 166.9200ms,3.3V 166.9267ms,3.3
+ 166.9268ms,0.0V 166.9399ms,0.0
+ 166.9400ms,3.3V 166.9467ms,3.3
+ 166.9468ms,0.0V 166.9599ms,0.0
+ 166.9600ms,3.3V 166.9667ms,3.3
+ 166.9668ms,0.0V 166.9799ms,0.0
+ 166.9800ms,3.3V 166.9867ms,3.3
+ 166.9868ms,0.0V 166.9999ms,0.0
+ 167.0000ms,3.3V 167.0067ms,3.3
+ 167.0068ms,0.0V 167.0199ms,0.0
+ 167.0200ms,3.3V 167.0267ms,3.3
+ 167.0268ms,0.0V 167.0399ms,0.0
+ 167.0400ms,3.3V 167.0467ms,3.3
+ 167.0468ms,0.0V 167.0599ms,0.0
+ 167.0600ms,3.3V 167.0667ms,3.3
+ 167.0668ms,0.0V 167.0799ms,0.0
+ 167.0800ms,3.3V 167.0867ms,3.3
+ 167.0868ms,0.0V 167.0999ms,0.0
+ 167.1000ms,3.3V 167.1067ms,3.3
+ 167.1068ms,0.0V 167.1199ms,0.0
+ 167.1200ms,3.3V 167.1267ms,3.3
+ 167.1268ms,0.0V 167.1399ms,0.0
+ 167.1400ms,3.3V 167.1467ms,3.3
+ 167.1468ms,0.0V 167.1599ms,0.0
+ 167.1600ms,3.3V 167.1667ms,3.3
+ 167.1668ms,0.0V 167.1799ms,0.0
+ 167.1800ms,3.3V 167.1867ms,3.3
+ 167.1868ms,0.0V 167.1999ms,0.0
+ 167.2000ms,3.3V 167.2067ms,3.3
+ 167.2068ms,0.0V 167.2199ms,0.0
+ 167.2200ms,3.3V 167.2267ms,3.3
+ 167.2268ms,0.0V 167.2399ms,0.0
+ 167.2400ms,3.3V 167.2467ms,3.3
+ 167.2468ms,0.0V 167.2599ms,0.0
+ 167.2600ms,3.3V 167.2667ms,3.3
+ 167.2668ms,0.0V 167.2799ms,0.0
+ 167.2800ms,3.3V 167.2867ms,3.3
+ 167.2868ms,0.0V 167.2999ms,0.0
+ 167.3000ms,3.3V 167.3067ms,3.3
+ 167.3068ms,0.0V 167.3199ms,0.0
+ 167.3200ms,3.3V 167.3267ms,3.3
+ 167.3268ms,0.0V 167.3399ms,0.0
+ 167.3400ms,3.3V 167.3467ms,3.3
+ 167.3468ms,0.0V 167.3599ms,0.0
+ 167.3600ms,3.3V 167.3667ms,3.3
+ 167.3668ms,0.0V 167.3799ms,0.0
+ 167.3800ms,3.3V 167.3867ms,3.3
+ 167.3868ms,0.0V 167.3999ms,0.0
+ 167.4000ms,3.3V 167.4067ms,3.3
+ 167.4068ms,0.0V 167.4199ms,0.0
+ 167.4200ms,3.3V 167.4267ms,3.3
+ 167.4268ms,0.0V 167.4399ms,0.0
+ 167.4400ms,3.3V 167.4467ms,3.3
+ 167.4468ms,0.0V 167.4599ms,0.0
+ 167.4600ms,3.3V 167.4667ms,3.3
+ 167.4668ms,0.0V 167.4799ms,0.0
+ 167.4800ms,3.3V 167.4867ms,3.3
+ 167.4868ms,0.0V 167.4999ms,0.0
+ 167.5000ms,3.3V 167.5067ms,3.3
+ 167.5068ms,0.0V 167.5199ms,0.0
+ 167.5200ms,3.3V 167.5267ms,3.3
+ 167.5268ms,0.0V 167.5399ms,0.0
+ 167.5400ms,3.3V 167.5467ms,3.3
+ 167.5468ms,0.0V 167.5599ms,0.0
+ 167.5600ms,3.3V 167.5667ms,3.3
+ 167.5668ms,0.0V 167.5799ms,0.0
+ 167.5800ms,3.3V 167.5867ms,3.3
+ 167.5868ms,0.0V 167.5999ms,0.0
+ 167.6000ms,3.3V 167.6067ms,3.3
+ 167.6068ms,0.0V 167.6199ms,0.0
+ 167.6200ms,3.3V 167.6267ms,3.3
+ 167.6268ms,0.0V 167.6399ms,0.0
+ 167.6400ms,3.3V 167.6467ms,3.3
+ 167.6468ms,0.0V 167.6599ms,0.0
+ 167.6600ms,3.3V 167.6667ms,3.3
+ 167.6668ms,0.0V 167.6799ms,0.0
+ 167.6800ms,3.3V 167.6867ms,3.3
+ 167.6868ms,0.0V 167.6999ms,0.0
+ 167.7000ms,3.3V 167.7067ms,3.3
+ 167.7068ms,0.0V 167.7199ms,0.0
+ 167.7200ms,3.3V 167.7267ms,3.3
+ 167.7268ms,0.0V 167.7399ms,0.0
+ 167.7400ms,3.3V 167.7467ms,3.3
+ 167.7468ms,0.0V 167.7599ms,0.0
+ 167.7600ms,3.3V 167.7667ms,3.3
+ 167.7668ms,0.0V 167.7799ms,0.0
+ 167.7800ms,3.3V 167.7867ms,3.3
+ 167.7868ms,0.0V 167.7999ms,0.0
+ 167.8000ms,3.3V 167.8067ms,3.3
+ 167.8068ms,0.0V 167.8199ms,0.0
+ 167.8200ms,3.3V 167.8267ms,3.3
+ 167.8268ms,0.0V 167.8399ms,0.0
+ 167.8400ms,3.3V 167.8467ms,3.3
+ 167.8468ms,0.0V 167.8599ms,0.0
+ 167.8600ms,3.3V 167.8667ms,3.3
+ 167.8668ms,0.0V 167.8799ms,0.0
+ 167.8800ms,3.3V 167.8867ms,3.3
+ 167.8868ms,0.0V 167.8999ms,0.0
+ 167.9000ms,3.3V 167.9067ms,3.3
+ 167.9068ms,0.0V 167.9199ms,0.0
+ 167.9200ms,3.3V 167.9267ms,3.3
+ 167.9268ms,0.0V 167.9399ms,0.0
+ 167.9400ms,3.3V 167.9467ms,3.3
+ 167.9468ms,0.0V 167.9599ms,0.0
+ 167.9600ms,3.3V 167.9667ms,3.3
+ 167.9668ms,0.0V 167.9799ms,0.0
+ 167.9800ms,3.3V 167.9867ms,3.3
+ 167.9868ms,0.0V 167.9999ms,0.0
+ 168.0000ms,3.3V 168.0067ms,3.3
+ 168.0068ms,0.0V 168.0199ms,0.0
+ 168.0200ms,3.3V 168.0267ms,3.3
+ 168.0268ms,0.0V 168.0399ms,0.0
+ 168.0400ms,3.3V 168.0467ms,3.3
+ 168.0468ms,0.0V 168.0599ms,0.0
+ 168.0600ms,3.3V 168.0667ms,3.3
+ 168.0668ms,0.0V 168.0799ms,0.0
+ 168.0800ms,3.3V 168.0867ms,3.3
+ 168.0868ms,0.0V 168.0999ms,0.0
+ 168.1000ms,3.3V 168.1067ms,3.3
+ 168.1068ms,0.0V 168.1199ms,0.0
+ 168.1200ms,3.3V 168.1267ms,3.3
+ 168.1268ms,0.0V 168.1399ms,0.0
+ 168.1400ms,3.3V 168.1467ms,3.3
+ 168.1468ms,0.0V 168.1599ms,0.0
+ 168.1600ms,3.3V 168.1667ms,3.3
+ 168.1668ms,0.0V 168.1799ms,0.0
+ 168.1800ms,3.3V 168.1867ms,3.3
+ 168.1868ms,0.0V 168.1999ms,0.0
+ 168.2000ms,3.3V 168.2067ms,3.3
+ 168.2068ms,0.0V 168.2199ms,0.0
+ 168.2200ms,3.3V 168.2267ms,3.3
+ 168.2268ms,0.0V 168.2399ms,0.0
+ 168.2400ms,3.3V 168.2467ms,3.3
+ 168.2468ms,0.0V 168.2599ms,0.0
+ 168.2600ms,3.3V 168.2667ms,3.3
+ 168.2668ms,0.0V 168.2799ms,0.0
+ 168.2800ms,3.3V 168.2867ms,3.3
+ 168.2868ms,0.0V 168.2999ms,0.0
+ 168.3000ms,3.3V 168.3067ms,3.3
+ 168.3068ms,0.0V 168.3199ms,0.0
+ 168.3200ms,3.3V 168.3267ms,3.3
+ 168.3268ms,0.0V 168.3399ms,0.0
+ 168.3400ms,3.3V 168.3467ms,3.3
+ 168.3468ms,0.0V 168.3599ms,0.0
+ 168.3600ms,3.3V 168.3667ms,3.3
+ 168.3668ms,0.0V 168.3799ms,0.0
+ 168.3800ms,3.3V 168.3867ms,3.3
+ 168.3868ms,0.0V 168.3999ms,0.0
+ 168.4000ms,3.3V 168.4067ms,3.3
+ 168.4068ms,0.0V 168.4199ms,0.0
+ 168.4200ms,3.3V 168.4267ms,3.3
+ 168.4268ms,0.0V 168.4399ms,0.0
+ 168.4400ms,3.3V 168.4467ms,3.3
+ 168.4468ms,0.0V 168.4599ms,0.0
+ 168.4600ms,3.3V 168.4667ms,3.3
+ 168.4668ms,0.0V 168.4799ms,0.0
+ 168.4800ms,3.3V 168.4867ms,3.3
+ 168.4868ms,0.0V 168.4999ms,0.0
+ 168.5000ms,3.3V 168.5067ms,3.3
+ 168.5068ms,0.0V 168.5199ms,0.0
+ 168.5200ms,3.3V 168.5267ms,3.3
+ 168.5268ms,0.0V 168.5399ms,0.0
+ 168.5400ms,3.3V 168.5467ms,3.3
+ 168.5468ms,0.0V 168.5599ms,0.0
+ 168.5600ms,3.3V 168.5667ms,3.3
+ 168.5668ms,0.0V 168.5799ms,0.0
+ 168.5800ms,3.3V 168.5867ms,3.3
+ 168.5868ms,0.0V 168.5999ms,0.0
+ 168.6000ms,3.3V 168.6067ms,3.3
+ 168.6068ms,0.0V 168.6199ms,0.0
+ 168.6200ms,3.3V 168.6267ms,3.3
+ 168.6268ms,0.0V 168.6399ms,0.0
+ 168.6400ms,3.3V 168.6467ms,3.3
+ 168.6468ms,0.0V 168.6599ms,0.0
+ 168.6600ms,3.3V 168.6667ms,3.3
+ 168.6668ms,0.0V 168.6799ms,0.0
+ 168.6800ms,3.3V 168.6867ms,3.3
+ 168.6868ms,0.0V 168.6999ms,0.0
+ 168.7000ms,3.3V 168.7067ms,3.3
+ 168.7068ms,0.0V 168.7199ms,0.0
+ 168.7200ms,3.3V 168.7267ms,3.3
+ 168.7268ms,0.0V 168.7399ms,0.0
+ 168.7400ms,3.3V 168.7467ms,3.3
+ 168.7468ms,0.0V 168.7599ms,0.0
+ 168.7600ms,3.3V 168.7667ms,3.3
+ 168.7668ms,0.0V 168.7799ms,0.0
+ 168.7800ms,3.3V 168.7867ms,3.3
+ 168.7868ms,0.0V 168.7999ms,0.0
+ 168.8000ms,3.3V 168.8067ms,3.3
+ 168.8068ms,0.0V 168.8199ms,0.0
+ 168.8200ms,3.3V 168.8267ms,3.3
+ 168.8268ms,0.0V 168.8399ms,0.0
+ 168.8400ms,3.3V 168.8467ms,3.3
+ 168.8468ms,0.0V 168.8599ms,0.0
+ 168.8600ms,3.3V 168.8667ms,3.3
+ 168.8668ms,0.0V 168.8799ms,0.0
+ 168.8800ms,3.3V 168.8867ms,3.3
+ 168.8868ms,0.0V 168.8999ms,0.0
+ 168.9000ms,3.3V 168.9067ms,3.3
+ 168.9068ms,0.0V 168.9199ms,0.0
+ 168.9200ms,3.3V 168.9267ms,3.3
+ 168.9268ms,0.0V 168.9399ms,0.0
+ 168.9400ms,3.3V 168.9467ms,3.3
+ 168.9468ms,0.0V 168.9599ms,0.0
+ 168.9600ms,3.3V 168.9667ms,3.3
+ 168.9668ms,0.0V 168.9799ms,0.0
+ 168.9800ms,3.3V 168.9867ms,3.3
+ 168.9868ms,0.0V 168.9999ms,0.0
+ 169.0000ms,3.3V 169.0067ms,3.3
+ 169.0068ms,0.0V 169.0199ms,0.0
+ 169.0200ms,3.3V 169.0267ms,3.3
+ 169.0268ms,0.0V 169.0399ms,0.0
+ 169.0400ms,3.3V 169.0467ms,3.3
+ 169.0468ms,0.0V 169.0599ms,0.0
+ 169.0600ms,3.3V 169.0667ms,3.3
+ 169.0668ms,0.0V 169.0799ms,0.0
+ 169.0800ms,3.3V 169.0867ms,3.3
+ 169.0868ms,0.0V 169.0999ms,0.0
+ 169.1000ms,3.3V 169.1067ms,3.3
+ 169.1068ms,0.0V 169.1199ms,0.0
+ 169.1200ms,3.3V 169.1267ms,3.3
+ 169.1268ms,0.0V 169.1399ms,0.0
+ 169.1400ms,3.3V 169.1467ms,3.3
+ 169.1468ms,0.0V 169.1599ms,0.0
+ 169.1600ms,3.3V 169.1667ms,3.3
+ 169.1668ms,0.0V 169.1799ms,0.0
+ 169.1800ms,3.3V 169.1867ms,3.3
+ 169.1868ms,0.0V 169.1999ms,0.0
+ 169.2000ms,3.3V 169.2067ms,3.3
+ 169.2068ms,0.0V 169.2199ms,0.0
+ 169.2200ms,3.3V 169.2267ms,3.3
+ 169.2268ms,0.0V 169.2399ms,0.0
+ 169.2400ms,3.3V 169.2467ms,3.3
+ 169.2468ms,0.0V 169.2599ms,0.0
+ 169.2600ms,3.3V 169.2667ms,3.3
+ 169.2668ms,0.0V 169.2799ms,0.0
+ 169.2800ms,3.3V 169.2867ms,3.3
+ 169.2868ms,0.0V 169.2999ms,0.0
+ 169.3000ms,3.3V 169.3067ms,3.3
+ 169.3068ms,0.0V 169.3199ms,0.0
+ 169.3200ms,3.3V 169.3267ms,3.3
+ 169.3268ms,0.0V 169.3399ms,0.0
+ 169.3400ms,3.3V 169.3467ms,3.3
+ 169.3468ms,0.0V 169.3599ms,0.0
+ 169.3600ms,3.3V 169.3667ms,3.3
+ 169.3668ms,0.0V 169.3799ms,0.0
+ 169.3800ms,3.3V 169.3867ms,3.3
+ 169.3868ms,0.0V 169.3999ms,0.0
+ 169.4000ms,3.3V 169.4067ms,3.3
+ 169.4068ms,0.0V 169.4199ms,0.0
+ 169.4200ms,3.3V 169.4267ms,3.3
+ 169.4268ms,0.0V 169.4399ms,0.0
+ 169.4400ms,3.3V 169.4467ms,3.3
+ 169.4468ms,0.0V 169.4599ms,0.0
+ 169.4600ms,3.3V 169.4667ms,3.3
+ 169.4668ms,0.0V 169.4799ms,0.0
+ 169.4800ms,3.3V 169.4867ms,3.3
+ 169.4868ms,0.0V 169.4999ms,0.0
+ 169.5000ms,3.3V 169.5067ms,3.3
+ 169.5068ms,0.0V 169.5199ms,0.0
+ 169.5200ms,3.3V 169.5267ms,3.3
+ 169.5268ms,0.0V 169.5399ms,0.0
+ 169.5400ms,3.3V 169.5467ms,3.3
+ 169.5468ms,0.0V 169.5599ms,0.0
+ 169.5600ms,3.3V 169.5667ms,3.3
+ 169.5668ms,0.0V 169.5799ms,0.0
+ 169.5800ms,3.3V 169.5867ms,3.3
+ 169.5868ms,0.0V 169.5999ms,0.0
+ 169.6000ms,3.3V 169.6067ms,3.3
+ 169.6068ms,0.0V 169.6199ms,0.0
+ 169.6200ms,3.3V 169.6267ms,3.3
+ 169.6268ms,0.0V 169.6399ms,0.0
+ 169.6400ms,3.3V 169.6467ms,3.3
+ 169.6468ms,0.0V 169.6599ms,0.0
+ 169.6600ms,3.3V 169.6667ms,3.3
+ 169.6668ms,0.0V 169.6799ms,0.0
+ 169.6800ms,3.3V 169.6867ms,3.3
+ 169.6868ms,0.0V 169.6999ms,0.0
+ 169.7000ms,3.3V 169.7067ms,3.3
+ 169.7068ms,0.0V 169.7199ms,0.0
+ 169.7200ms,3.3V 169.7267ms,3.3
+ 169.7268ms,0.0V 169.7399ms,0.0
+ 169.7400ms,3.3V 169.7467ms,3.3
+ 169.7468ms,0.0V 169.7599ms,0.0
+ 169.7600ms,3.3V 169.7667ms,3.3
+ 169.7668ms,0.0V 169.7799ms,0.0
+ 169.7800ms,3.3V 169.7867ms,3.3
+ 169.7868ms,0.0V 169.7999ms,0.0
+ 169.8000ms,3.3V 169.8067ms,3.3
+ 169.8068ms,0.0V 169.8199ms,0.0
+ 169.8200ms,3.3V 169.8267ms,3.3
+ 169.8268ms,0.0V 169.8399ms,0.0
+ 169.8400ms,3.3V 169.8467ms,3.3
+ 169.8468ms,0.0V 169.8599ms,0.0
+ 169.8600ms,3.3V 169.8667ms,3.3
+ 169.8668ms,0.0V 169.8799ms,0.0
+ 169.8800ms,3.3V 169.8867ms,3.3
+ 169.8868ms,0.0V 169.8999ms,0.0
+ 169.9000ms,3.3V 169.9067ms,3.3
+ 169.9068ms,0.0V 169.9199ms,0.0
+ 169.9200ms,3.3V 169.9267ms,3.3
+ 169.9268ms,0.0V 169.9399ms,0.0
+ 169.9400ms,3.3V 169.9467ms,3.3
+ 169.9468ms,0.0V 169.9599ms,0.0
+ 169.9600ms,3.3V 169.9667ms,3.3
+ 169.9668ms,0.0V 169.9799ms,0.0
+ 169.9800ms,3.3V 169.9867ms,3.3
+ 169.9868ms,0.0V 169.9999ms,0.0
+ 170.0000ms,3.3V 170.0067ms,3.3
+ 170.0068ms,0.0V 170.0199ms,0.0
+ 170.0200ms,3.3V 170.0267ms,3.3
+ 170.0268ms,0.0V 170.0399ms,0.0
+ 170.0400ms,3.3V 170.0467ms,3.3
+ 170.0468ms,0.0V 170.0599ms,0.0
+ 170.0600ms,3.3V 170.0667ms,3.3
+ 170.0668ms,0.0V 170.0799ms,0.0
+ 170.0800ms,3.3V 170.0867ms,3.3
+ 170.0868ms,0.0V 170.0999ms,0.0
+ 170.1000ms,3.3V 170.1067ms,3.3
+ 170.1068ms,0.0V 170.1199ms,0.0
+ 170.1200ms,3.3V 170.1267ms,3.3
+ 170.1268ms,0.0V 170.1399ms,0.0
+ 170.1400ms,3.3V 170.1467ms,3.3
+ 170.1468ms,0.0V 170.1599ms,0.0
+ 170.1600ms,3.3V 170.1667ms,3.3
+ 170.1668ms,0.0V 170.1799ms,0.0
+ 170.1800ms,3.3V 170.1867ms,3.3
+ 170.1868ms,0.0V 170.1999ms,0.0
+ 170.2000ms,3.3V 170.2067ms,3.3
+ 170.2068ms,0.0V 170.2199ms,0.0
+ 170.2200ms,3.3V 170.2267ms,3.3
+ 170.2268ms,0.0V 170.2399ms,0.0
+ 170.2400ms,3.3V 170.2467ms,3.3
+ 170.2468ms,0.0V 170.2599ms,0.0
+ 170.2600ms,3.3V 170.2667ms,3.3
+ 170.2668ms,0.0V 170.2799ms,0.0
+ 170.2800ms,3.3V 170.2867ms,3.3
+ 170.2868ms,0.0V 170.2999ms,0.0
+ 170.3000ms,3.3V 170.3067ms,3.3
+ 170.3068ms,0.0V 170.3199ms,0.0
+ 170.3200ms,3.3V 170.3267ms,3.3
+ 170.3268ms,0.0V 170.3399ms,0.0
+ 170.3400ms,3.3V 170.3467ms,3.3
+ 170.3468ms,0.0V 170.3599ms,0.0
+ 170.3600ms,3.3V 170.3669ms,3.3
+ 170.3670ms,0.0V 170.3799ms,0.0
+ 170.3800ms,3.3V 170.3869ms,3.3
+ 170.3870ms,0.0V 170.3999ms,0.0
+ 170.4000ms,3.3V 170.4069ms,3.3
+ 170.4070ms,0.0V 170.4199ms,0.0
+ 170.4200ms,3.3V 170.4269ms,3.3
+ 170.4270ms,0.0V 170.4399ms,0.0
+ 170.4400ms,3.3V 170.4469ms,3.3
+ 170.4470ms,0.0V 170.4599ms,0.0
+ 170.4600ms,3.3V 170.4669ms,3.3
+ 170.4670ms,0.0V 170.4799ms,0.0
+ 170.4800ms,3.3V 170.4869ms,3.3
+ 170.4870ms,0.0V 170.4999ms,0.0
+ 170.5000ms,3.3V 170.5069ms,3.3
+ 170.5070ms,0.0V 170.5199ms,0.0
+ 170.5200ms,3.3V 170.5269ms,3.3
+ 170.5270ms,0.0V 170.5399ms,0.0
+ 170.5400ms,3.3V 170.5469ms,3.3
+ 170.5470ms,0.0V 170.5599ms,0.0
+ 170.5600ms,3.3V 170.5669ms,3.3
+ 170.5670ms,0.0V 170.5799ms,0.0
+ 170.5800ms,3.3V 170.5869ms,3.3
+ 170.5870ms,0.0V 170.5999ms,0.0
+ 170.6000ms,3.3V 170.6069ms,3.3
+ 170.6070ms,0.0V 170.6199ms,0.0
+ 170.6200ms,3.3V 170.6269ms,3.3
+ 170.6270ms,0.0V 170.6399ms,0.0
+ 170.6400ms,3.3V 170.6469ms,3.3
+ 170.6470ms,0.0V 170.6599ms,0.0
+ 170.6600ms,3.3V 170.6669ms,3.3
+ 170.6670ms,0.0V 170.6799ms,0.0
+ 170.6800ms,3.3V 170.6869ms,3.3
+ 170.6870ms,0.0V 170.6999ms,0.0
+ 170.7000ms,3.3V 170.7069ms,3.3
+ 170.7070ms,0.0V 170.7199ms,0.0
+ 170.7200ms,3.3V 170.7269ms,3.3
+ 170.7270ms,0.0V 170.7399ms,0.0
+ 170.7400ms,3.3V 170.7469ms,3.3
+ 170.7470ms,0.0V 170.7599ms,0.0
+ 170.7600ms,3.3V 170.7669ms,3.3
+ 170.7670ms,0.0V 170.7799ms,0.0
+ 170.7800ms,3.3V 170.7869ms,3.3
+ 170.7870ms,0.0V 170.7999ms,0.0
+ 170.8000ms,3.3V 170.8069ms,3.3
+ 170.8070ms,0.0V 170.8199ms,0.0
+ 170.8200ms,3.3V 170.8269ms,3.3
+ 170.8270ms,0.0V 170.8399ms,0.0
+ 170.8400ms,3.3V 170.8469ms,3.3
+ 170.8470ms,0.0V 170.8599ms,0.0
+ 170.8600ms,3.3V 170.8669ms,3.3
+ 170.8670ms,0.0V 170.8799ms,0.0
+ 170.8800ms,3.3V 170.8869ms,3.3
+ 170.8870ms,0.0V 170.8999ms,0.0
+ 170.9000ms,3.3V 170.9069ms,3.3
+ 170.9070ms,0.0V 170.9199ms,0.0
+ 170.9200ms,3.3V 170.9269ms,3.3
+ 170.9270ms,0.0V 170.9399ms,0.0
+ 170.9400ms,3.3V 170.9469ms,3.3
+ 170.9470ms,0.0V 170.9599ms,0.0
+ 170.9600ms,3.3V 170.9669ms,3.3
+ 170.9670ms,0.0V 170.9799ms,0.0
+ 170.9800ms,3.3V 170.9869ms,3.3
+ 170.9870ms,0.0V 170.9999ms,0.0
+ 171.0000ms,3.3V 171.0069ms,3.3
+ 171.0070ms,0.0V 171.0199ms,0.0
+ 171.0200ms,3.3V 171.0269ms,3.3
+ 171.0270ms,0.0V 171.0399ms,0.0
+ 171.0400ms,3.3V 171.0469ms,3.3
+ 171.0470ms,0.0V 171.0599ms,0.0
+ 171.0600ms,3.3V 171.0669ms,3.3
+ 171.0670ms,0.0V 171.0799ms,0.0
+ 171.0800ms,3.3V 171.0869ms,3.3
+ 171.0870ms,0.0V 171.0999ms,0.0
+ 171.1000ms,3.3V 171.1069ms,3.3
+ 171.1070ms,0.0V 171.1199ms,0.0
+ 171.1200ms,3.3V 171.1269ms,3.3
+ 171.1270ms,0.0V 171.1399ms,0.0
+ 171.1400ms,3.3V 171.1469ms,3.3
+ 171.1470ms,0.0V 171.1599ms,0.0
+ 171.1600ms,3.3V 171.1669ms,3.3
+ 171.1670ms,0.0V 171.1799ms,0.0
+ 171.1800ms,3.3V 171.1869ms,3.3
+ 171.1870ms,0.0V 171.1999ms,0.0
+ 171.2000ms,3.3V 171.2069ms,3.3
+ 171.2070ms,0.0V 171.2199ms,0.0
+ 171.2200ms,3.3V 171.2269ms,3.3
+ 171.2270ms,0.0V 171.2399ms,0.0
+ 171.2400ms,3.3V 171.2469ms,3.3
+ 171.2470ms,0.0V 171.2599ms,0.0
+ 171.2600ms,3.3V 171.2669ms,3.3
+ 171.2670ms,0.0V 171.2799ms,0.0
+ 171.2800ms,3.3V 171.2869ms,3.3
+ 171.2870ms,0.0V 171.2999ms,0.0
+ 171.3000ms,3.3V 171.3069ms,3.3
+ 171.3070ms,0.0V 171.3199ms,0.0
+ 171.3200ms,3.3V 171.3269ms,3.3
+ 171.3270ms,0.0V 171.3399ms,0.0
+ 171.3400ms,3.3V 171.3469ms,3.3
+ 171.3470ms,0.0V 171.3599ms,0.0
+ 171.3600ms,3.3V 171.3669ms,3.3
+ 171.3670ms,0.0V 171.3799ms,0.0
+ 171.3800ms,3.3V 171.3869ms,3.3
+ 171.3870ms,0.0V 171.3999ms,0.0
+ 171.4000ms,3.3V 171.4069ms,3.3
+ 171.4070ms,0.0V 171.4199ms,0.0
+ 171.4200ms,3.3V 171.4269ms,3.3
+ 171.4270ms,0.0V 171.4399ms,0.0
+ 171.4400ms,3.3V 171.4469ms,3.3
+ 171.4470ms,0.0V 171.4599ms,0.0
+ 171.4600ms,3.3V 171.4669ms,3.3
+ 171.4670ms,0.0V 171.4799ms,0.0
+ 171.4800ms,3.3V 171.4869ms,3.3
+ 171.4870ms,0.0V 171.4999ms,0.0
+ 171.5000ms,3.3V 171.5069ms,3.3
+ 171.5070ms,0.0V 171.5199ms,0.0
+ 171.5200ms,3.3V 171.5269ms,3.3
+ 171.5270ms,0.0V 171.5399ms,0.0
+ 171.5400ms,3.3V 171.5469ms,3.3
+ 171.5470ms,0.0V 171.5599ms,0.0
+ 171.5600ms,3.3V 171.5669ms,3.3
+ 171.5670ms,0.0V 171.5799ms,0.0
+ 171.5800ms,3.3V 171.5869ms,3.3
+ 171.5870ms,0.0V 171.5999ms,0.0
+ 171.6000ms,3.3V 171.6069ms,3.3
+ 171.6070ms,0.0V 171.6199ms,0.0
+ 171.6200ms,3.3V 171.6269ms,3.3
+ 171.6270ms,0.0V 171.6399ms,0.0
+ 171.6400ms,3.3V 171.6469ms,3.3
+ 171.6470ms,0.0V 171.6599ms,0.0
+ 171.6600ms,3.3V 171.6669ms,3.3
+ 171.6670ms,0.0V 171.6799ms,0.0
+ 171.6800ms,3.3V 171.6869ms,3.3
+ 171.6870ms,0.0V 171.6999ms,0.0
+ 171.7000ms,3.3V 171.7069ms,3.3
+ 171.7070ms,0.0V 171.7199ms,0.0
+ 171.7200ms,3.3V 171.7269ms,3.3
+ 171.7270ms,0.0V 171.7399ms,0.0
+ 171.7400ms,3.3V 171.7469ms,3.3
+ 171.7470ms,0.0V 171.7599ms,0.0
+ 171.7600ms,3.3V 171.7669ms,3.3
+ 171.7670ms,0.0V 171.7799ms,0.0
+ 171.7800ms,3.3V 171.7869ms,3.3
+ 171.7870ms,0.0V 171.7999ms,0.0
+ 171.8000ms,3.3V 171.8069ms,3.3
+ 171.8070ms,0.0V 171.8199ms,0.0
+ 171.8200ms,3.3V 171.8269ms,3.3
+ 171.8270ms,0.0V 171.8399ms,0.0
+ 171.8400ms,3.3V 171.8469ms,3.3
+ 171.8470ms,0.0V 171.8599ms,0.0
+ 171.8600ms,3.3V 171.8669ms,3.3
+ 171.8670ms,0.0V 171.8799ms,0.0
+ 171.8800ms,3.3V 171.8869ms,3.3
+ 171.8870ms,0.0V 171.8999ms,0.0
+ 171.9000ms,3.3V 171.9069ms,3.3
+ 171.9070ms,0.0V 171.9199ms,0.0
+ 171.9200ms,3.3V 171.9269ms,3.3
+ 171.9270ms,0.0V 171.9399ms,0.0
+ 171.9400ms,3.3V 171.9469ms,3.3
+ 171.9470ms,0.0V 171.9599ms,0.0
+ 171.9600ms,3.3V 171.9669ms,3.3
+ 171.9670ms,0.0V 171.9799ms,0.0
+ 171.9800ms,3.3V 171.9869ms,3.3
+ 171.9870ms,0.0V 171.9999ms,0.0
+ 172.0000ms,3.3V 172.0069ms,3.3
+ 172.0070ms,0.0V 172.0199ms,0.0
+ 172.0200ms,3.3V 172.0269ms,3.3
+ 172.0270ms,0.0V 172.0399ms,0.0
+ 172.0400ms,3.3V 172.0469ms,3.3
+ 172.0470ms,0.0V 172.0599ms,0.0
+ 172.0600ms,3.3V 172.0669ms,3.3
+ 172.0670ms,0.0V 172.0799ms,0.0
+ 172.0800ms,3.3V 172.0869ms,3.3
+ 172.0870ms,0.0V 172.0999ms,0.0
+ 172.1000ms,3.3V 172.1069ms,3.3
+ 172.1070ms,0.0V 172.1199ms,0.0
+ 172.1200ms,3.3V 172.1269ms,3.3
+ 172.1270ms,0.0V 172.1399ms,0.0
+ 172.1400ms,3.3V 172.1469ms,3.3
+ 172.1470ms,0.0V 172.1599ms,0.0
+ 172.1600ms,3.3V 172.1669ms,3.3
+ 172.1670ms,0.0V 172.1799ms,0.0
+ 172.1800ms,3.3V 172.1869ms,3.3
+ 172.1870ms,0.0V 172.1999ms,0.0
+ 172.2000ms,3.3V 172.2069ms,3.3
+ 172.2070ms,0.0V 172.2199ms,0.0
+ 172.2200ms,3.3V 172.2269ms,3.3
+ 172.2270ms,0.0V 172.2399ms,0.0
+ 172.2400ms,3.3V 172.2469ms,3.3
+ 172.2470ms,0.0V 172.2599ms,0.0
+ 172.2600ms,3.3V 172.2669ms,3.3
+ 172.2670ms,0.0V 172.2799ms,0.0
+ 172.2800ms,3.3V 172.2869ms,3.3
+ 172.2870ms,0.0V 172.2999ms,0.0
+ 172.3000ms,3.3V 172.3069ms,3.3
+ 172.3070ms,0.0V 172.3199ms,0.0
+ 172.3200ms,3.3V 172.3269ms,3.3
+ 172.3270ms,0.0V 172.3399ms,0.0
+ 172.3400ms,3.3V 172.3469ms,3.3
+ 172.3470ms,0.0V 172.3599ms,0.0
+ 172.3600ms,3.3V 172.3669ms,3.3
+ 172.3670ms,0.0V 172.3799ms,0.0
+ 172.3800ms,3.3V 172.3869ms,3.3
+ 172.3870ms,0.0V 172.3999ms,0.0
+ 172.4000ms,3.3V 172.4069ms,3.3
+ 172.4070ms,0.0V 172.4199ms,0.0
+ 172.4200ms,3.3V 172.4269ms,3.3
+ 172.4270ms,0.0V 172.4399ms,0.0
+ 172.4400ms,3.3V 172.4469ms,3.3
+ 172.4470ms,0.0V 172.4599ms,0.0
+ 172.4600ms,3.3V 172.4669ms,3.3
+ 172.4670ms,0.0V 172.4799ms,0.0
+ 172.4800ms,3.3V 172.4869ms,3.3
+ 172.4870ms,0.0V 172.4999ms,0.0
+ 172.5000ms,3.3V 172.5069ms,3.3
+ 172.5070ms,0.0V 172.5199ms,0.0
+ 172.5200ms,3.3V 172.5269ms,3.3
+ 172.5270ms,0.0V 172.5399ms,0.0
+ 172.5400ms,3.3V 172.5469ms,3.3
+ 172.5470ms,0.0V 172.5599ms,0.0
+ 172.5600ms,3.3V 172.5669ms,3.3
+ 172.5670ms,0.0V 172.5799ms,0.0
+ 172.5800ms,3.3V 172.5869ms,3.3
+ 172.5870ms,0.0V 172.5999ms,0.0
+ 172.6000ms,3.3V 172.6069ms,3.3
+ 172.6070ms,0.0V 172.6199ms,0.0
+ 172.6200ms,3.3V 172.6269ms,3.3
+ 172.6270ms,0.0V 172.6399ms,0.0
+ 172.6400ms,3.3V 172.6469ms,3.3
+ 172.6470ms,0.0V 172.6599ms,0.0
+ 172.6600ms,3.3V 172.6669ms,3.3
+ 172.6670ms,0.0V 172.6799ms,0.0
+ 172.6800ms,3.3V 172.6869ms,3.3
+ 172.6870ms,0.0V 172.6999ms,0.0
+ 172.7000ms,3.3V 172.7069ms,3.3
+ 172.7070ms,0.0V 172.7199ms,0.0
+ 172.7200ms,3.3V 172.7269ms,3.3
+ 172.7270ms,0.0V 172.7399ms,0.0
+ 172.7400ms,3.3V 172.7469ms,3.3
+ 172.7470ms,0.0V 172.7599ms,0.0
+ 172.7600ms,3.3V 172.7669ms,3.3
+ 172.7670ms,0.0V 172.7799ms,0.0
+ 172.7800ms,3.3V 172.7869ms,3.3
+ 172.7870ms,0.0V 172.7999ms,0.0
+ 172.8000ms,3.3V 172.8069ms,3.3
+ 172.8070ms,0.0V 172.8199ms,0.0
+ 172.8200ms,3.3V 172.8269ms,3.3
+ 172.8270ms,0.0V 172.8399ms,0.0
+ 172.8400ms,3.3V 172.8469ms,3.3
+ 172.8470ms,0.0V 172.8599ms,0.0
+ 172.8600ms,3.3V 172.8669ms,3.3
+ 172.8670ms,0.0V 172.8799ms,0.0
+ 172.8800ms,3.3V 172.8869ms,3.3
+ 172.8870ms,0.0V 172.8999ms,0.0
+ 172.9000ms,3.3V 172.9069ms,3.3
+ 172.9070ms,0.0V 172.9199ms,0.0
+ 172.9200ms,3.3V 172.9269ms,3.3
+ 172.9270ms,0.0V 172.9399ms,0.0
+ 172.9400ms,3.3V 172.9469ms,3.3
+ 172.9470ms,0.0V 172.9599ms,0.0
+ 172.9600ms,3.3V 172.9669ms,3.3
+ 172.9670ms,0.0V 172.9799ms,0.0
+ 172.9800ms,3.3V 172.9869ms,3.3
+ 172.9870ms,0.0V 172.9999ms,0.0
+ 173.0000ms,3.3V 173.0069ms,3.3
+ 173.0070ms,0.0V 173.0199ms,0.0
+ 173.0200ms,3.3V 173.0269ms,3.3
+ 173.0270ms,0.0V 173.0399ms,0.0
+ 173.0400ms,3.3V 173.0469ms,3.3
+ 173.0470ms,0.0V 173.0599ms,0.0
+ 173.0600ms,3.3V 173.0669ms,3.3
+ 173.0670ms,0.0V 173.0799ms,0.0
+ 173.0800ms,3.3V 173.0869ms,3.3
+ 173.0870ms,0.0V 173.0999ms,0.0
+ 173.1000ms,3.3V 173.1069ms,3.3
+ 173.1070ms,0.0V 173.1199ms,0.0
+ 173.1200ms,3.3V 173.1269ms,3.3
+ 173.1270ms,0.0V 173.1399ms,0.0
+ 173.1400ms,3.3V 173.1469ms,3.3
+ 173.1470ms,0.0V 173.1599ms,0.0
+ 173.1600ms,3.3V 173.1669ms,3.3
+ 173.1670ms,0.0V 173.1799ms,0.0
+ 173.1800ms,3.3V 173.1869ms,3.3
+ 173.1870ms,0.0V 173.1999ms,0.0
+ 173.2000ms,3.3V 173.2069ms,3.3
+ 173.2070ms,0.0V 173.2199ms,0.0
+ 173.2200ms,3.3V 173.2269ms,3.3
+ 173.2270ms,0.0V 173.2399ms,0.0
+ 173.2400ms,3.3V 173.2469ms,3.3
+ 173.2470ms,0.0V 173.2599ms,0.0
+ 173.2600ms,3.3V 173.2669ms,3.3
+ 173.2670ms,0.0V 173.2799ms,0.0
+ 173.2800ms,3.3V 173.2869ms,3.3
+ 173.2870ms,0.0V 173.2999ms,0.0
+ 173.3000ms,3.3V 173.3069ms,3.3
+ 173.3070ms,0.0V 173.3199ms,0.0
+ 173.3200ms,3.3V 173.3269ms,3.3
+ 173.3270ms,0.0V 173.3399ms,0.0
+ 173.3400ms,3.3V 173.3469ms,3.3
+ 173.3470ms,0.0V 173.3599ms,0.0
+ 173.3600ms,3.3V 173.3669ms,3.3
+ 173.3670ms,0.0V 173.3799ms,0.0
+ 173.3800ms,3.3V 173.3869ms,3.3
+ 173.3870ms,0.0V 173.3999ms,0.0
+ 173.4000ms,3.3V 173.4069ms,3.3
+ 173.4070ms,0.0V 173.4199ms,0.0
+ 173.4200ms,3.3V 173.4269ms,3.3
+ 173.4270ms,0.0V 173.4399ms,0.0
+ 173.4400ms,3.3V 173.4469ms,3.3
+ 173.4470ms,0.0V 173.4599ms,0.0
+ 173.4600ms,3.3V 173.4669ms,3.3
+ 173.4670ms,0.0V 173.4799ms,0.0
+ 173.4800ms,3.3V 173.4869ms,3.3
+ 173.4870ms,0.0V 173.4999ms,0.0
+ 173.5000ms,3.3V 173.5069ms,3.3
+ 173.5070ms,0.0V 173.5199ms,0.0
+ 173.5200ms,3.3V 173.5269ms,3.3
+ 173.5270ms,0.0V 173.5399ms,0.0
+ 173.5400ms,3.3V 173.5469ms,3.3
+ 173.5470ms,0.0V 173.5599ms,0.0
+ 173.5600ms,3.3V 173.5669ms,3.3
+ 173.5670ms,0.0V 173.5799ms,0.0
+ 173.5800ms,3.3V 173.5869ms,3.3
+ 173.5870ms,0.0V 173.5999ms,0.0
+ 173.6000ms,3.3V 173.6069ms,3.3
+ 173.6070ms,0.0V 173.6199ms,0.0
+ 173.6200ms,3.3V 173.6269ms,3.3
+ 173.6270ms,0.0V 173.6399ms,0.0
+ 173.6400ms,3.3V 173.6469ms,3.3
+ 173.6470ms,0.0V 173.6599ms,0.0
+ 173.6600ms,3.3V 173.6669ms,3.3
+ 173.6670ms,0.0V 173.6799ms,0.0
+ 173.6800ms,3.3V 173.6869ms,3.3
+ 173.6870ms,0.0V 173.6999ms,0.0
+ 173.7000ms,3.3V 173.7069ms,3.3
+ 173.7070ms,0.0V 173.7199ms,0.0
+ 173.7200ms,3.3V 173.7269ms,3.3
+ 173.7270ms,0.0V 173.7399ms,0.0
+ 173.7400ms,3.3V 173.7469ms,3.3
+ 173.7470ms,0.0V 173.7599ms,0.0
+ 173.7600ms,3.3V 173.7669ms,3.3
+ 173.7670ms,0.0V 173.7799ms,0.0
+ 173.7800ms,3.3V 173.7869ms,3.3
+ 173.7870ms,0.0V 173.7999ms,0.0
+ 173.8000ms,3.3V 173.8069ms,3.3
+ 173.8070ms,0.0V 173.8199ms,0.0
+ 173.8200ms,3.3V 173.8269ms,3.3
+ 173.8270ms,0.0V 173.8399ms,0.0
+ 173.8400ms,3.3V 173.8469ms,3.3
+ 173.8470ms,0.0V 173.8599ms,0.0
+ 173.8600ms,3.3V 173.8669ms,3.3
+ 173.8670ms,0.0V 173.8799ms,0.0
+ 173.8800ms,3.3V 173.8869ms,3.3
+ 173.8870ms,0.0V 173.8999ms,0.0
+ 173.9000ms,3.3V 173.9069ms,3.3
+ 173.9070ms,0.0V 173.9199ms,0.0
+ 173.9200ms,3.3V 173.9269ms,3.3
+ 173.9270ms,0.0V 173.9399ms,0.0
+ 173.9400ms,3.3V 173.9469ms,3.3
+ 173.9470ms,0.0V 173.9599ms,0.0
+ 173.9600ms,3.3V 173.9669ms,3.3
+ 173.9670ms,0.0V 173.9799ms,0.0
+ 173.9800ms,3.3V 173.9869ms,3.3
+ 173.9870ms,0.0V 173.9999ms,0.0
+ 174.0000ms,3.3V 174.0069ms,3.3
+ 174.0070ms,0.0V 174.0199ms,0.0
+ 174.0200ms,3.3V 174.0269ms,3.3
+ 174.0270ms,0.0V 174.0399ms,0.0
+ 174.0400ms,3.3V 174.0469ms,3.3
+ 174.0470ms,0.0V 174.0599ms,0.0
+ 174.0600ms,3.3V 174.0669ms,3.3
+ 174.0670ms,0.0V 174.0799ms,0.0
+ 174.0800ms,3.3V 174.0869ms,3.3
+ 174.0870ms,0.0V 174.0999ms,0.0
+ 174.1000ms,3.3V 174.1069ms,3.3
+ 174.1070ms,0.0V 174.1199ms,0.0
+ 174.1200ms,3.3V 174.1269ms,3.3
+ 174.1270ms,0.0V 174.1399ms,0.0
+ 174.1400ms,3.3V 174.1469ms,3.3
+ 174.1470ms,0.0V 174.1599ms,0.0
+ 174.1600ms,3.3V 174.1669ms,3.3
+ 174.1670ms,0.0V 174.1799ms,0.0
+ 174.1800ms,3.3V 174.1869ms,3.3
+ 174.1870ms,0.0V 174.1999ms,0.0
+ 174.2000ms,3.3V 174.2069ms,3.3
+ 174.2070ms,0.0V 174.2199ms,0.0
+ 174.2200ms,3.3V 174.2269ms,3.3
+ 174.2270ms,0.0V 174.2399ms,0.0
+ 174.2400ms,3.3V 174.2469ms,3.3
+ 174.2470ms,0.0V 174.2599ms,0.0
+ 174.2600ms,3.3V 174.2669ms,3.3
+ 174.2670ms,0.0V 174.2799ms,0.0
+ 174.2800ms,3.3V 174.2869ms,3.3
+ 174.2870ms,0.0V 174.2999ms,0.0
+ 174.3000ms,3.3V 174.3069ms,3.3
+ 174.3070ms,0.0V 174.3199ms,0.0
+ 174.3200ms,3.3V 174.3269ms,3.3
+ 174.3270ms,0.0V 174.3399ms,0.0
+ 174.3400ms,3.3V 174.3469ms,3.3
+ 174.3470ms,0.0V 174.3599ms,0.0
+ 174.3600ms,3.3V 174.3669ms,3.3
+ 174.3670ms,0.0V 174.3799ms,0.0
+ 174.3800ms,3.3V 174.3869ms,3.3
+ 174.3870ms,0.0V 174.3999ms,0.0
+ 174.4000ms,3.3V 174.4069ms,3.3
+ 174.4070ms,0.0V 174.4199ms,0.0
+ 174.4200ms,3.3V 174.4269ms,3.3
+ 174.4270ms,0.0V 174.4399ms,0.0
+ 174.4400ms,3.3V 174.4469ms,3.3
+ 174.4470ms,0.0V 174.4599ms,0.0
+ 174.4600ms,3.3V 174.4669ms,3.3
+ 174.4670ms,0.0V 174.4799ms,0.0
+ 174.4800ms,3.3V 174.4869ms,3.3
+ 174.4870ms,0.0V 174.4999ms,0.0
+ 174.5000ms,3.3V 174.5069ms,3.3
+ 174.5070ms,0.0V 174.5199ms,0.0
+ 174.5200ms,3.3V 174.5269ms,3.3
+ 174.5270ms,0.0V 174.5399ms,0.0
+ 174.5400ms,3.3V 174.5469ms,3.3
+ 174.5470ms,0.0V 174.5599ms,0.0
+ 174.5600ms,3.3V 174.5669ms,3.3
+ 174.5670ms,0.0V 174.5799ms,0.0
+ 174.5800ms,3.3V 174.5869ms,3.3
+ 174.5870ms,0.0V 174.5999ms,0.0
+ 174.6000ms,3.3V 174.6069ms,3.3
+ 174.6070ms,0.0V 174.6199ms,0.0
+ 174.6200ms,3.3V 174.6269ms,3.3
+ 174.6270ms,0.0V 174.6399ms,0.0
+ 174.6400ms,3.3V 174.6469ms,3.3
+ 174.6470ms,0.0V 174.6599ms,0.0
+ 174.6600ms,3.3V 174.6669ms,3.3
+ 174.6670ms,0.0V 174.6799ms,0.0
+ 174.6800ms,3.3V 174.6869ms,3.3
+ 174.6870ms,0.0V 174.6999ms,0.0
+ 174.7000ms,3.3V 174.7069ms,3.3
+ 174.7070ms,0.0V 174.7199ms,0.0
+ 174.7200ms,3.3V 174.7269ms,3.3
+ 174.7270ms,0.0V 174.7399ms,0.0
+ 174.7400ms,3.3V 174.7469ms,3.3
+ 174.7470ms,0.0V 174.7599ms,0.0
+ 174.7600ms,3.3V 174.7669ms,3.3
+ 174.7670ms,0.0V 174.7799ms,0.0
+ 174.7800ms,3.3V 174.7869ms,3.3
+ 174.7870ms,0.0V 174.7999ms,0.0
+ 174.8000ms,3.3V 174.8069ms,3.3
+ 174.8070ms,0.0V 174.8199ms,0.0
+ 174.8200ms,3.3V 174.8269ms,3.3
+ 174.8270ms,0.0V 174.8399ms,0.0
+ 174.8400ms,3.3V 174.8469ms,3.3
+ 174.8470ms,0.0V 174.8599ms,0.0
+ 174.8600ms,3.3V 174.8669ms,3.3
+ 174.8670ms,0.0V 174.8799ms,0.0
+ 174.8800ms,3.3V 174.8869ms,3.3
+ 174.8870ms,0.0V 174.8999ms,0.0
+ 174.9000ms,3.3V 174.9069ms,3.3
+ 174.9070ms,0.0V 174.9199ms,0.0
+ 174.9200ms,3.3V 174.9269ms,3.3
+ 174.9270ms,0.0V 174.9399ms,0.0
+ 174.9400ms,3.3V 174.9469ms,3.3
+ 174.9470ms,0.0V 174.9599ms,0.0
+ 174.9600ms,3.3V 174.9669ms,3.3
+ 174.9670ms,0.0V 174.9799ms,0.0
+ 174.9800ms,3.3V 174.9869ms,3.3
+ 174.9870ms,0.0V 174.9999ms,0.0
+ 175.0000ms,3.3V 175.0069ms,3.3
+ 175.0070ms,0.0V 175.0199ms,0.0
+ 175.0200ms,3.3V 175.0269ms,3.3
+ 175.0270ms,0.0V 175.0399ms,0.0
+ 175.0400ms,3.3V 175.0469ms,3.3
+ 175.0470ms,0.0V 175.0599ms,0.0
+ 175.0600ms,3.3V 175.0669ms,3.3
+ 175.0670ms,0.0V 175.0799ms,0.0
+ 175.0800ms,3.3V 175.0869ms,3.3
+ 175.0870ms,0.0V 175.0999ms,0.0
+ 175.1000ms,3.3V 175.1069ms,3.3
+ 175.1070ms,0.0V 175.1199ms,0.0
+ 175.1200ms,3.3V 175.1269ms,3.3
+ 175.1270ms,0.0V 175.1399ms,0.0
+ 175.1400ms,3.3V 175.1469ms,3.3
+ 175.1470ms,0.0V 175.1599ms,0.0
+ 175.1600ms,3.3V 175.1669ms,3.3
+ 175.1670ms,0.0V 175.1799ms,0.0
+ 175.1800ms,3.3V 175.1869ms,3.3
+ 175.1870ms,0.0V 175.1999ms,0.0
+ 175.2000ms,3.3V 175.2069ms,3.3
+ 175.2070ms,0.0V 175.2199ms,0.0
+ 175.2200ms,3.3V 175.2269ms,3.3
+ 175.2270ms,0.0V 175.2399ms,0.0
+ 175.2400ms,3.3V 175.2469ms,3.3
+ 175.2470ms,0.0V 175.2599ms,0.0
+ 175.2600ms,3.3V 175.2669ms,3.3
+ 175.2670ms,0.0V 175.2799ms,0.0
+ 175.2800ms,3.3V 175.2869ms,3.3
+ 175.2870ms,0.0V 175.2999ms,0.0
+ 175.3000ms,3.3V 175.3069ms,3.3
+ 175.3070ms,0.0V 175.3199ms,0.0
+ 175.3200ms,3.3V 175.3269ms,3.3
+ 175.3270ms,0.0V 175.3399ms,0.0
+ 175.3400ms,3.3V 175.3469ms,3.3
+ 175.3470ms,0.0V 175.3599ms,0.0
+ 175.3600ms,3.3V 175.3671ms,3.3
+ 175.3672ms,0.0V 175.3799ms,0.0
+ 175.3800ms,3.3V 175.3871ms,3.3
+ 175.3872ms,0.0V 175.3999ms,0.0
+ 175.4000ms,3.3V 175.4071ms,3.3
+ 175.4072ms,0.0V 175.4199ms,0.0
+ 175.4200ms,3.3V 175.4271ms,3.3
+ 175.4272ms,0.0V 175.4399ms,0.0
+ 175.4400ms,3.3V 175.4471ms,3.3
+ 175.4472ms,0.0V 175.4599ms,0.0
+ 175.4600ms,3.3V 175.4671ms,3.3
+ 175.4672ms,0.0V 175.4799ms,0.0
+ 175.4800ms,3.3V 175.4871ms,3.3
+ 175.4872ms,0.0V 175.4999ms,0.0
+ 175.5000ms,3.3V 175.5071ms,3.3
+ 175.5072ms,0.0V 175.5199ms,0.0
+ 175.5200ms,3.3V 175.5271ms,3.3
+ 175.5272ms,0.0V 175.5399ms,0.0
+ 175.5400ms,3.3V 175.5471ms,3.3
+ 175.5472ms,0.0V 175.5599ms,0.0
+ 175.5600ms,3.3V 175.5671ms,3.3
+ 175.5672ms,0.0V 175.5799ms,0.0
+ 175.5800ms,3.3V 175.5871ms,3.3
+ 175.5872ms,0.0V 175.5999ms,0.0
+ 175.6000ms,3.3V 175.6071ms,3.3
+ 175.6072ms,0.0V 175.6199ms,0.0
+ 175.6200ms,3.3V 175.6271ms,3.3
+ 175.6272ms,0.0V 175.6399ms,0.0
+ 175.6400ms,3.3V 175.6471ms,3.3
+ 175.6472ms,0.0V 175.6599ms,0.0
+ 175.6600ms,3.3V 175.6671ms,3.3
+ 175.6672ms,0.0V 175.6799ms,0.0
+ 175.6800ms,3.3V 175.6871ms,3.3
+ 175.6872ms,0.0V 175.6999ms,0.0
+ 175.7000ms,3.3V 175.7071ms,3.3
+ 175.7072ms,0.0V 175.7199ms,0.0
+ 175.7200ms,3.3V 175.7271ms,3.3
+ 175.7272ms,0.0V 175.7399ms,0.0
+ 175.7400ms,3.3V 175.7471ms,3.3
+ 175.7472ms,0.0V 175.7599ms,0.0
+ 175.7600ms,3.3V 175.7671ms,3.3
+ 175.7672ms,0.0V 175.7799ms,0.0
+ 175.7800ms,3.3V 175.7871ms,3.3
+ 175.7872ms,0.0V 175.7999ms,0.0
+ 175.8000ms,3.3V 175.8071ms,3.3
+ 175.8072ms,0.0V 175.8199ms,0.0
+ 175.8200ms,3.3V 175.8271ms,3.3
+ 175.8272ms,0.0V 175.8399ms,0.0
+ 175.8400ms,3.3V 175.8471ms,3.3
+ 175.8472ms,0.0V 175.8599ms,0.0
+ 175.8600ms,3.3V 175.8671ms,3.3
+ 175.8672ms,0.0V 175.8799ms,0.0
+ 175.8800ms,3.3V 175.8871ms,3.3
+ 175.8872ms,0.0V 175.8999ms,0.0
+ 175.9000ms,3.3V 175.9071ms,3.3
+ 175.9072ms,0.0V 175.9199ms,0.0
+ 175.9200ms,3.3V 175.9271ms,3.3
+ 175.9272ms,0.0V 175.9399ms,0.0
+ 175.9400ms,3.3V 175.9471ms,3.3
+ 175.9472ms,0.0V 175.9599ms,0.0
+ 175.9600ms,3.3V 175.9671ms,3.3
+ 175.9672ms,0.0V 175.9799ms,0.0
+ 175.9800ms,3.3V 175.9871ms,3.3
+ 175.9872ms,0.0V 175.9999ms,0.0
+ 176.0000ms,3.3V 176.0071ms,3.3
+ 176.0072ms,0.0V 176.0199ms,0.0
+ 176.0200ms,3.3V 176.0271ms,3.3
+ 176.0272ms,0.0V 176.0399ms,0.0
+ 176.0400ms,3.3V 176.0471ms,3.3
+ 176.0472ms,0.0V 176.0599ms,0.0
+ 176.0600ms,3.3V 176.0671ms,3.3
+ 176.0672ms,0.0V 176.0799ms,0.0
+ 176.0800ms,3.3V 176.0871ms,3.3
+ 176.0872ms,0.0V 176.0999ms,0.0
+ 176.1000ms,3.3V 176.1071ms,3.3
+ 176.1072ms,0.0V 176.1199ms,0.0
+ 176.1200ms,3.3V 176.1271ms,3.3
+ 176.1272ms,0.0V 176.1399ms,0.0
+ 176.1400ms,3.3V 176.1471ms,3.3
+ 176.1472ms,0.0V 176.1599ms,0.0
+ 176.1600ms,3.3V 176.1671ms,3.3
+ 176.1672ms,0.0V 176.1799ms,0.0
+ 176.1800ms,3.3V 176.1871ms,3.3
+ 176.1872ms,0.0V 176.1999ms,0.0
+ 176.2000ms,3.3V 176.2071ms,3.3
+ 176.2072ms,0.0V 176.2199ms,0.0
+ 176.2200ms,3.3V 176.2271ms,3.3
+ 176.2272ms,0.0V 176.2399ms,0.0
+ 176.2400ms,3.3V 176.2471ms,3.3
+ 176.2472ms,0.0V 176.2599ms,0.0
+ 176.2600ms,3.3V 176.2671ms,3.3
+ 176.2672ms,0.0V 176.2799ms,0.0
+ 176.2800ms,3.3V 176.2871ms,3.3
+ 176.2872ms,0.0V 176.2999ms,0.0
+ 176.3000ms,3.3V 176.3071ms,3.3
+ 176.3072ms,0.0V 176.3199ms,0.0
+ 176.3200ms,3.3V 176.3271ms,3.3
+ 176.3272ms,0.0V 176.3399ms,0.0
+ 176.3400ms,3.3V 176.3471ms,3.3
+ 176.3472ms,0.0V 176.3599ms,0.0
+ 176.3600ms,3.3V 176.3671ms,3.3
+ 176.3672ms,0.0V 176.3799ms,0.0
+ 176.3800ms,3.3V 176.3871ms,3.3
+ 176.3872ms,0.0V 176.3999ms,0.0
+ 176.4000ms,3.3V 176.4071ms,3.3
+ 176.4072ms,0.0V 176.4199ms,0.0
+ 176.4200ms,3.3V 176.4271ms,3.3
+ 176.4272ms,0.0V 176.4399ms,0.0
+ 176.4400ms,3.3V 176.4471ms,3.3
+ 176.4472ms,0.0V 176.4599ms,0.0
+ 176.4600ms,3.3V 176.4671ms,3.3
+ 176.4672ms,0.0V 176.4799ms,0.0
+ 176.4800ms,3.3V 176.4871ms,3.3
+ 176.4872ms,0.0V 176.4999ms,0.0
+ 176.5000ms,3.3V 176.5071ms,3.3
+ 176.5072ms,0.0V 176.5199ms,0.0
+ 176.5200ms,3.3V 176.5271ms,3.3
+ 176.5272ms,0.0V 176.5399ms,0.0
+ 176.5400ms,3.3V 176.5471ms,3.3
+ 176.5472ms,0.0V 176.5599ms,0.0
+ 176.5600ms,3.3V 176.5671ms,3.3
+ 176.5672ms,0.0V 176.5799ms,0.0
+ 176.5800ms,3.3V 176.5871ms,3.3
+ 176.5872ms,0.0V 176.5999ms,0.0
+ 176.6000ms,3.3V 176.6071ms,3.3
+ 176.6072ms,0.0V 176.6199ms,0.0
+ 176.6200ms,3.3V 176.6271ms,3.3
+ 176.6272ms,0.0V 176.6399ms,0.0
+ 176.6400ms,3.3V 176.6471ms,3.3
+ 176.6472ms,0.0V 176.6599ms,0.0
+ 176.6600ms,3.3V 176.6671ms,3.3
+ 176.6672ms,0.0V 176.6799ms,0.0
+ 176.6800ms,3.3V 176.6871ms,3.3
+ 176.6872ms,0.0V 176.6999ms,0.0
+ 176.7000ms,3.3V 176.7071ms,3.3
+ 176.7072ms,0.0V 176.7199ms,0.0
+ 176.7200ms,3.3V 176.7271ms,3.3
+ 176.7272ms,0.0V 176.7399ms,0.0
+ 176.7400ms,3.3V 176.7471ms,3.3
+ 176.7472ms,0.0V 176.7599ms,0.0
+ 176.7600ms,3.3V 176.7671ms,3.3
+ 176.7672ms,0.0V 176.7799ms,0.0
+ 176.7800ms,3.3V 176.7871ms,3.3
+ 176.7872ms,0.0V 176.7999ms,0.0
+ 176.8000ms,3.3V 176.8071ms,3.3
+ 176.8072ms,0.0V 176.8199ms,0.0
+ 176.8200ms,3.3V 176.8271ms,3.3
+ 176.8272ms,0.0V 176.8399ms,0.0
+ 176.8400ms,3.3V 176.8471ms,3.3
+ 176.8472ms,0.0V 176.8599ms,0.0
+ 176.8600ms,3.3V 176.8671ms,3.3
+ 176.8672ms,0.0V 176.8799ms,0.0
+ 176.8800ms,3.3V 176.8871ms,3.3
+ 176.8872ms,0.0V 176.8999ms,0.0
+ 176.9000ms,3.3V 176.9071ms,3.3
+ 176.9072ms,0.0V 176.9199ms,0.0
+ 176.9200ms,3.3V 176.9271ms,3.3
+ 176.9272ms,0.0V 176.9399ms,0.0
+ 176.9400ms,3.3V 176.9471ms,3.3
+ 176.9472ms,0.0V 176.9599ms,0.0
+ 176.9600ms,3.3V 176.9671ms,3.3
+ 176.9672ms,0.0V 176.9799ms,0.0
+ 176.9800ms,3.3V 176.9871ms,3.3
+ 176.9872ms,0.0V 176.9999ms,0.0
+ 177.0000ms,3.3V 177.0071ms,3.3
+ 177.0072ms,0.0V 177.0199ms,0.0
+ 177.0200ms,3.3V 177.0271ms,3.3
+ 177.0272ms,0.0V 177.0399ms,0.0
+ 177.0400ms,3.3V 177.0471ms,3.3
+ 177.0472ms,0.0V 177.0599ms,0.0
+ 177.0600ms,3.3V 177.0671ms,3.3
+ 177.0672ms,0.0V 177.0799ms,0.0
+ 177.0800ms,3.3V 177.0871ms,3.3
+ 177.0872ms,0.0V 177.0999ms,0.0
+ 177.1000ms,3.3V 177.1071ms,3.3
+ 177.1072ms,0.0V 177.1199ms,0.0
+ 177.1200ms,3.3V 177.1271ms,3.3
+ 177.1272ms,0.0V 177.1399ms,0.0
+ 177.1400ms,3.3V 177.1471ms,3.3
+ 177.1472ms,0.0V 177.1599ms,0.0
+ 177.1600ms,3.3V 177.1671ms,3.3
+ 177.1672ms,0.0V 177.1799ms,0.0
+ 177.1800ms,3.3V 177.1871ms,3.3
+ 177.1872ms,0.0V 177.1999ms,0.0
+ 177.2000ms,3.3V 177.2071ms,3.3
+ 177.2072ms,0.0V 177.2199ms,0.0
+ 177.2200ms,3.3V 177.2271ms,3.3
+ 177.2272ms,0.0V 177.2399ms,0.0
+ 177.2400ms,3.3V 177.2471ms,3.3
+ 177.2472ms,0.0V 177.2599ms,0.0
+ 177.2600ms,3.3V 177.2671ms,3.3
+ 177.2672ms,0.0V 177.2799ms,0.0
+ 177.2800ms,3.3V 177.2871ms,3.3
+ 177.2872ms,0.0V 177.2999ms,0.0
+ 177.3000ms,3.3V 177.3071ms,3.3
+ 177.3072ms,0.0V 177.3199ms,0.0
+ 177.3200ms,3.3V 177.3271ms,3.3
+ 177.3272ms,0.0V 177.3399ms,0.0
+ 177.3400ms,3.3V 177.3471ms,3.3
+ 177.3472ms,0.0V 177.3599ms,0.0
+ 177.3600ms,3.3V 177.3671ms,3.3
+ 177.3672ms,0.0V 177.3799ms,0.0
+ 177.3800ms,3.3V 177.3871ms,3.3
+ 177.3872ms,0.0V 177.3999ms,0.0
+ 177.4000ms,3.3V 177.4071ms,3.3
+ 177.4072ms,0.0V 177.4199ms,0.0
+ 177.4200ms,3.3V 177.4271ms,3.3
+ 177.4272ms,0.0V 177.4399ms,0.0
+ 177.4400ms,3.3V 177.4471ms,3.3
+ 177.4472ms,0.0V 177.4599ms,0.0
+ 177.4600ms,3.3V 177.4671ms,3.3
+ 177.4672ms,0.0V 177.4799ms,0.0
+ 177.4800ms,3.3V 177.4871ms,3.3
+ 177.4872ms,0.0V 177.4999ms,0.0
+ 177.5000ms,3.3V 177.5071ms,3.3
+ 177.5072ms,0.0V 177.5199ms,0.0
+ 177.5200ms,3.3V 177.5271ms,3.3
+ 177.5272ms,0.0V 177.5399ms,0.0
+ 177.5400ms,3.3V 177.5471ms,3.3
+ 177.5472ms,0.0V 177.5599ms,0.0
+ 177.5600ms,3.3V 177.5671ms,3.3
+ 177.5672ms,0.0V 177.5799ms,0.0
+ 177.5800ms,3.3V 177.5871ms,3.3
+ 177.5872ms,0.0V 177.5999ms,0.0
+ 177.6000ms,3.3V 177.6071ms,3.3
+ 177.6072ms,0.0V 177.6199ms,0.0
+ 177.6200ms,3.3V 177.6271ms,3.3
+ 177.6272ms,0.0V 177.6399ms,0.0
+ 177.6400ms,3.3V 177.6471ms,3.3
+ 177.6472ms,0.0V 177.6599ms,0.0
+ 177.6600ms,3.3V 177.6671ms,3.3
+ 177.6672ms,0.0V 177.6799ms,0.0
+ 177.6800ms,3.3V 177.6871ms,3.3
+ 177.6872ms,0.0V 177.6999ms,0.0
+ 177.7000ms,3.3V 177.7071ms,3.3
+ 177.7072ms,0.0V 177.7199ms,0.0
+ 177.7200ms,3.3V 177.7271ms,3.3
+ 177.7272ms,0.0V 177.7399ms,0.0
+ 177.7400ms,3.3V 177.7471ms,3.3
+ 177.7472ms,0.0V 177.7599ms,0.0
+ 177.7600ms,3.3V 177.7671ms,3.3
+ 177.7672ms,0.0V 177.7799ms,0.0
+ 177.7800ms,3.3V 177.7871ms,3.3
+ 177.7872ms,0.0V 177.7999ms,0.0
+ 177.8000ms,3.3V 177.8071ms,3.3
+ 177.8072ms,0.0V 177.8199ms,0.0
+ 177.8200ms,3.3V 177.8271ms,3.3
+ 177.8272ms,0.0V 177.8399ms,0.0
+ 177.8400ms,3.3V 177.8471ms,3.3
+ 177.8472ms,0.0V 177.8599ms,0.0
+ 177.8600ms,3.3V 177.8671ms,3.3
+ 177.8672ms,0.0V 177.8799ms,0.0
+ 177.8800ms,3.3V 177.8871ms,3.3
+ 177.8872ms,0.0V 177.8999ms,0.0
+ 177.9000ms,3.3V 177.9071ms,3.3
+ 177.9072ms,0.0V 177.9199ms,0.0
+ 177.9200ms,3.3V 177.9271ms,3.3
+ 177.9272ms,0.0V 177.9399ms,0.0
+ 177.9400ms,3.3V 177.9471ms,3.3
+ 177.9472ms,0.0V 177.9599ms,0.0
+ 177.9600ms,3.3V 177.9671ms,3.3
+ 177.9672ms,0.0V 177.9799ms,0.0
+ 177.9800ms,3.3V 177.9871ms,3.3
+ 177.9872ms,0.0V 177.9999ms,0.0
+ 178.0000ms,3.3V 178.0071ms,3.3
+ 178.0072ms,0.0V 178.0199ms,0.0
+ 178.0200ms,3.3V 178.0271ms,3.3
+ 178.0272ms,0.0V 178.0399ms,0.0
+ 178.0400ms,3.3V 178.0471ms,3.3
+ 178.0472ms,0.0V 178.0599ms,0.0
+ 178.0600ms,3.3V 178.0671ms,3.3
+ 178.0672ms,0.0V 178.0799ms,0.0
+ 178.0800ms,3.3V 178.0871ms,3.3
+ 178.0872ms,0.0V 178.0999ms,0.0
+ 178.1000ms,3.3V 178.1071ms,3.3
+ 178.1072ms,0.0V 178.1199ms,0.0
+ 178.1200ms,3.3V 178.1271ms,3.3
+ 178.1272ms,0.0V 178.1399ms,0.0
+ 178.1400ms,3.3V 178.1471ms,3.3
+ 178.1472ms,0.0V 178.1599ms,0.0
+ 178.1600ms,3.3V 178.1671ms,3.3
+ 178.1672ms,0.0V 178.1799ms,0.0
+ 178.1800ms,3.3V 178.1871ms,3.3
+ 178.1872ms,0.0V 178.1999ms,0.0
+ 178.2000ms,3.3V 178.2071ms,3.3
+ 178.2072ms,0.0V 178.2199ms,0.0
+ 178.2200ms,3.3V 178.2271ms,3.3
+ 178.2272ms,0.0V 178.2399ms,0.0
+ 178.2400ms,3.3V 178.2471ms,3.3
+ 178.2472ms,0.0V 178.2599ms,0.0
+ 178.2600ms,3.3V 178.2671ms,3.3
+ 178.2672ms,0.0V 178.2799ms,0.0
+ 178.2800ms,3.3V 178.2871ms,3.3
+ 178.2872ms,0.0V 178.2999ms,0.0
+ 178.3000ms,3.3V 178.3071ms,3.3
+ 178.3072ms,0.0V 178.3199ms,0.0
+ 178.3200ms,3.3V 178.3271ms,3.3
+ 178.3272ms,0.0V 178.3399ms,0.0
+ 178.3400ms,3.3V 178.3471ms,3.3
+ 178.3472ms,0.0V 178.3599ms,0.0
+ 178.3600ms,3.3V 178.3671ms,3.3
+ 178.3672ms,0.0V 178.3799ms,0.0
+ 178.3800ms,3.3V 178.3871ms,3.3
+ 178.3872ms,0.0V 178.3999ms,0.0
+ 178.4000ms,3.3V 178.4071ms,3.3
+ 178.4072ms,0.0V 178.4199ms,0.0
+ 178.4200ms,3.3V 178.4271ms,3.3
+ 178.4272ms,0.0V 178.4399ms,0.0
+ 178.4400ms,3.3V 178.4471ms,3.3
+ 178.4472ms,0.0V 178.4599ms,0.0
+ 178.4600ms,3.3V 178.4671ms,3.3
+ 178.4672ms,0.0V 178.4799ms,0.0
+ 178.4800ms,3.3V 178.4871ms,3.3
+ 178.4872ms,0.0V 178.4999ms,0.0
+ 178.5000ms,3.3V 178.5071ms,3.3
+ 178.5072ms,0.0V 178.5199ms,0.0
+ 178.5200ms,3.3V 178.5271ms,3.3
+ 178.5272ms,0.0V 178.5399ms,0.0
+ 178.5400ms,3.3V 178.5471ms,3.3
+ 178.5472ms,0.0V 178.5599ms,0.0
+ 178.5600ms,3.3V 178.5671ms,3.3
+ 178.5672ms,0.0V 178.5799ms,0.0
+ 178.5800ms,3.3V 178.5871ms,3.3
+ 178.5872ms,0.0V 178.5999ms,0.0
+ 178.6000ms,3.3V 178.6071ms,3.3
+ 178.6072ms,0.0V 178.6199ms,0.0
+ 178.6200ms,3.3V 178.6271ms,3.3
+ 178.6272ms,0.0V 178.6399ms,0.0
+ 178.6400ms,3.3V 178.6471ms,3.3
+ 178.6472ms,0.0V 178.6599ms,0.0
+ 178.6600ms,3.3V 178.6671ms,3.3
+ 178.6672ms,0.0V 178.6799ms,0.0
+ 178.6800ms,3.3V 178.6871ms,3.3
+ 178.6872ms,0.0V 178.6999ms,0.0
+ 178.7000ms,3.3V 178.7071ms,3.3
+ 178.7072ms,0.0V 178.7199ms,0.0
+ 178.7200ms,3.3V 178.7271ms,3.3
+ 178.7272ms,0.0V 178.7399ms,0.0
+ 178.7400ms,3.3V 178.7471ms,3.3
+ 178.7472ms,0.0V 178.7599ms,0.0
+ 178.7600ms,3.3V 178.7671ms,3.3
+ 178.7672ms,0.0V 178.7799ms,0.0
+ 178.7800ms,3.3V 178.7871ms,3.3
+ 178.7872ms,0.0V 178.7999ms,0.0
+ 178.8000ms,3.3V 178.8071ms,3.3
+ 178.8072ms,0.0V 178.8199ms,0.0
+ 178.8200ms,3.3V 178.8271ms,3.3
+ 178.8272ms,0.0V 178.8399ms,0.0
+ 178.8400ms,3.3V 178.8471ms,3.3
+ 178.8472ms,0.0V 178.8599ms,0.0
+ 178.8600ms,3.3V 178.8671ms,3.3
+ 178.8672ms,0.0V 178.8799ms,0.0
+ 178.8800ms,3.3V 178.8871ms,3.3
+ 178.8872ms,0.0V 178.8999ms,0.0
+ 178.9000ms,3.3V 178.9071ms,3.3
+ 178.9072ms,0.0V 178.9199ms,0.0
+ 178.9200ms,3.3V 178.9271ms,3.3
+ 178.9272ms,0.0V 178.9399ms,0.0
+ 178.9400ms,3.3V 178.9471ms,3.3
+ 178.9472ms,0.0V 178.9599ms,0.0
+ 178.9600ms,3.3V 178.9671ms,3.3
+ 178.9672ms,0.0V 178.9799ms,0.0
+ 178.9800ms,3.3V 178.9871ms,3.3
+ 178.9872ms,0.0V 178.9999ms,0.0
+ 179.0000ms,3.3V 179.0071ms,3.3
+ 179.0072ms,0.0V 179.0199ms,0.0
+ 179.0200ms,3.3V 179.0271ms,3.3
+ 179.0272ms,0.0V 179.0399ms,0.0
+ 179.0400ms,3.3V 179.0471ms,3.3
+ 179.0472ms,0.0V 179.0599ms,0.0
+ 179.0600ms,3.3V 179.0671ms,3.3
+ 179.0672ms,0.0V 179.0799ms,0.0
+ 179.0800ms,3.3V 179.0871ms,3.3
+ 179.0872ms,0.0V 179.0999ms,0.0
+ 179.1000ms,3.3V 179.1071ms,3.3
+ 179.1072ms,0.0V 179.1199ms,0.0
+ 179.1200ms,3.3V 179.1271ms,3.3
+ 179.1272ms,0.0V 179.1399ms,0.0
+ 179.1400ms,3.3V 179.1471ms,3.3
+ 179.1472ms,0.0V 179.1599ms,0.0
+ 179.1600ms,3.3V 179.1671ms,3.3
+ 179.1672ms,0.0V 179.1799ms,0.0
+ 179.1800ms,3.3V 179.1871ms,3.3
+ 179.1872ms,0.0V 179.1999ms,0.0
+ 179.2000ms,3.3V 179.2071ms,3.3
+ 179.2072ms,0.0V 179.2199ms,0.0
+ 179.2200ms,3.3V 179.2271ms,3.3
+ 179.2272ms,0.0V 179.2399ms,0.0
+ 179.2400ms,3.3V 179.2471ms,3.3
+ 179.2472ms,0.0V 179.2599ms,0.0
+ 179.2600ms,3.3V 179.2671ms,3.3
+ 179.2672ms,0.0V 179.2799ms,0.0
+ 179.2800ms,3.3V 179.2871ms,3.3
+ 179.2872ms,0.0V 179.2999ms,0.0
+ 179.3000ms,3.3V 179.3071ms,3.3
+ 179.3072ms,0.0V 179.3199ms,0.0
+ 179.3200ms,3.3V 179.3271ms,3.3
+ 179.3272ms,0.0V 179.3399ms,0.0
+ 179.3400ms,3.3V 179.3471ms,3.3
+ 179.3472ms,0.0V 179.3599ms,0.0
+ 179.3600ms,3.3V 179.3671ms,3.3
+ 179.3672ms,0.0V 179.3799ms,0.0
+ 179.3800ms,3.3V 179.3871ms,3.3
+ 179.3872ms,0.0V 179.3999ms,0.0
+ 179.4000ms,3.3V 179.4071ms,3.3
+ 179.4072ms,0.0V 179.4199ms,0.0
+ 179.4200ms,3.3V 179.4271ms,3.3
+ 179.4272ms,0.0V 179.4399ms,0.0
+ 179.4400ms,3.3V 179.4471ms,3.3
+ 179.4472ms,0.0V 179.4599ms,0.0
+ 179.4600ms,3.3V 179.4671ms,3.3
+ 179.4672ms,0.0V 179.4799ms,0.0
+ 179.4800ms,3.3V 179.4871ms,3.3
+ 179.4872ms,0.0V 179.4999ms,0.0
+ 179.5000ms,3.3V 179.5071ms,3.3
+ 179.5072ms,0.0V 179.5199ms,0.0
+ 179.5200ms,3.3V 179.5271ms,3.3
+ 179.5272ms,0.0V 179.5399ms,0.0
+ 179.5400ms,3.3V 179.5471ms,3.3
+ 179.5472ms,0.0V 179.5599ms,0.0
+ 179.5600ms,3.3V 179.5671ms,3.3
+ 179.5672ms,0.0V 179.5799ms,0.0
+ 179.5800ms,3.3V 179.5871ms,3.3
+ 179.5872ms,0.0V 179.5999ms,0.0
+ 179.6000ms,3.3V 179.6071ms,3.3
+ 179.6072ms,0.0V 179.6199ms,0.0
+ 179.6200ms,3.3V 179.6271ms,3.3
+ 179.6272ms,0.0V 179.6399ms,0.0
+ 179.6400ms,3.3V 179.6471ms,3.3
+ 179.6472ms,0.0V 179.6599ms,0.0
+ 179.6600ms,3.3V 179.6671ms,3.3
+ 179.6672ms,0.0V 179.6799ms,0.0
+ 179.6800ms,3.3V 179.6871ms,3.3
+ 179.6872ms,0.0V 179.6999ms,0.0
+ 179.7000ms,3.3V 179.7071ms,3.3
+ 179.7072ms,0.0V 179.7199ms,0.0
+ 179.7200ms,3.3V 179.7271ms,3.3
+ 179.7272ms,0.0V 179.7399ms,0.0
+ 179.7400ms,3.3V 179.7471ms,3.3
+ 179.7472ms,0.0V 179.7599ms,0.0
+ 179.7600ms,3.3V 179.7671ms,3.3
+ 179.7672ms,0.0V 179.7799ms,0.0
+ 179.7800ms,3.3V 179.7871ms,3.3
+ 179.7872ms,0.0V 179.7999ms,0.0
+ 179.8000ms,3.3V 179.8071ms,3.3
+ 179.8072ms,0.0V 179.8199ms,0.0
+ 179.8200ms,3.3V 179.8271ms,3.3
+ 179.8272ms,0.0V 179.8399ms,0.0
+ 179.8400ms,3.3V 179.8471ms,3.3
+ 179.8472ms,0.0V 179.8599ms,0.0
+ 179.8600ms,3.3V 179.8671ms,3.3
+ 179.8672ms,0.0V 179.8799ms,0.0
+ 179.8800ms,3.3V 179.8871ms,3.3
+ 179.8872ms,0.0V 179.8999ms,0.0
+ 179.9000ms,3.3V 179.9071ms,3.3
+ 179.9072ms,0.0V 179.9199ms,0.0
+ 179.9200ms,3.3V 179.9271ms,3.3
+ 179.9272ms,0.0V 179.9399ms,0.0
+ 179.9400ms,3.3V 179.9471ms,3.3
+ 179.9472ms,0.0V 179.9599ms,0.0
+ 179.9600ms,3.3V 179.9671ms,3.3
+ 179.9672ms,0.0V 179.9799ms,0.0
+ 179.9800ms,3.3V 179.9871ms,3.3
+ 179.9872ms,0.0V 179.9999ms,0.0
+ 180.0000ms,3.3V 180.0071ms,3.3
+ 180.0072ms,0.0V 180.0199ms,0.0
+ 180.0200ms,3.3V 180.0271ms,3.3
+ 180.0272ms,0.0V 180.0399ms,0.0
+ 180.0400ms,3.3V 180.0471ms,3.3
+ 180.0472ms,0.0V 180.0599ms,0.0
+ 180.0600ms,3.3V 180.0671ms,3.3
+ 180.0672ms,0.0V 180.0799ms,0.0
+ 180.0800ms,3.3V 180.0871ms,3.3
+ 180.0872ms,0.0V 180.0999ms,0.0
+ 180.1000ms,3.3V 180.1071ms,3.3
+ 180.1072ms,0.0V 180.1199ms,0.0
+ 180.1200ms,3.3V 180.1271ms,3.3
+ 180.1272ms,0.0V 180.1399ms,0.0
+ 180.1400ms,3.3V 180.1471ms,3.3
+ 180.1472ms,0.0V 180.1599ms,0.0
+ 180.1600ms,3.3V 180.1671ms,3.3
+ 180.1672ms,0.0V 180.1799ms,0.0
+ 180.1800ms,3.3V 180.1871ms,3.3
+ 180.1872ms,0.0V 180.1999ms,0.0
+ 180.2000ms,3.3V 180.2071ms,3.3
+ 180.2072ms,0.0V 180.2199ms,0.0
+ 180.2200ms,3.3V 180.2271ms,3.3
+ 180.2272ms,0.0V 180.2399ms,0.0
+ 180.2400ms,3.3V 180.2471ms,3.3
+ 180.2472ms,0.0V 180.2599ms,0.0
+ 180.2600ms,3.3V 180.2671ms,3.3
+ 180.2672ms,0.0V 180.2799ms,0.0
+ 180.2800ms,3.3V 180.2871ms,3.3
+ 180.2872ms,0.0V 180.2999ms,0.0
+ 180.3000ms,3.3V 180.3071ms,3.3
+ 180.3072ms,0.0V 180.3199ms,0.0
+ 180.3200ms,3.3V 180.3271ms,3.3
+ 180.3272ms,0.0V 180.3399ms,0.0
+ 180.3400ms,3.3V 180.3471ms,3.3
+ 180.3472ms,0.0V 180.3599ms,0.0
+ 180.3600ms,3.3V 180.3673ms,3.3
+ 180.3674ms,0.0V 180.3799ms,0.0
+ 180.3800ms,3.3V 180.3873ms,3.3
+ 180.3874ms,0.0V 180.3999ms,0.0
+ 180.4000ms,3.3V 180.4073ms,3.3
+ 180.4074ms,0.0V 180.4199ms,0.0
+ 180.4200ms,3.3V 180.4273ms,3.3
+ 180.4274ms,0.0V 180.4399ms,0.0
+ 180.4400ms,3.3V 180.4473ms,3.3
+ 180.4474ms,0.0V 180.4599ms,0.0
+ 180.4600ms,3.3V 180.4673ms,3.3
+ 180.4674ms,0.0V 180.4799ms,0.0
+ 180.4800ms,3.3V 180.4873ms,3.3
+ 180.4874ms,0.0V 180.4999ms,0.0
+ 180.5000ms,3.3V 180.5073ms,3.3
+ 180.5074ms,0.0V 180.5199ms,0.0
+ 180.5200ms,3.3V 180.5273ms,3.3
+ 180.5274ms,0.0V 180.5399ms,0.0
+ 180.5400ms,3.3V 180.5473ms,3.3
+ 180.5474ms,0.0V 180.5599ms,0.0
+ 180.5600ms,3.3V 180.5673ms,3.3
+ 180.5674ms,0.0V 180.5799ms,0.0
+ 180.5800ms,3.3V 180.5873ms,3.3
+ 180.5874ms,0.0V 180.5999ms,0.0
+ 180.6000ms,3.3V 180.6073ms,3.3
+ 180.6074ms,0.0V 180.6199ms,0.0
+ 180.6200ms,3.3V 180.6273ms,3.3
+ 180.6274ms,0.0V 180.6399ms,0.0
+ 180.6400ms,3.3V 180.6473ms,3.3
+ 180.6474ms,0.0V 180.6599ms,0.0
+ 180.6600ms,3.3V 180.6673ms,3.3
+ 180.6674ms,0.0V 180.6799ms,0.0
+ 180.6800ms,3.3V 180.6873ms,3.3
+ 180.6874ms,0.0V 180.6999ms,0.0
+ 180.7000ms,3.3V 180.7073ms,3.3
+ 180.7074ms,0.0V 180.7199ms,0.0
+ 180.7200ms,3.3V 180.7273ms,3.3
+ 180.7274ms,0.0V 180.7399ms,0.0
+ 180.7400ms,3.3V 180.7473ms,3.3
+ 180.7474ms,0.0V 180.7599ms,0.0
+ 180.7600ms,3.3V 180.7673ms,3.3
+ 180.7674ms,0.0V 180.7799ms,0.0
+ 180.7800ms,3.3V 180.7873ms,3.3
+ 180.7874ms,0.0V 180.7999ms,0.0
+ 180.8000ms,3.3V 180.8073ms,3.3
+ 180.8074ms,0.0V 180.8199ms,0.0
+ 180.8200ms,3.3V 180.8273ms,3.3
+ 180.8274ms,0.0V 180.8399ms,0.0
+ 180.8400ms,3.3V 180.8473ms,3.3
+ 180.8474ms,0.0V 180.8599ms,0.0
+ 180.8600ms,3.3V 180.8673ms,3.3
+ 180.8674ms,0.0V 180.8799ms,0.0
+ 180.8800ms,3.3V 180.8873ms,3.3
+ 180.8874ms,0.0V 180.8999ms,0.0
+ 180.9000ms,3.3V 180.9073ms,3.3
+ 180.9074ms,0.0V 180.9199ms,0.0
+ 180.9200ms,3.3V 180.9273ms,3.3
+ 180.9274ms,0.0V 180.9399ms,0.0
+ 180.9400ms,3.3V 180.9473ms,3.3
+ 180.9474ms,0.0V 180.9599ms,0.0
+ 180.9600ms,3.3V 180.9673ms,3.3
+ 180.9674ms,0.0V 180.9799ms,0.0
+ 180.9800ms,3.3V 180.9873ms,3.3
+ 180.9874ms,0.0V 180.9999ms,0.0
+ 181.0000ms,3.3V 181.0073ms,3.3
+ 181.0074ms,0.0V 181.0199ms,0.0
+ 181.0200ms,3.3V 181.0273ms,3.3
+ 181.0274ms,0.0V 181.0399ms,0.0
+ 181.0400ms,3.3V 181.0473ms,3.3
+ 181.0474ms,0.0V 181.0599ms,0.0
+ 181.0600ms,3.3V 181.0673ms,3.3
+ 181.0674ms,0.0V 181.0799ms,0.0
+ 181.0800ms,3.3V 181.0873ms,3.3
+ 181.0874ms,0.0V 181.0999ms,0.0
+ 181.1000ms,3.3V 181.1073ms,3.3
+ 181.1074ms,0.0V 181.1199ms,0.0
+ 181.1200ms,3.3V 181.1273ms,3.3
+ 181.1274ms,0.0V 181.1399ms,0.0
+ 181.1400ms,3.3V 181.1473ms,3.3
+ 181.1474ms,0.0V 181.1599ms,0.0
+ 181.1600ms,3.3V 181.1673ms,3.3
+ 181.1674ms,0.0V 181.1799ms,0.0
+ 181.1800ms,3.3V 181.1873ms,3.3
+ 181.1874ms,0.0V 181.1999ms,0.0
+ 181.2000ms,3.3V 181.2073ms,3.3
+ 181.2074ms,0.0V 181.2199ms,0.0
+ 181.2200ms,3.3V 181.2273ms,3.3
+ 181.2274ms,0.0V 181.2399ms,0.0
+ 181.2400ms,3.3V 181.2473ms,3.3
+ 181.2474ms,0.0V 181.2599ms,0.0
+ 181.2600ms,3.3V 181.2673ms,3.3
+ 181.2674ms,0.0V 181.2799ms,0.0
+ 181.2800ms,3.3V 181.2873ms,3.3
+ 181.2874ms,0.0V 181.2999ms,0.0
+ 181.3000ms,3.3V 181.3073ms,3.3
+ 181.3074ms,0.0V 181.3199ms,0.0
+ 181.3200ms,3.3V 181.3273ms,3.3
+ 181.3274ms,0.0V 181.3399ms,0.0
+ 181.3400ms,3.3V 181.3473ms,3.3
+ 181.3474ms,0.0V 181.3599ms,0.0
+ 181.3600ms,3.3V 181.3673ms,3.3
+ 181.3674ms,0.0V 181.3799ms,0.0
+ 181.3800ms,3.3V 181.3873ms,3.3
+ 181.3874ms,0.0V 181.3999ms,0.0
+ 181.4000ms,3.3V 181.4073ms,3.3
+ 181.4074ms,0.0V 181.4199ms,0.0
+ 181.4200ms,3.3V 181.4273ms,3.3
+ 181.4274ms,0.0V 181.4399ms,0.0
+ 181.4400ms,3.3V 181.4473ms,3.3
+ 181.4474ms,0.0V 181.4599ms,0.0
+ 181.4600ms,3.3V 181.4673ms,3.3
+ 181.4674ms,0.0V 181.4799ms,0.0
+ 181.4800ms,3.3V 181.4873ms,3.3
+ 181.4874ms,0.0V 181.4999ms,0.0
+ 181.5000ms,3.3V 181.5073ms,3.3
+ 181.5074ms,0.0V 181.5199ms,0.0
+ 181.5200ms,3.3V 181.5273ms,3.3
+ 181.5274ms,0.0V 181.5399ms,0.0
+ 181.5400ms,3.3V 181.5473ms,3.3
+ 181.5474ms,0.0V 181.5599ms,0.0
+ 181.5600ms,3.3V 181.5673ms,3.3
+ 181.5674ms,0.0V 181.5799ms,0.0
+ 181.5800ms,3.3V 181.5873ms,3.3
+ 181.5874ms,0.0V 181.5999ms,0.0
+ 181.6000ms,3.3V 181.6073ms,3.3
+ 181.6074ms,0.0V 181.6199ms,0.0
+ 181.6200ms,3.3V 181.6273ms,3.3
+ 181.6274ms,0.0V 181.6399ms,0.0
+ 181.6400ms,3.3V 181.6473ms,3.3
+ 181.6474ms,0.0V 181.6599ms,0.0
+ 181.6600ms,3.3V 181.6673ms,3.3
+ 181.6674ms,0.0V 181.6799ms,0.0
+ 181.6800ms,3.3V 181.6873ms,3.3
+ 181.6874ms,0.0V 181.6999ms,0.0
+ 181.7000ms,3.3V 181.7073ms,3.3
+ 181.7074ms,0.0V 181.7199ms,0.0
+ 181.7200ms,3.3V 181.7273ms,3.3
+ 181.7274ms,0.0V 181.7399ms,0.0
+ 181.7400ms,3.3V 181.7473ms,3.3
+ 181.7474ms,0.0V 181.7599ms,0.0
+ 181.7600ms,3.3V 181.7673ms,3.3
+ 181.7674ms,0.0V 181.7799ms,0.0
+ 181.7800ms,3.3V 181.7873ms,3.3
+ 181.7874ms,0.0V 181.7999ms,0.0
+ 181.8000ms,3.3V 181.8073ms,3.3
+ 181.8074ms,0.0V 181.8199ms,0.0
+ 181.8200ms,3.3V 181.8273ms,3.3
+ 181.8274ms,0.0V 181.8399ms,0.0
+ 181.8400ms,3.3V 181.8473ms,3.3
+ 181.8474ms,0.0V 181.8599ms,0.0
+ 181.8600ms,3.3V 181.8673ms,3.3
+ 181.8674ms,0.0V 181.8799ms,0.0
+ 181.8800ms,3.3V 181.8873ms,3.3
+ 181.8874ms,0.0V 181.8999ms,0.0
+ 181.9000ms,3.3V 181.9073ms,3.3
+ 181.9074ms,0.0V 181.9199ms,0.0
+ 181.9200ms,3.3V 181.9273ms,3.3
+ 181.9274ms,0.0V 181.9399ms,0.0
+ 181.9400ms,3.3V 181.9473ms,3.3
+ 181.9474ms,0.0V 181.9599ms,0.0
+ 181.9600ms,3.3V 181.9673ms,3.3
+ 181.9674ms,0.0V 181.9799ms,0.0
+ 181.9800ms,3.3V 181.9873ms,3.3
+ 181.9874ms,0.0V 181.9999ms,0.0
+ 182.0000ms,3.3V 182.0073ms,3.3
+ 182.0074ms,0.0V 182.0199ms,0.0
+ 182.0200ms,3.3V 182.0273ms,3.3
+ 182.0274ms,0.0V 182.0399ms,0.0
+ 182.0400ms,3.3V 182.0473ms,3.3
+ 182.0474ms,0.0V 182.0599ms,0.0
+ 182.0600ms,3.3V 182.0673ms,3.3
+ 182.0674ms,0.0V 182.0799ms,0.0
+ 182.0800ms,3.3V 182.0873ms,3.3
+ 182.0874ms,0.0V 182.0999ms,0.0
+ 182.1000ms,3.3V 182.1073ms,3.3
+ 182.1074ms,0.0V 182.1199ms,0.0
+ 182.1200ms,3.3V 182.1273ms,3.3
+ 182.1274ms,0.0V 182.1399ms,0.0
+ 182.1400ms,3.3V 182.1473ms,3.3
+ 182.1474ms,0.0V 182.1599ms,0.0
+ 182.1600ms,3.3V 182.1673ms,3.3
+ 182.1674ms,0.0V 182.1799ms,0.0
+ 182.1800ms,3.3V 182.1873ms,3.3
+ 182.1874ms,0.0V 182.1999ms,0.0
+ 182.2000ms,3.3V 182.2073ms,3.3
+ 182.2074ms,0.0V 182.2199ms,0.0
+ 182.2200ms,3.3V 182.2273ms,3.3
+ 182.2274ms,0.0V 182.2399ms,0.0
+ 182.2400ms,3.3V 182.2473ms,3.3
+ 182.2474ms,0.0V 182.2599ms,0.0
+ 182.2600ms,3.3V 182.2673ms,3.3
+ 182.2674ms,0.0V 182.2799ms,0.0
+ 182.2800ms,3.3V 182.2873ms,3.3
+ 182.2874ms,0.0V 182.2999ms,0.0
+ 182.3000ms,3.3V 182.3073ms,3.3
+ 182.3074ms,0.0V 182.3199ms,0.0
+ 182.3200ms,3.3V 182.3273ms,3.3
+ 182.3274ms,0.0V 182.3399ms,0.0
+ 182.3400ms,3.3V 182.3473ms,3.3
+ 182.3474ms,0.0V 182.3599ms,0.0
+ 182.3600ms,3.3V 182.3673ms,3.3
+ 182.3674ms,0.0V 182.3799ms,0.0
+ 182.3800ms,3.3V 182.3873ms,3.3
+ 182.3874ms,0.0V 182.3999ms,0.0
+ 182.4000ms,3.3V 182.4073ms,3.3
+ 182.4074ms,0.0V 182.4199ms,0.0
+ 182.4200ms,3.3V 182.4273ms,3.3
+ 182.4274ms,0.0V 182.4399ms,0.0
+ 182.4400ms,3.3V 182.4473ms,3.3
+ 182.4474ms,0.0V 182.4599ms,0.0
+ 182.4600ms,3.3V 182.4673ms,3.3
+ 182.4674ms,0.0V 182.4799ms,0.0
+ 182.4800ms,3.3V 182.4873ms,3.3
+ 182.4874ms,0.0V 182.4999ms,0.0
+ 182.5000ms,3.3V 182.5073ms,3.3
+ 182.5074ms,0.0V 182.5199ms,0.0
+ 182.5200ms,3.3V 182.5273ms,3.3
+ 182.5274ms,0.0V 182.5399ms,0.0
+ 182.5400ms,3.3V 182.5473ms,3.3
+ 182.5474ms,0.0V 182.5599ms,0.0
+ 182.5600ms,3.3V 182.5673ms,3.3
+ 182.5674ms,0.0V 182.5799ms,0.0
+ 182.5800ms,3.3V 182.5873ms,3.3
+ 182.5874ms,0.0V 182.5999ms,0.0
+ 182.6000ms,3.3V 182.6073ms,3.3
+ 182.6074ms,0.0V 182.6199ms,0.0
+ 182.6200ms,3.3V 182.6273ms,3.3
+ 182.6274ms,0.0V 182.6399ms,0.0
+ 182.6400ms,3.3V 182.6473ms,3.3
+ 182.6474ms,0.0V 182.6599ms,0.0
+ 182.6600ms,3.3V 182.6673ms,3.3
+ 182.6674ms,0.0V 182.6799ms,0.0
+ 182.6800ms,3.3V 182.6873ms,3.3
+ 182.6874ms,0.0V 182.6999ms,0.0
+ 182.7000ms,3.3V 182.7073ms,3.3
+ 182.7074ms,0.0V 182.7199ms,0.0
+ 182.7200ms,3.3V 182.7273ms,3.3
+ 182.7274ms,0.0V 182.7399ms,0.0
+ 182.7400ms,3.3V 182.7473ms,3.3
+ 182.7474ms,0.0V 182.7599ms,0.0
+ 182.7600ms,3.3V 182.7673ms,3.3
+ 182.7674ms,0.0V 182.7799ms,0.0
+ 182.7800ms,3.3V 182.7873ms,3.3
+ 182.7874ms,0.0V 182.7999ms,0.0
+ 182.8000ms,3.3V 182.8073ms,3.3
+ 182.8074ms,0.0V 182.8199ms,0.0
+ 182.8200ms,3.3V 182.8273ms,3.3
+ 182.8274ms,0.0V 182.8399ms,0.0
+ 182.8400ms,3.3V 182.8473ms,3.3
+ 182.8474ms,0.0V 182.8599ms,0.0
+ 182.8600ms,3.3V 182.8673ms,3.3
+ 182.8674ms,0.0V 182.8799ms,0.0
+ 182.8800ms,3.3V 182.8873ms,3.3
+ 182.8874ms,0.0V 182.8999ms,0.0
+ 182.9000ms,3.3V 182.9073ms,3.3
+ 182.9074ms,0.0V 182.9199ms,0.0
+ 182.9200ms,3.3V 182.9273ms,3.3
+ 182.9274ms,0.0V 182.9399ms,0.0
+ 182.9400ms,3.3V 182.9473ms,3.3
+ 182.9474ms,0.0V 182.9599ms,0.0
+ 182.9600ms,3.3V 182.9673ms,3.3
+ 182.9674ms,0.0V 182.9799ms,0.0
+ 182.9800ms,3.3V 182.9873ms,3.3
+ 182.9874ms,0.0V 182.9999ms,0.0
+ 183.0000ms,3.3V 183.0073ms,3.3
+ 183.0074ms,0.0V 183.0199ms,0.0
+ 183.0200ms,3.3V 183.0273ms,3.3
+ 183.0274ms,0.0V 183.0399ms,0.0
+ 183.0400ms,3.3V 183.0473ms,3.3
+ 183.0474ms,0.0V 183.0599ms,0.0
+ 183.0600ms,3.3V 183.0673ms,3.3
+ 183.0674ms,0.0V 183.0799ms,0.0
+ 183.0800ms,3.3V 183.0873ms,3.3
+ 183.0874ms,0.0V 183.0999ms,0.0
+ 183.1000ms,3.3V 183.1073ms,3.3
+ 183.1074ms,0.0V 183.1199ms,0.0
+ 183.1200ms,3.3V 183.1273ms,3.3
+ 183.1274ms,0.0V 183.1399ms,0.0
+ 183.1400ms,3.3V 183.1473ms,3.3
+ 183.1474ms,0.0V 183.1599ms,0.0
+ 183.1600ms,3.3V 183.1673ms,3.3
+ 183.1674ms,0.0V 183.1799ms,0.0
+ 183.1800ms,3.3V 183.1873ms,3.3
+ 183.1874ms,0.0V 183.1999ms,0.0
+ 183.2000ms,3.3V 183.2073ms,3.3
+ 183.2074ms,0.0V 183.2199ms,0.0
+ 183.2200ms,3.3V 183.2273ms,3.3
+ 183.2274ms,0.0V 183.2399ms,0.0
+ 183.2400ms,3.3V 183.2473ms,3.3
+ 183.2474ms,0.0V 183.2599ms,0.0
+ 183.2600ms,3.3V 183.2673ms,3.3
+ 183.2674ms,0.0V 183.2799ms,0.0
+ 183.2800ms,3.3V 183.2873ms,3.3
+ 183.2874ms,0.0V 183.2999ms,0.0
+ 183.3000ms,3.3V 183.3073ms,3.3
+ 183.3074ms,0.0V 183.3199ms,0.0
+ 183.3200ms,3.3V 183.3273ms,3.3
+ 183.3274ms,0.0V 183.3399ms,0.0
+ 183.3400ms,3.3V 183.3473ms,3.3
+ 183.3474ms,0.0V 183.3599ms,0.0
+ 183.3600ms,3.3V 183.3673ms,3.3
+ 183.3674ms,0.0V 183.3799ms,0.0
+ 183.3800ms,3.3V 183.3873ms,3.3
+ 183.3874ms,0.0V 183.3999ms,0.0
+ 183.4000ms,3.3V 183.4073ms,3.3
+ 183.4074ms,0.0V 183.4199ms,0.0
+ 183.4200ms,3.3V 183.4273ms,3.3
+ 183.4274ms,0.0V 183.4399ms,0.0
+ 183.4400ms,3.3V 183.4473ms,3.3
+ 183.4474ms,0.0V 183.4599ms,0.0
+ 183.4600ms,3.3V 183.4673ms,3.3
+ 183.4674ms,0.0V 183.4799ms,0.0
+ 183.4800ms,3.3V 183.4873ms,3.3
+ 183.4874ms,0.0V 183.4999ms,0.0
+ 183.5000ms,3.3V 183.5073ms,3.3
+ 183.5074ms,0.0V 183.5199ms,0.0
+ 183.5200ms,3.3V 183.5273ms,3.3
+ 183.5274ms,0.0V 183.5399ms,0.0
+ 183.5400ms,3.3V 183.5473ms,3.3
+ 183.5474ms,0.0V 183.5599ms,0.0
+ 183.5600ms,3.3V 183.5673ms,3.3
+ 183.5674ms,0.0V 183.5799ms,0.0
+ 183.5800ms,3.3V 183.5873ms,3.3
+ 183.5874ms,0.0V 183.5999ms,0.0
+ 183.6000ms,3.3V 183.6073ms,3.3
+ 183.6074ms,0.0V 183.6199ms,0.0
+ 183.6200ms,3.3V 183.6273ms,3.3
+ 183.6274ms,0.0V 183.6399ms,0.0
+ 183.6400ms,3.3V 183.6473ms,3.3
+ 183.6474ms,0.0V 183.6599ms,0.0
+ 183.6600ms,3.3V 183.6673ms,3.3
+ 183.6674ms,0.0V 183.6799ms,0.0
+ 183.6800ms,3.3V 183.6873ms,3.3
+ 183.6874ms,0.0V 183.6999ms,0.0
+ 183.7000ms,3.3V 183.7073ms,3.3
+ 183.7074ms,0.0V 183.7199ms,0.0
+ 183.7200ms,3.3V 183.7273ms,3.3
+ 183.7274ms,0.0V 183.7399ms,0.0
+ 183.7400ms,3.3V 183.7473ms,3.3
+ 183.7474ms,0.0V 183.7599ms,0.0
+ 183.7600ms,3.3V 183.7673ms,3.3
+ 183.7674ms,0.0V 183.7799ms,0.0
+ 183.7800ms,3.3V 183.7873ms,3.3
+ 183.7874ms,0.0V 183.7999ms,0.0
+ 183.8000ms,3.3V 183.8073ms,3.3
+ 183.8074ms,0.0V 183.8199ms,0.0
+ 183.8200ms,3.3V 183.8273ms,3.3
+ 183.8274ms,0.0V 183.8399ms,0.0
+ 183.8400ms,3.3V 183.8473ms,3.3
+ 183.8474ms,0.0V 183.8599ms,0.0
+ 183.8600ms,3.3V 183.8673ms,3.3
+ 183.8674ms,0.0V 183.8799ms,0.0
+ 183.8800ms,3.3V 183.8873ms,3.3
+ 183.8874ms,0.0V 183.8999ms,0.0
+ 183.9000ms,3.3V 183.9073ms,3.3
+ 183.9074ms,0.0V 183.9199ms,0.0
+ 183.9200ms,3.3V 183.9273ms,3.3
+ 183.9274ms,0.0V 183.9399ms,0.0
+ 183.9400ms,3.3V 183.9473ms,3.3
+ 183.9474ms,0.0V 183.9599ms,0.0
+ 183.9600ms,3.3V 183.9673ms,3.3
+ 183.9674ms,0.0V 183.9799ms,0.0
+ 183.9800ms,3.3V 183.9873ms,3.3
+ 183.9874ms,0.0V 183.9999ms,0.0
+ 184.0000ms,3.3V 184.0073ms,3.3
+ 184.0074ms,0.0V 184.0199ms,0.0
+ 184.0200ms,3.3V 184.0273ms,3.3
+ 184.0274ms,0.0V 184.0399ms,0.0
+ 184.0400ms,3.3V 184.0473ms,3.3
+ 184.0474ms,0.0V 184.0599ms,0.0
+ 184.0600ms,3.3V 184.0673ms,3.3
+ 184.0674ms,0.0V 184.0799ms,0.0
+ 184.0800ms,3.3V 184.0873ms,3.3
+ 184.0874ms,0.0V 184.0999ms,0.0
+ 184.1000ms,3.3V 184.1073ms,3.3
+ 184.1074ms,0.0V 184.1199ms,0.0
+ 184.1200ms,3.3V 184.1273ms,3.3
+ 184.1274ms,0.0V 184.1399ms,0.0
+ 184.1400ms,3.3V 184.1473ms,3.3
+ 184.1474ms,0.0V 184.1599ms,0.0
+ 184.1600ms,3.3V 184.1673ms,3.3
+ 184.1674ms,0.0V 184.1799ms,0.0
+ 184.1800ms,3.3V 184.1873ms,3.3
+ 184.1874ms,0.0V 184.1999ms,0.0
+ 184.2000ms,3.3V 184.2073ms,3.3
+ 184.2074ms,0.0V 184.2199ms,0.0
+ 184.2200ms,3.3V 184.2273ms,3.3
+ 184.2274ms,0.0V 184.2399ms,0.0
+ 184.2400ms,3.3V 184.2473ms,3.3
+ 184.2474ms,0.0V 184.2599ms,0.0
+ 184.2600ms,3.3V 184.2673ms,3.3
+ 184.2674ms,0.0V 184.2799ms,0.0
+ 184.2800ms,3.3V 184.2873ms,3.3
+ 184.2874ms,0.0V 184.2999ms,0.0
+ 184.3000ms,3.3V 184.3073ms,3.3
+ 184.3074ms,0.0V 184.3199ms,0.0
+ 184.3200ms,3.3V 184.3273ms,3.3
+ 184.3274ms,0.0V 184.3399ms,0.0
+ 184.3400ms,3.3V 184.3473ms,3.3
+ 184.3474ms,0.0V 184.3599ms,0.0
+ 184.3600ms,3.3V 184.3673ms,3.3
+ 184.3674ms,0.0V 184.3799ms,0.0
+ 184.3800ms,3.3V 184.3873ms,3.3
+ 184.3874ms,0.0V 184.3999ms,0.0
+ 184.4000ms,3.3V 184.4073ms,3.3
+ 184.4074ms,0.0V 184.4199ms,0.0
+ 184.4200ms,3.3V 184.4273ms,3.3
+ 184.4274ms,0.0V 184.4399ms,0.0
+ 184.4400ms,3.3V 184.4473ms,3.3
+ 184.4474ms,0.0V 184.4599ms,0.0
+ 184.4600ms,3.3V 184.4673ms,3.3
+ 184.4674ms,0.0V 184.4799ms,0.0
+ 184.4800ms,3.3V 184.4873ms,3.3
+ 184.4874ms,0.0V 184.4999ms,0.0
+ 184.5000ms,3.3V 184.5073ms,3.3
+ 184.5074ms,0.0V 184.5199ms,0.0
+ 184.5200ms,3.3V 184.5273ms,3.3
+ 184.5274ms,0.0V 184.5399ms,0.0
+ 184.5400ms,3.3V 184.5473ms,3.3
+ 184.5474ms,0.0V 184.5599ms,0.0
+ 184.5600ms,3.3V 184.5673ms,3.3
+ 184.5674ms,0.0V 184.5799ms,0.0
+ 184.5800ms,3.3V 184.5873ms,3.3
+ 184.5874ms,0.0V 184.5999ms,0.0
+ 184.6000ms,3.3V 184.6073ms,3.3
+ 184.6074ms,0.0V 184.6199ms,0.0
+ 184.6200ms,3.3V 184.6273ms,3.3
+ 184.6274ms,0.0V 184.6399ms,0.0
+ 184.6400ms,3.3V 184.6473ms,3.3
+ 184.6474ms,0.0V 184.6599ms,0.0
+ 184.6600ms,3.3V 184.6673ms,3.3
+ 184.6674ms,0.0V 184.6799ms,0.0
+ 184.6800ms,3.3V 184.6873ms,3.3
+ 184.6874ms,0.0V 184.6999ms,0.0
+ 184.7000ms,3.3V 184.7073ms,3.3
+ 184.7074ms,0.0V 184.7199ms,0.0
+ 184.7200ms,3.3V 184.7273ms,3.3
+ 184.7274ms,0.0V 184.7399ms,0.0
+ 184.7400ms,3.3V 184.7473ms,3.3
+ 184.7474ms,0.0V 184.7599ms,0.0
+ 184.7600ms,3.3V 184.7673ms,3.3
+ 184.7674ms,0.0V 184.7799ms,0.0
+ 184.7800ms,3.3V 184.7873ms,3.3
+ 184.7874ms,0.0V 184.7999ms,0.0
+ 184.8000ms,3.3V 184.8073ms,3.3
+ 184.8074ms,0.0V 184.8199ms,0.0
+ 184.8200ms,3.3V 184.8273ms,3.3
+ 184.8274ms,0.0V 184.8399ms,0.0
+ 184.8400ms,3.3V 184.8473ms,3.3
+ 184.8474ms,0.0V 184.8599ms,0.0
+ 184.8600ms,3.3V 184.8673ms,3.3
+ 184.8674ms,0.0V 184.8799ms,0.0
+ 184.8800ms,3.3V 184.8873ms,3.3
+ 184.8874ms,0.0V 184.8999ms,0.0
+ 184.9000ms,3.3V 184.9073ms,3.3
+ 184.9074ms,0.0V 184.9199ms,0.0
+ 184.9200ms,3.3V 184.9273ms,3.3
+ 184.9274ms,0.0V 184.9399ms,0.0
+ 184.9400ms,3.3V 184.9473ms,3.3
+ 184.9474ms,0.0V 184.9599ms,0.0
+ 184.9600ms,3.3V 184.9673ms,3.3
+ 184.9674ms,0.0V 184.9799ms,0.0
+ 184.9800ms,3.3V 184.9873ms,3.3
+ 184.9874ms,0.0V 184.9999ms,0.0
+ 185.0000ms,3.3V 185.0073ms,3.3
+ 185.0074ms,0.0V 185.0199ms,0.0
+ 185.0200ms,3.3V 185.0273ms,3.3
+ 185.0274ms,0.0V 185.0399ms,0.0
+ 185.0400ms,3.3V 185.0473ms,3.3
+ 185.0474ms,0.0V 185.0599ms,0.0
+ 185.0600ms,3.3V 185.0673ms,3.3
+ 185.0674ms,0.0V 185.0799ms,0.0
+ 185.0800ms,3.3V 185.0873ms,3.3
+ 185.0874ms,0.0V 185.0999ms,0.0
+ 185.1000ms,3.3V 185.1073ms,3.3
+ 185.1074ms,0.0V 185.1199ms,0.0
+ 185.1200ms,3.3V 185.1273ms,3.3
+ 185.1274ms,0.0V 185.1399ms,0.0
+ 185.1400ms,3.3V 185.1473ms,3.3
+ 185.1474ms,0.0V 185.1599ms,0.0
+ 185.1600ms,3.3V 185.1673ms,3.3
+ 185.1674ms,0.0V 185.1799ms,0.0
+ 185.1800ms,3.3V 185.1873ms,3.3
+ 185.1874ms,0.0V 185.1999ms,0.0
+ 185.2000ms,3.3V 185.2073ms,3.3
+ 185.2074ms,0.0V 185.2199ms,0.0
+ 185.2200ms,3.3V 185.2273ms,3.3
+ 185.2274ms,0.0V 185.2399ms,0.0
+ 185.2400ms,3.3V 185.2473ms,3.3
+ 185.2474ms,0.0V 185.2599ms,0.0
+ 185.2600ms,3.3V 185.2673ms,3.3
+ 185.2674ms,0.0V 185.2799ms,0.0
+ 185.2800ms,3.3V 185.2873ms,3.3
+ 185.2874ms,0.0V 185.2999ms,0.0
+ 185.3000ms,3.3V 185.3073ms,3.3
+ 185.3074ms,0.0V 185.3199ms,0.0
+ 185.3200ms,3.3V 185.3273ms,3.3
+ 185.3274ms,0.0V 185.3399ms,0.0
+ 185.3400ms,3.3V 185.3473ms,3.3
+ 185.3474ms,0.0V 185.3599ms,0.0
+ 185.3600ms,3.3V 185.3675ms,3.3
+ 185.3676ms,0.0V 185.3799ms,0.0
+ 185.3800ms,3.3V 185.3875ms,3.3
+ 185.3876ms,0.0V 185.3999ms,0.0
+ 185.4000ms,3.3V 185.4075ms,3.3
+ 185.4076ms,0.0V 185.4199ms,0.0
+ 185.4200ms,3.3V 185.4275ms,3.3
+ 185.4276ms,0.0V 185.4399ms,0.0
+ 185.4400ms,3.3V 185.4475ms,3.3
+ 185.4476ms,0.0V 185.4599ms,0.0
+ 185.4600ms,3.3V 185.4675ms,3.3
+ 185.4676ms,0.0V 185.4799ms,0.0
+ 185.4800ms,3.3V 185.4875ms,3.3
+ 185.4876ms,0.0V 185.4999ms,0.0
+ 185.5000ms,3.3V 185.5075ms,3.3
+ 185.5076ms,0.0V 185.5199ms,0.0
+ 185.5200ms,3.3V 185.5275ms,3.3
+ 185.5276ms,0.0V 185.5399ms,0.0
+ 185.5400ms,3.3V 185.5475ms,3.3
+ 185.5476ms,0.0V 185.5599ms,0.0
+ 185.5600ms,3.3V 185.5675ms,3.3
+ 185.5676ms,0.0V 185.5799ms,0.0
+ 185.5800ms,3.3V 185.5875ms,3.3
+ 185.5876ms,0.0V 185.5999ms,0.0
+ 185.6000ms,3.3V 185.6075ms,3.3
+ 185.6076ms,0.0V 185.6199ms,0.0
+ 185.6200ms,3.3V 185.6275ms,3.3
+ 185.6276ms,0.0V 185.6399ms,0.0
+ 185.6400ms,3.3V 185.6475ms,3.3
+ 185.6476ms,0.0V 185.6599ms,0.0
+ 185.6600ms,3.3V 185.6675ms,3.3
+ 185.6676ms,0.0V 185.6799ms,0.0
+ 185.6800ms,3.3V 185.6875ms,3.3
+ 185.6876ms,0.0V 185.6999ms,0.0
+ 185.7000ms,3.3V 185.7075ms,3.3
+ 185.7076ms,0.0V 185.7199ms,0.0
+ 185.7200ms,3.3V 185.7275ms,3.3
+ 185.7276ms,0.0V 185.7399ms,0.0
+ 185.7400ms,3.3V 185.7475ms,3.3
+ 185.7476ms,0.0V 185.7599ms,0.0
+ 185.7600ms,3.3V 185.7675ms,3.3
+ 185.7676ms,0.0V 185.7799ms,0.0
+ 185.7800ms,3.3V 185.7875ms,3.3
+ 185.7876ms,0.0V 185.7999ms,0.0
+ 185.8000ms,3.3V 185.8075ms,3.3
+ 185.8076ms,0.0V 185.8199ms,0.0
+ 185.8200ms,3.3V 185.8275ms,3.3
+ 185.8276ms,0.0V 185.8399ms,0.0
+ 185.8400ms,3.3V 185.8475ms,3.3
+ 185.8476ms,0.0V 185.8599ms,0.0
+ 185.8600ms,3.3V 185.8675ms,3.3
+ 185.8676ms,0.0V 185.8799ms,0.0
+ 185.8800ms,3.3V 185.8875ms,3.3
+ 185.8876ms,0.0V 185.8999ms,0.0
+ 185.9000ms,3.3V 185.9075ms,3.3
+ 185.9076ms,0.0V 185.9199ms,0.0
+ 185.9200ms,3.3V 185.9275ms,3.3
+ 185.9276ms,0.0V 185.9399ms,0.0
+ 185.9400ms,3.3V 185.9475ms,3.3
+ 185.9476ms,0.0V 185.9599ms,0.0
+ 185.9600ms,3.3V 185.9675ms,3.3
+ 185.9676ms,0.0V 185.9799ms,0.0
+ 185.9800ms,3.3V 185.9875ms,3.3
+ 185.9876ms,0.0V 185.9999ms,0.0
+ 186.0000ms,3.3V 186.0075ms,3.3
+ 186.0076ms,0.0V 186.0199ms,0.0
+ 186.0200ms,3.3V 186.0275ms,3.3
+ 186.0276ms,0.0V 186.0399ms,0.0
+ 186.0400ms,3.3V 186.0475ms,3.3
+ 186.0476ms,0.0V 186.0599ms,0.0
+ 186.0600ms,3.3V 186.0675ms,3.3
+ 186.0676ms,0.0V 186.0799ms,0.0
+ 186.0800ms,3.3V 186.0875ms,3.3
+ 186.0876ms,0.0V 186.0999ms,0.0
+ 186.1000ms,3.3V 186.1075ms,3.3
+ 186.1076ms,0.0V 186.1199ms,0.0
+ 186.1200ms,3.3V 186.1275ms,3.3
+ 186.1276ms,0.0V 186.1399ms,0.0
+ 186.1400ms,3.3V 186.1475ms,3.3
+ 186.1476ms,0.0V 186.1599ms,0.0
+ 186.1600ms,3.3V 186.1675ms,3.3
+ 186.1676ms,0.0V 186.1799ms,0.0
+ 186.1800ms,3.3V 186.1875ms,3.3
+ 186.1876ms,0.0V 186.1999ms,0.0
+ 186.2000ms,3.3V 186.2075ms,3.3
+ 186.2076ms,0.0V 186.2199ms,0.0
+ 186.2200ms,3.3V 186.2275ms,3.3
+ 186.2276ms,0.0V 186.2399ms,0.0
+ 186.2400ms,3.3V 186.2475ms,3.3
+ 186.2476ms,0.0V 186.2599ms,0.0
+ 186.2600ms,3.3V 186.2675ms,3.3
+ 186.2676ms,0.0V 186.2799ms,0.0
+ 186.2800ms,3.3V 186.2875ms,3.3
+ 186.2876ms,0.0V 186.2999ms,0.0
+ 186.3000ms,3.3V 186.3075ms,3.3
+ 186.3076ms,0.0V 186.3199ms,0.0
+ 186.3200ms,3.3V 186.3275ms,3.3
+ 186.3276ms,0.0V 186.3399ms,0.0
+ 186.3400ms,3.3V 186.3475ms,3.3
+ 186.3476ms,0.0V 186.3599ms,0.0
+ 186.3600ms,3.3V 186.3675ms,3.3
+ 186.3676ms,0.0V 186.3799ms,0.0
+ 186.3800ms,3.3V 186.3875ms,3.3
+ 186.3876ms,0.0V 186.3999ms,0.0
+ 186.4000ms,3.3V 186.4075ms,3.3
+ 186.4076ms,0.0V 186.4199ms,0.0
+ 186.4200ms,3.3V 186.4275ms,3.3
+ 186.4276ms,0.0V 186.4399ms,0.0
+ 186.4400ms,3.3V 186.4475ms,3.3
+ 186.4476ms,0.0V 186.4599ms,0.0
+ 186.4600ms,3.3V 186.4675ms,3.3
+ 186.4676ms,0.0V 186.4799ms,0.0
+ 186.4800ms,3.3V 186.4875ms,3.3
+ 186.4876ms,0.0V 186.4999ms,0.0
+ 186.5000ms,3.3V 186.5075ms,3.3
+ 186.5076ms,0.0V 186.5199ms,0.0
+ 186.5200ms,3.3V 186.5275ms,3.3
+ 186.5276ms,0.0V 186.5399ms,0.0
+ 186.5400ms,3.3V 186.5475ms,3.3
+ 186.5476ms,0.0V 186.5599ms,0.0
+ 186.5600ms,3.3V 186.5675ms,3.3
+ 186.5676ms,0.0V 186.5799ms,0.0
+ 186.5800ms,3.3V 186.5875ms,3.3
+ 186.5876ms,0.0V 186.5999ms,0.0
+ 186.6000ms,3.3V 186.6075ms,3.3
+ 186.6076ms,0.0V 186.6199ms,0.0
+ 186.6200ms,3.3V 186.6275ms,3.3
+ 186.6276ms,0.0V 186.6399ms,0.0
+ 186.6400ms,3.3V 186.6475ms,3.3
+ 186.6476ms,0.0V 186.6599ms,0.0
+ 186.6600ms,3.3V 186.6675ms,3.3
+ 186.6676ms,0.0V 186.6799ms,0.0
+ 186.6800ms,3.3V 186.6875ms,3.3
+ 186.6876ms,0.0V 186.6999ms,0.0
+ 186.7000ms,3.3V 186.7075ms,3.3
+ 186.7076ms,0.0V 186.7199ms,0.0
+ 186.7200ms,3.3V 186.7275ms,3.3
+ 186.7276ms,0.0V 186.7399ms,0.0
+ 186.7400ms,3.3V 186.7475ms,3.3
+ 186.7476ms,0.0V 186.7599ms,0.0
+ 186.7600ms,3.3V 186.7675ms,3.3
+ 186.7676ms,0.0V 186.7799ms,0.0
+ 186.7800ms,3.3V 186.7875ms,3.3
+ 186.7876ms,0.0V 186.7999ms,0.0
+ 186.8000ms,3.3V 186.8075ms,3.3
+ 186.8076ms,0.0V 186.8199ms,0.0
+ 186.8200ms,3.3V 186.8275ms,3.3
+ 186.8276ms,0.0V 186.8399ms,0.0
+ 186.8400ms,3.3V 186.8475ms,3.3
+ 186.8476ms,0.0V 186.8599ms,0.0
+ 186.8600ms,3.3V 186.8675ms,3.3
+ 186.8676ms,0.0V 186.8799ms,0.0
+ 186.8800ms,3.3V 186.8875ms,3.3
+ 186.8876ms,0.0V 186.8999ms,0.0
+ 186.9000ms,3.3V 186.9075ms,3.3
+ 186.9076ms,0.0V 186.9199ms,0.0
+ 186.9200ms,3.3V 186.9275ms,3.3
+ 186.9276ms,0.0V 186.9399ms,0.0
+ 186.9400ms,3.3V 186.9475ms,3.3
+ 186.9476ms,0.0V 186.9599ms,0.0
+ 186.9600ms,3.3V 186.9675ms,3.3
+ 186.9676ms,0.0V 186.9799ms,0.0
+ 186.9800ms,3.3V 186.9875ms,3.3
+ 186.9876ms,0.0V 186.9999ms,0.0
+ 187.0000ms,3.3V 187.0075ms,3.3
+ 187.0076ms,0.0V 187.0199ms,0.0
+ 187.0200ms,3.3V 187.0275ms,3.3
+ 187.0276ms,0.0V 187.0399ms,0.0
+ 187.0400ms,3.3V 187.0475ms,3.3
+ 187.0476ms,0.0V 187.0599ms,0.0
+ 187.0600ms,3.3V 187.0675ms,3.3
+ 187.0676ms,0.0V 187.0799ms,0.0
+ 187.0800ms,3.3V 187.0875ms,3.3
+ 187.0876ms,0.0V 187.0999ms,0.0
+ 187.1000ms,3.3V 187.1075ms,3.3
+ 187.1076ms,0.0V 187.1199ms,0.0
+ 187.1200ms,3.3V 187.1275ms,3.3
+ 187.1276ms,0.0V 187.1399ms,0.0
+ 187.1400ms,3.3V 187.1475ms,3.3
+ 187.1476ms,0.0V 187.1599ms,0.0
+ 187.1600ms,3.3V 187.1675ms,3.3
+ 187.1676ms,0.0V 187.1799ms,0.0
+ 187.1800ms,3.3V 187.1875ms,3.3
+ 187.1876ms,0.0V 187.1999ms,0.0
+ 187.2000ms,3.3V 187.2075ms,3.3
+ 187.2076ms,0.0V 187.2199ms,0.0
+ 187.2200ms,3.3V 187.2275ms,3.3
+ 187.2276ms,0.0V 187.2399ms,0.0
+ 187.2400ms,3.3V 187.2475ms,3.3
+ 187.2476ms,0.0V 187.2599ms,0.0
+ 187.2600ms,3.3V 187.2675ms,3.3
+ 187.2676ms,0.0V 187.2799ms,0.0
+ 187.2800ms,3.3V 187.2875ms,3.3
+ 187.2876ms,0.0V 187.2999ms,0.0
+ 187.3000ms,3.3V 187.3075ms,3.3
+ 187.3076ms,0.0V 187.3199ms,0.0
+ 187.3200ms,3.3V 187.3275ms,3.3
+ 187.3276ms,0.0V 187.3399ms,0.0
+ 187.3400ms,3.3V 187.3475ms,3.3
+ 187.3476ms,0.0V 187.3599ms,0.0
+ 187.3600ms,3.3V 187.3675ms,3.3
+ 187.3676ms,0.0V 187.3799ms,0.0
+ 187.3800ms,3.3V 187.3875ms,3.3
+ 187.3876ms,0.0V 187.3999ms,0.0
+ 187.4000ms,3.3V 187.4075ms,3.3
+ 187.4076ms,0.0V 187.4199ms,0.0
+ 187.4200ms,3.3V 187.4275ms,3.3
+ 187.4276ms,0.0V 187.4399ms,0.0
+ 187.4400ms,3.3V 187.4475ms,3.3
+ 187.4476ms,0.0V 187.4599ms,0.0
+ 187.4600ms,3.3V 187.4675ms,3.3
+ 187.4676ms,0.0V 187.4799ms,0.0
+ 187.4800ms,3.3V 187.4875ms,3.3
+ 187.4876ms,0.0V 187.4999ms,0.0
+ 187.5000ms,3.3V 187.5075ms,3.3
+ 187.5076ms,0.0V 187.5199ms,0.0
+ 187.5200ms,3.3V 187.5275ms,3.3
+ 187.5276ms,0.0V 187.5399ms,0.0
+ 187.5400ms,3.3V 187.5475ms,3.3
+ 187.5476ms,0.0V 187.5599ms,0.0
+ 187.5600ms,3.3V 187.5675ms,3.3
+ 187.5676ms,0.0V 187.5799ms,0.0
+ 187.5800ms,3.3V 187.5875ms,3.3
+ 187.5876ms,0.0V 187.5999ms,0.0
+ 187.6000ms,3.3V 187.6075ms,3.3
+ 187.6076ms,0.0V 187.6199ms,0.0
+ 187.6200ms,3.3V 187.6275ms,3.3
+ 187.6276ms,0.0V 187.6399ms,0.0
+ 187.6400ms,3.3V 187.6475ms,3.3
+ 187.6476ms,0.0V 187.6599ms,0.0
+ 187.6600ms,3.3V 187.6675ms,3.3
+ 187.6676ms,0.0V 187.6799ms,0.0
+ 187.6800ms,3.3V 187.6875ms,3.3
+ 187.6876ms,0.0V 187.6999ms,0.0
+ 187.7000ms,3.3V 187.7075ms,3.3
+ 187.7076ms,0.0V 187.7199ms,0.0
+ 187.7200ms,3.3V 187.7275ms,3.3
+ 187.7276ms,0.0V 187.7399ms,0.0
+ 187.7400ms,3.3V 187.7475ms,3.3
+ 187.7476ms,0.0V 187.7599ms,0.0
+ 187.7600ms,3.3V 187.7675ms,3.3
+ 187.7676ms,0.0V 187.7799ms,0.0
+ 187.7800ms,3.3V 187.7875ms,3.3
+ 187.7876ms,0.0V 187.7999ms,0.0
+ 187.8000ms,3.3V 187.8075ms,3.3
+ 187.8076ms,0.0V 187.8199ms,0.0
+ 187.8200ms,3.3V 187.8275ms,3.3
+ 187.8276ms,0.0V 187.8399ms,0.0
+ 187.8400ms,3.3V 187.8475ms,3.3
+ 187.8476ms,0.0V 187.8599ms,0.0
+ 187.8600ms,3.3V 187.8675ms,3.3
+ 187.8676ms,0.0V 187.8799ms,0.0
+ 187.8800ms,3.3V 187.8875ms,3.3
+ 187.8876ms,0.0V 187.8999ms,0.0
+ 187.9000ms,3.3V 187.9075ms,3.3
+ 187.9076ms,0.0V 187.9199ms,0.0
+ 187.9200ms,3.3V 187.9275ms,3.3
+ 187.9276ms,0.0V 187.9399ms,0.0
+ 187.9400ms,3.3V 187.9475ms,3.3
+ 187.9476ms,0.0V 187.9599ms,0.0
+ 187.9600ms,3.3V 187.9675ms,3.3
+ 187.9676ms,0.0V 187.9799ms,0.0
+ 187.9800ms,3.3V 187.9875ms,3.3
+ 187.9876ms,0.0V 187.9999ms,0.0
+ 188.0000ms,3.3V 188.0075ms,3.3
+ 188.0076ms,0.0V 188.0199ms,0.0
+ 188.0200ms,3.3V 188.0275ms,3.3
+ 188.0276ms,0.0V 188.0399ms,0.0
+ 188.0400ms,3.3V 188.0475ms,3.3
+ 188.0476ms,0.0V 188.0599ms,0.0
+ 188.0600ms,3.3V 188.0675ms,3.3
+ 188.0676ms,0.0V 188.0799ms,0.0
+ 188.0800ms,3.3V 188.0875ms,3.3
+ 188.0876ms,0.0V 188.0999ms,0.0
+ 188.1000ms,3.3V 188.1075ms,3.3
+ 188.1076ms,0.0V 188.1199ms,0.0
+ 188.1200ms,3.3V 188.1275ms,3.3
+ 188.1276ms,0.0V 188.1399ms,0.0
+ 188.1400ms,3.3V 188.1475ms,3.3
+ 188.1476ms,0.0V 188.1599ms,0.0
+ 188.1600ms,3.3V 188.1675ms,3.3
+ 188.1676ms,0.0V 188.1799ms,0.0
+ 188.1800ms,3.3V 188.1875ms,3.3
+ 188.1876ms,0.0V 188.1999ms,0.0
+ 188.2000ms,3.3V 188.2075ms,3.3
+ 188.2076ms,0.0V 188.2199ms,0.0
+ 188.2200ms,3.3V 188.2275ms,3.3
+ 188.2276ms,0.0V 188.2399ms,0.0
+ 188.2400ms,3.3V 188.2475ms,3.3
+ 188.2476ms,0.0V 188.2599ms,0.0
+ 188.2600ms,3.3V 188.2675ms,3.3
+ 188.2676ms,0.0V 188.2799ms,0.0
+ 188.2800ms,3.3V 188.2875ms,3.3
+ 188.2876ms,0.0V 188.2999ms,0.0
+ 188.3000ms,3.3V 188.3075ms,3.3
+ 188.3076ms,0.0V 188.3199ms,0.0
+ 188.3200ms,3.3V 188.3275ms,3.3
+ 188.3276ms,0.0V 188.3399ms,0.0
+ 188.3400ms,3.3V 188.3475ms,3.3
+ 188.3476ms,0.0V 188.3599ms,0.0
+ 188.3600ms,3.3V 188.3675ms,3.3
+ 188.3676ms,0.0V 188.3799ms,0.0
+ 188.3800ms,3.3V 188.3875ms,3.3
+ 188.3876ms,0.0V 188.3999ms,0.0
+ 188.4000ms,3.3V 188.4075ms,3.3
+ 188.4076ms,0.0V 188.4199ms,0.0
+ 188.4200ms,3.3V 188.4275ms,3.3
+ 188.4276ms,0.0V 188.4399ms,0.0
+ 188.4400ms,3.3V 188.4475ms,3.3
+ 188.4476ms,0.0V 188.4599ms,0.0
+ 188.4600ms,3.3V 188.4675ms,3.3
+ 188.4676ms,0.0V 188.4799ms,0.0
+ 188.4800ms,3.3V 188.4875ms,3.3
+ 188.4876ms,0.0V 188.4999ms,0.0
+ 188.5000ms,3.3V 188.5075ms,3.3
+ 188.5076ms,0.0V 188.5199ms,0.0
+ 188.5200ms,3.3V 188.5275ms,3.3
+ 188.5276ms,0.0V 188.5399ms,0.0
+ 188.5400ms,3.3V 188.5475ms,3.3
+ 188.5476ms,0.0V 188.5599ms,0.0
+ 188.5600ms,3.3V 188.5675ms,3.3
+ 188.5676ms,0.0V 188.5799ms,0.0
+ 188.5800ms,3.3V 188.5875ms,3.3
+ 188.5876ms,0.0V 188.5999ms,0.0
+ 188.6000ms,3.3V 188.6075ms,3.3
+ 188.6076ms,0.0V 188.6199ms,0.0
+ 188.6200ms,3.3V 188.6275ms,3.3
+ 188.6276ms,0.0V 188.6399ms,0.0
+ 188.6400ms,3.3V 188.6475ms,3.3
+ 188.6476ms,0.0V 188.6599ms,0.0
+ 188.6600ms,3.3V 188.6675ms,3.3
+ 188.6676ms,0.0V 188.6799ms,0.0
+ 188.6800ms,3.3V 188.6875ms,3.3
+ 188.6876ms,0.0V 188.6999ms,0.0
+ 188.7000ms,3.3V 188.7075ms,3.3
+ 188.7076ms,0.0V 188.7199ms,0.0
+ 188.7200ms,3.3V 188.7275ms,3.3
+ 188.7276ms,0.0V 188.7399ms,0.0
+ 188.7400ms,3.3V 188.7475ms,3.3
+ 188.7476ms,0.0V 188.7599ms,0.0
+ 188.7600ms,3.3V 188.7675ms,3.3
+ 188.7676ms,0.0V 188.7799ms,0.0
+ 188.7800ms,3.3V 188.7875ms,3.3
+ 188.7876ms,0.0V 188.7999ms,0.0
+ 188.8000ms,3.3V 188.8075ms,3.3
+ 188.8076ms,0.0V 188.8199ms,0.0
+ 188.8200ms,3.3V 188.8275ms,3.3
+ 188.8276ms,0.0V 188.8399ms,0.0
+ 188.8400ms,3.3V 188.8475ms,3.3
+ 188.8476ms,0.0V 188.8599ms,0.0
+ 188.8600ms,3.3V 188.8675ms,3.3
+ 188.8676ms,0.0V 188.8799ms,0.0
+ 188.8800ms,3.3V 188.8875ms,3.3
+ 188.8876ms,0.0V 188.8999ms,0.0
+ 188.9000ms,3.3V 188.9075ms,3.3
+ 188.9076ms,0.0V 188.9199ms,0.0
+ 188.9200ms,3.3V 188.9275ms,3.3
+ 188.9276ms,0.0V 188.9399ms,0.0
+ 188.9400ms,3.3V 188.9475ms,3.3
+ 188.9476ms,0.0V 188.9599ms,0.0
+ 188.9600ms,3.3V 188.9675ms,3.3
+ 188.9676ms,0.0V 188.9799ms,0.0
+ 188.9800ms,3.3V 188.9875ms,3.3
+ 188.9876ms,0.0V 188.9999ms,0.0
+ 189.0000ms,3.3V 189.0075ms,3.3
+ 189.0076ms,0.0V 189.0199ms,0.0
+ 189.0200ms,3.3V 189.0275ms,3.3
+ 189.0276ms,0.0V 189.0399ms,0.0
+ 189.0400ms,3.3V 189.0475ms,3.3
+ 189.0476ms,0.0V 189.0599ms,0.0
+ 189.0600ms,3.3V 189.0675ms,3.3
+ 189.0676ms,0.0V 189.0799ms,0.0
+ 189.0800ms,3.3V 189.0875ms,3.3
+ 189.0876ms,0.0V 189.0999ms,0.0
+ 189.1000ms,3.3V 189.1075ms,3.3
+ 189.1076ms,0.0V 189.1199ms,0.0
+ 189.1200ms,3.3V 189.1275ms,3.3
+ 189.1276ms,0.0V 189.1399ms,0.0
+ 189.1400ms,3.3V 189.1475ms,3.3
+ 189.1476ms,0.0V 189.1599ms,0.0
+ 189.1600ms,3.3V 189.1675ms,3.3
+ 189.1676ms,0.0V 189.1799ms,0.0
+ 189.1800ms,3.3V 189.1875ms,3.3
+ 189.1876ms,0.0V 189.1999ms,0.0
+ 189.2000ms,3.3V 189.2075ms,3.3
+ 189.2076ms,0.0V 189.2199ms,0.0
+ 189.2200ms,3.3V 189.2275ms,3.3
+ 189.2276ms,0.0V 189.2399ms,0.0
+ 189.2400ms,3.3V 189.2475ms,3.3
+ 189.2476ms,0.0V 189.2599ms,0.0
+ 189.2600ms,3.3V 189.2675ms,3.3
+ 189.2676ms,0.0V 189.2799ms,0.0
+ 189.2800ms,3.3V 189.2875ms,3.3
+ 189.2876ms,0.0V 189.2999ms,0.0
+ 189.3000ms,3.3V 189.3075ms,3.3
+ 189.3076ms,0.0V 189.3199ms,0.0
+ 189.3200ms,3.3V 189.3275ms,3.3
+ 189.3276ms,0.0V 189.3399ms,0.0
+ 189.3400ms,3.3V 189.3475ms,3.3
+ 189.3476ms,0.0V 189.3599ms,0.0
+ 189.3600ms,3.3V 189.3675ms,3.3
+ 189.3676ms,0.0V 189.3799ms,0.0
+ 189.3800ms,3.3V 189.3875ms,3.3
+ 189.3876ms,0.0V 189.3999ms,0.0
+ 189.4000ms,3.3V 189.4075ms,3.3
+ 189.4076ms,0.0V 189.4199ms,0.0
+ 189.4200ms,3.3V 189.4275ms,3.3
+ 189.4276ms,0.0V 189.4399ms,0.0
+ 189.4400ms,3.3V 189.4475ms,3.3
+ 189.4476ms,0.0V 189.4599ms,0.0
+ 189.4600ms,3.3V 189.4675ms,3.3
+ 189.4676ms,0.0V 189.4799ms,0.0
+ 189.4800ms,3.3V 189.4875ms,3.3
+ 189.4876ms,0.0V 189.4999ms,0.0
+ 189.5000ms,3.3V 189.5075ms,3.3
+ 189.5076ms,0.0V 189.5199ms,0.0
+ 189.5200ms,3.3V 189.5275ms,3.3
+ 189.5276ms,0.0V 189.5399ms,0.0
+ 189.5400ms,3.3V 189.5475ms,3.3
+ 189.5476ms,0.0V 189.5599ms,0.0
+ 189.5600ms,3.3V 189.5675ms,3.3
+ 189.5676ms,0.0V 189.5799ms,0.0
+ 189.5800ms,3.3V 189.5875ms,3.3
+ 189.5876ms,0.0V 189.5999ms,0.0
+ 189.6000ms,3.3V 189.6075ms,3.3
+ 189.6076ms,0.0V 189.6199ms,0.0
+ 189.6200ms,3.3V 189.6275ms,3.3
+ 189.6276ms,0.0V 189.6399ms,0.0
+ 189.6400ms,3.3V 189.6475ms,3.3
+ 189.6476ms,0.0V 189.6599ms,0.0
+ 189.6600ms,3.3V 189.6675ms,3.3
+ 189.6676ms,0.0V 189.6799ms,0.0
+ 189.6800ms,3.3V 189.6875ms,3.3
+ 189.6876ms,0.0V 189.6999ms,0.0
+ 189.7000ms,3.3V 189.7075ms,3.3
+ 189.7076ms,0.0V 189.7199ms,0.0
+ 189.7200ms,3.3V 189.7275ms,3.3
+ 189.7276ms,0.0V 189.7399ms,0.0
+ 189.7400ms,3.3V 189.7475ms,3.3
+ 189.7476ms,0.0V 189.7599ms,0.0
+ 189.7600ms,3.3V 189.7675ms,3.3
+ 189.7676ms,0.0V 189.7799ms,0.0
+ 189.7800ms,3.3V 189.7875ms,3.3
+ 189.7876ms,0.0V 189.7999ms,0.0
+ 189.8000ms,3.3V 189.8075ms,3.3
+ 189.8076ms,0.0V 189.8199ms,0.0
+ 189.8200ms,3.3V 189.8275ms,3.3
+ 189.8276ms,0.0V 189.8399ms,0.0
+ 189.8400ms,3.3V 189.8475ms,3.3
+ 189.8476ms,0.0V 189.8599ms,0.0
+ 189.8600ms,3.3V 189.8675ms,3.3
+ 189.8676ms,0.0V 189.8799ms,0.0
+ 189.8800ms,3.3V 189.8875ms,3.3
+ 189.8876ms,0.0V 189.8999ms,0.0
+ 189.9000ms,3.3V 189.9075ms,3.3
+ 189.9076ms,0.0V 189.9199ms,0.0
+ 189.9200ms,3.3V 189.9275ms,3.3
+ 189.9276ms,0.0V 189.9399ms,0.0
+ 189.9400ms,3.3V 189.9475ms,3.3
+ 189.9476ms,0.0V 189.9599ms,0.0
+ 189.9600ms,3.3V 189.9675ms,3.3
+ 189.9676ms,0.0V 189.9799ms,0.0
+ 189.9800ms,3.3V 189.9875ms,3.3
+ 189.9876ms,0.0V 189.9999ms,0.0
+ 190.0000ms,3.3V 190.0075ms,3.3
+ 190.0076ms,0.0V 190.0199ms,0.0
+ 190.0200ms,3.3V 190.0275ms,3.3
+ 190.0276ms,0.0V 190.0399ms,0.0
+ 190.0400ms,3.3V 190.0475ms,3.3
+ 190.0476ms,0.0V 190.0599ms,0.0
+ 190.0600ms,3.3V 190.0675ms,3.3
+ 190.0676ms,0.0V 190.0799ms,0.0
+ 190.0800ms,3.3V 190.0875ms,3.3
+ 190.0876ms,0.0V 190.0999ms,0.0
+ 190.1000ms,3.3V 190.1075ms,3.3
+ 190.1076ms,0.0V 190.1199ms,0.0
+ 190.1200ms,3.3V 190.1275ms,3.3
+ 190.1276ms,0.0V 190.1399ms,0.0
+ 190.1400ms,3.3V 190.1475ms,3.3
+ 190.1476ms,0.0V 190.1599ms,0.0
+ 190.1600ms,3.3V 190.1675ms,3.3
+ 190.1676ms,0.0V 190.1799ms,0.0
+ 190.1800ms,3.3V 190.1875ms,3.3
+ 190.1876ms,0.0V 190.1999ms,0.0
+ 190.2000ms,3.3V 190.2075ms,3.3
+ 190.2076ms,0.0V 190.2199ms,0.0
+ 190.2200ms,3.3V 190.2275ms,3.3
+ 190.2276ms,0.0V 190.2399ms,0.0
+ 190.2400ms,3.3V 190.2475ms,3.3
+ 190.2476ms,0.0V 190.2599ms,0.0
+ 190.2600ms,3.3V 190.2675ms,3.3
+ 190.2676ms,0.0V 190.2799ms,0.0
+ 190.2800ms,3.3V 190.2875ms,3.3
+ 190.2876ms,0.0V 190.2999ms,0.0
+ 190.3000ms,3.3V 190.3075ms,3.3
+ 190.3076ms,0.0V 190.3199ms,0.0
+ 190.3200ms,3.3V 190.3275ms,3.3
+ 190.3276ms,0.0V 190.3399ms,0.0
+ 190.3400ms,3.3V 190.3475ms,3.3
+ 190.3476ms,0.0V 190.3599ms,0.0
+ 190.3600ms,3.3V 190.3677ms,3.3
+ 190.3678ms,0.0V 190.3799ms,0.0
+ 190.3800ms,3.3V 190.3877ms,3.3
+ 190.3878ms,0.0V 190.3999ms,0.0
+ 190.4000ms,3.3V 190.4077ms,3.3
+ 190.4078ms,0.0V 190.4199ms,0.0
+ 190.4200ms,3.3V 190.4277ms,3.3
+ 190.4278ms,0.0V 190.4399ms,0.0
+ 190.4400ms,3.3V 190.4477ms,3.3
+ 190.4478ms,0.0V 190.4599ms,0.0
+ 190.4600ms,3.3V 190.4677ms,3.3
+ 190.4678ms,0.0V 190.4799ms,0.0
+ 190.4800ms,3.3V 190.4877ms,3.3
+ 190.4878ms,0.0V 190.4999ms,0.0
+ 190.5000ms,3.3V 190.5077ms,3.3
+ 190.5078ms,0.0V 190.5199ms,0.0
+ 190.5200ms,3.3V 190.5277ms,3.3
+ 190.5278ms,0.0V 190.5399ms,0.0
+ 190.5400ms,3.3V 190.5477ms,3.3
+ 190.5478ms,0.0V 190.5599ms,0.0
+ 190.5600ms,3.3V 190.5677ms,3.3
+ 190.5678ms,0.0V 190.5799ms,0.0
+ 190.5800ms,3.3V 190.5877ms,3.3
+ 190.5878ms,0.0V 190.5999ms,0.0
+ 190.6000ms,3.3V 190.6077ms,3.3
+ 190.6078ms,0.0V 190.6199ms,0.0
+ 190.6200ms,3.3V 190.6277ms,3.3
+ 190.6278ms,0.0V 190.6399ms,0.0
+ 190.6400ms,3.3V 190.6477ms,3.3
+ 190.6478ms,0.0V 190.6599ms,0.0
+ 190.6600ms,3.3V 190.6677ms,3.3
+ 190.6678ms,0.0V 190.6799ms,0.0
+ 190.6800ms,3.3V 190.6877ms,3.3
+ 190.6878ms,0.0V 190.6999ms,0.0
+ 190.7000ms,3.3V 190.7077ms,3.3
+ 190.7078ms,0.0V 190.7199ms,0.0
+ 190.7200ms,3.3V 190.7277ms,3.3
+ 190.7278ms,0.0V 190.7399ms,0.0
+ 190.7400ms,3.3V 190.7477ms,3.3
+ 190.7478ms,0.0V 190.7599ms,0.0
+ 190.7600ms,3.3V 190.7677ms,3.3
+ 190.7678ms,0.0V 190.7799ms,0.0
+ 190.7800ms,3.3V 190.7877ms,3.3
+ 190.7878ms,0.0V 190.7999ms,0.0
+ 190.8000ms,3.3V 190.8077ms,3.3
+ 190.8078ms,0.0V 190.8199ms,0.0
+ 190.8200ms,3.3V 190.8277ms,3.3
+ 190.8278ms,0.0V 190.8399ms,0.0
+ 190.8400ms,3.3V 190.8477ms,3.3
+ 190.8478ms,0.0V 190.8599ms,0.0
+ 190.8600ms,3.3V 190.8677ms,3.3
+ 190.8678ms,0.0V 190.8799ms,0.0
+ 190.8800ms,3.3V 190.8877ms,3.3
+ 190.8878ms,0.0V 190.8999ms,0.0
+ 190.9000ms,3.3V 190.9077ms,3.3
+ 190.9078ms,0.0V 190.9199ms,0.0
+ 190.9200ms,3.3V 190.9277ms,3.3
+ 190.9278ms,0.0V 190.9399ms,0.0
+ 190.9400ms,3.3V 190.9477ms,3.3
+ 190.9478ms,0.0V 190.9599ms,0.0
+ 190.9600ms,3.3V 190.9677ms,3.3
+ 190.9678ms,0.0V 190.9799ms,0.0
+ 190.9800ms,3.3V 190.9877ms,3.3
+ 190.9878ms,0.0V 190.9999ms,0.0
+ 191.0000ms,3.3V 191.0077ms,3.3
+ 191.0078ms,0.0V 191.0199ms,0.0
+ 191.0200ms,3.3V 191.0277ms,3.3
+ 191.0278ms,0.0V 191.0399ms,0.0
+ 191.0400ms,3.3V 191.0477ms,3.3
+ 191.0478ms,0.0V 191.0599ms,0.0
+ 191.0600ms,3.3V 191.0677ms,3.3
+ 191.0678ms,0.0V 191.0799ms,0.0
+ 191.0800ms,3.3V 191.0877ms,3.3
+ 191.0878ms,0.0V 191.0999ms,0.0
+ 191.1000ms,3.3V 191.1077ms,3.3
+ 191.1078ms,0.0V 191.1199ms,0.0
+ 191.1200ms,3.3V 191.1277ms,3.3
+ 191.1278ms,0.0V 191.1399ms,0.0
+ 191.1400ms,3.3V 191.1477ms,3.3
+ 191.1478ms,0.0V 191.1599ms,0.0
+ 191.1600ms,3.3V 191.1677ms,3.3
+ 191.1678ms,0.0V 191.1799ms,0.0
+ 191.1800ms,3.3V 191.1877ms,3.3
+ 191.1878ms,0.0V 191.1999ms,0.0
+ 191.2000ms,3.3V 191.2077ms,3.3
+ 191.2078ms,0.0V 191.2199ms,0.0
+ 191.2200ms,3.3V 191.2277ms,3.3
+ 191.2278ms,0.0V 191.2399ms,0.0
+ 191.2400ms,3.3V 191.2477ms,3.3
+ 191.2478ms,0.0V 191.2599ms,0.0
+ 191.2600ms,3.3V 191.2677ms,3.3
+ 191.2678ms,0.0V 191.2799ms,0.0
+ 191.2800ms,3.3V 191.2877ms,3.3
+ 191.2878ms,0.0V 191.2999ms,0.0
+ 191.3000ms,3.3V 191.3077ms,3.3
+ 191.3078ms,0.0V 191.3199ms,0.0
+ 191.3200ms,3.3V 191.3277ms,3.3
+ 191.3278ms,0.0V 191.3399ms,0.0
+ 191.3400ms,3.3V 191.3477ms,3.3
+ 191.3478ms,0.0V 191.3599ms,0.0
+ 191.3600ms,3.3V 191.3677ms,3.3
+ 191.3678ms,0.0V 191.3799ms,0.0
+ 191.3800ms,3.3V 191.3877ms,3.3
+ 191.3878ms,0.0V 191.3999ms,0.0
+ 191.4000ms,3.3V 191.4077ms,3.3
+ 191.4078ms,0.0V 191.4199ms,0.0
+ 191.4200ms,3.3V 191.4277ms,3.3
+ 191.4278ms,0.0V 191.4399ms,0.0
+ 191.4400ms,3.3V 191.4477ms,3.3
+ 191.4478ms,0.0V 191.4599ms,0.0
+ 191.4600ms,3.3V 191.4677ms,3.3
+ 191.4678ms,0.0V 191.4799ms,0.0
+ 191.4800ms,3.3V 191.4877ms,3.3
+ 191.4878ms,0.0V 191.4999ms,0.0
+ 191.5000ms,3.3V 191.5077ms,3.3
+ 191.5078ms,0.0V 191.5199ms,0.0
+ 191.5200ms,3.3V 191.5277ms,3.3
+ 191.5278ms,0.0V 191.5399ms,0.0
+ 191.5400ms,3.3V 191.5477ms,3.3
+ 191.5478ms,0.0V 191.5599ms,0.0
+ 191.5600ms,3.3V 191.5677ms,3.3
+ 191.5678ms,0.0V 191.5799ms,0.0
+ 191.5800ms,3.3V 191.5877ms,3.3
+ 191.5878ms,0.0V 191.5999ms,0.0
+ 191.6000ms,3.3V 191.6077ms,3.3
+ 191.6078ms,0.0V 191.6199ms,0.0
+ 191.6200ms,3.3V 191.6277ms,3.3
+ 191.6278ms,0.0V 191.6399ms,0.0
+ 191.6400ms,3.3V 191.6477ms,3.3
+ 191.6478ms,0.0V 191.6599ms,0.0
+ 191.6600ms,3.3V 191.6677ms,3.3
+ 191.6678ms,0.0V 191.6799ms,0.0
+ 191.6800ms,3.3V 191.6877ms,3.3
+ 191.6878ms,0.0V 191.6999ms,0.0
+ 191.7000ms,3.3V 191.7077ms,3.3
+ 191.7078ms,0.0V 191.7199ms,0.0
+ 191.7200ms,3.3V 191.7277ms,3.3
+ 191.7278ms,0.0V 191.7399ms,0.0
+ 191.7400ms,3.3V 191.7477ms,3.3
+ 191.7478ms,0.0V 191.7599ms,0.0
+ 191.7600ms,3.3V 191.7677ms,3.3
+ 191.7678ms,0.0V 191.7799ms,0.0
+ 191.7800ms,3.3V 191.7877ms,3.3
+ 191.7878ms,0.0V 191.7999ms,0.0
+ 191.8000ms,3.3V 191.8077ms,3.3
+ 191.8078ms,0.0V 191.8199ms,0.0
+ 191.8200ms,3.3V 191.8277ms,3.3
+ 191.8278ms,0.0V 191.8399ms,0.0
+ 191.8400ms,3.3V 191.8477ms,3.3
+ 191.8478ms,0.0V 191.8599ms,0.0
+ 191.8600ms,3.3V 191.8677ms,3.3
+ 191.8678ms,0.0V 191.8799ms,0.0
+ 191.8800ms,3.3V 191.8877ms,3.3
+ 191.8878ms,0.0V 191.8999ms,0.0
+ 191.9000ms,3.3V 191.9077ms,3.3
+ 191.9078ms,0.0V 191.9199ms,0.0
+ 191.9200ms,3.3V 191.9277ms,3.3
+ 191.9278ms,0.0V 191.9399ms,0.0
+ 191.9400ms,3.3V 191.9477ms,3.3
+ 191.9478ms,0.0V 191.9599ms,0.0
+ 191.9600ms,3.3V 191.9677ms,3.3
+ 191.9678ms,0.0V 191.9799ms,0.0
+ 191.9800ms,3.3V 191.9877ms,3.3
+ 191.9878ms,0.0V 191.9999ms,0.0
+ 192.0000ms,3.3V 192.0077ms,3.3
+ 192.0078ms,0.0V 192.0199ms,0.0
+ 192.0200ms,3.3V 192.0277ms,3.3
+ 192.0278ms,0.0V 192.0399ms,0.0
+ 192.0400ms,3.3V 192.0477ms,3.3
+ 192.0478ms,0.0V 192.0599ms,0.0
+ 192.0600ms,3.3V 192.0677ms,3.3
+ 192.0678ms,0.0V 192.0799ms,0.0
+ 192.0800ms,3.3V 192.0877ms,3.3
+ 192.0878ms,0.0V 192.0999ms,0.0
+ 192.1000ms,3.3V 192.1077ms,3.3
+ 192.1078ms,0.0V 192.1199ms,0.0
+ 192.1200ms,3.3V 192.1277ms,3.3
+ 192.1278ms,0.0V 192.1399ms,0.0
+ 192.1400ms,3.3V 192.1477ms,3.3
+ 192.1478ms,0.0V 192.1599ms,0.0
+ 192.1600ms,3.3V 192.1677ms,3.3
+ 192.1678ms,0.0V 192.1799ms,0.0
+ 192.1800ms,3.3V 192.1877ms,3.3
+ 192.1878ms,0.0V 192.1999ms,0.0
+ 192.2000ms,3.3V 192.2077ms,3.3
+ 192.2078ms,0.0V 192.2199ms,0.0
+ 192.2200ms,3.3V 192.2277ms,3.3
+ 192.2278ms,0.0V 192.2399ms,0.0
+ 192.2400ms,3.3V 192.2477ms,3.3
+ 192.2478ms,0.0V 192.2599ms,0.0
+ 192.2600ms,3.3V 192.2677ms,3.3
+ 192.2678ms,0.0V 192.2799ms,0.0
+ 192.2800ms,3.3V 192.2877ms,3.3
+ 192.2878ms,0.0V 192.2999ms,0.0
+ 192.3000ms,3.3V 192.3077ms,3.3
+ 192.3078ms,0.0V 192.3199ms,0.0
+ 192.3200ms,3.3V 192.3277ms,3.3
+ 192.3278ms,0.0V 192.3399ms,0.0
+ 192.3400ms,3.3V 192.3477ms,3.3
+ 192.3478ms,0.0V 192.3599ms,0.0
+ 192.3600ms,3.3V 192.3677ms,3.3
+ 192.3678ms,0.0V 192.3799ms,0.0
+ 192.3800ms,3.3V 192.3877ms,3.3
+ 192.3878ms,0.0V 192.3999ms,0.0
+ 192.4000ms,3.3V 192.4077ms,3.3
+ 192.4078ms,0.0V 192.4199ms,0.0
+ 192.4200ms,3.3V 192.4277ms,3.3
+ 192.4278ms,0.0V 192.4399ms,0.0
+ 192.4400ms,3.3V 192.4477ms,3.3
+ 192.4478ms,0.0V 192.4599ms,0.0
+ 192.4600ms,3.3V 192.4677ms,3.3
+ 192.4678ms,0.0V 192.4799ms,0.0
+ 192.4800ms,3.3V 192.4877ms,3.3
+ 192.4878ms,0.0V 192.4999ms,0.0
+ 192.5000ms,3.3V 192.5077ms,3.3
+ 192.5078ms,0.0V 192.5199ms,0.0
+ 192.5200ms,3.3V 192.5277ms,3.3
+ 192.5278ms,0.0V 192.5399ms,0.0
+ 192.5400ms,3.3V 192.5477ms,3.3
+ 192.5478ms,0.0V 192.5599ms,0.0
+ 192.5600ms,3.3V 192.5677ms,3.3
+ 192.5678ms,0.0V 192.5799ms,0.0
+ 192.5800ms,3.3V 192.5877ms,3.3
+ 192.5878ms,0.0V 192.5999ms,0.0
+ 192.6000ms,3.3V 192.6077ms,3.3
+ 192.6078ms,0.0V 192.6199ms,0.0
+ 192.6200ms,3.3V 192.6277ms,3.3
+ 192.6278ms,0.0V 192.6399ms,0.0
+ 192.6400ms,3.3V 192.6477ms,3.3
+ 192.6478ms,0.0V 192.6599ms,0.0
+ 192.6600ms,3.3V 192.6677ms,3.3
+ 192.6678ms,0.0V 192.6799ms,0.0
+ 192.6800ms,3.3V 192.6877ms,3.3
+ 192.6878ms,0.0V 192.6999ms,0.0
+ 192.7000ms,3.3V 192.7077ms,3.3
+ 192.7078ms,0.0V 192.7199ms,0.0
+ 192.7200ms,3.3V 192.7277ms,3.3
+ 192.7278ms,0.0V 192.7399ms,0.0
+ 192.7400ms,3.3V 192.7477ms,3.3
+ 192.7478ms,0.0V 192.7599ms,0.0
+ 192.7600ms,3.3V 192.7677ms,3.3
+ 192.7678ms,0.0V 192.7799ms,0.0
+ 192.7800ms,3.3V 192.7877ms,3.3
+ 192.7878ms,0.0V 192.7999ms,0.0
+ 192.8000ms,3.3V 192.8077ms,3.3
+ 192.8078ms,0.0V 192.8199ms,0.0
+ 192.8200ms,3.3V 192.8277ms,3.3
+ 192.8278ms,0.0V 192.8399ms,0.0
+ 192.8400ms,3.3V 192.8477ms,3.3
+ 192.8478ms,0.0V 192.8599ms,0.0
+ 192.8600ms,3.3V 192.8677ms,3.3
+ 192.8678ms,0.0V 192.8799ms,0.0
+ 192.8800ms,3.3V 192.8877ms,3.3
+ 192.8878ms,0.0V 192.8999ms,0.0
+ 192.9000ms,3.3V 192.9077ms,3.3
+ 192.9078ms,0.0V 192.9199ms,0.0
+ 192.9200ms,3.3V 192.9277ms,3.3
+ 192.9278ms,0.0V 192.9399ms,0.0
+ 192.9400ms,3.3V 192.9477ms,3.3
+ 192.9478ms,0.0V 192.9599ms,0.0
+ 192.9600ms,3.3V 192.9677ms,3.3
+ 192.9678ms,0.0V 192.9799ms,0.0
+ 192.9800ms,3.3V 192.9877ms,3.3
+ 192.9878ms,0.0V 192.9999ms,0.0
+ 193.0000ms,3.3V 193.0077ms,3.3
+ 193.0078ms,0.0V 193.0199ms,0.0
+ 193.0200ms,3.3V 193.0277ms,3.3
+ 193.0278ms,0.0V 193.0399ms,0.0
+ 193.0400ms,3.3V 193.0477ms,3.3
+ 193.0478ms,0.0V 193.0599ms,0.0
+ 193.0600ms,3.3V 193.0677ms,3.3
+ 193.0678ms,0.0V 193.0799ms,0.0
+ 193.0800ms,3.3V 193.0877ms,3.3
+ 193.0878ms,0.0V 193.0999ms,0.0
+ 193.1000ms,3.3V 193.1077ms,3.3
+ 193.1078ms,0.0V 193.1199ms,0.0
+ 193.1200ms,3.3V 193.1277ms,3.3
+ 193.1278ms,0.0V 193.1399ms,0.0
+ 193.1400ms,3.3V 193.1477ms,3.3
+ 193.1478ms,0.0V 193.1599ms,0.0
+ 193.1600ms,3.3V 193.1677ms,3.3
+ 193.1678ms,0.0V 193.1799ms,0.0
+ 193.1800ms,3.3V 193.1877ms,3.3
+ 193.1878ms,0.0V 193.1999ms,0.0
+ 193.2000ms,3.3V 193.2077ms,3.3
+ 193.2078ms,0.0V 193.2199ms,0.0
+ 193.2200ms,3.3V 193.2277ms,3.3
+ 193.2278ms,0.0V 193.2399ms,0.0
+ 193.2400ms,3.3V 193.2477ms,3.3
+ 193.2478ms,0.0V 193.2599ms,0.0
+ 193.2600ms,3.3V 193.2677ms,3.3
+ 193.2678ms,0.0V 193.2799ms,0.0
+ 193.2800ms,3.3V 193.2877ms,3.3
+ 193.2878ms,0.0V 193.2999ms,0.0
+ 193.3000ms,3.3V 193.3077ms,3.3
+ 193.3078ms,0.0V 193.3199ms,0.0
+ 193.3200ms,3.3V 193.3277ms,3.3
+ 193.3278ms,0.0V 193.3399ms,0.0
+ 193.3400ms,3.3V 193.3477ms,3.3
+ 193.3478ms,0.0V 193.3599ms,0.0
+ 193.3600ms,3.3V 193.3677ms,3.3
+ 193.3678ms,0.0V 193.3799ms,0.0
+ 193.3800ms,3.3V 193.3877ms,3.3
+ 193.3878ms,0.0V 193.3999ms,0.0
+ 193.4000ms,3.3V 193.4077ms,3.3
+ 193.4078ms,0.0V 193.4199ms,0.0
+ 193.4200ms,3.3V 193.4277ms,3.3
+ 193.4278ms,0.0V 193.4399ms,0.0
+ 193.4400ms,3.3V 193.4477ms,3.3
+ 193.4478ms,0.0V 193.4599ms,0.0
+ 193.4600ms,3.3V 193.4677ms,3.3
+ 193.4678ms,0.0V 193.4799ms,0.0
+ 193.4800ms,3.3V 193.4877ms,3.3
+ 193.4878ms,0.0V 193.4999ms,0.0
+ 193.5000ms,3.3V 193.5077ms,3.3
+ 193.5078ms,0.0V 193.5199ms,0.0
+ 193.5200ms,3.3V 193.5277ms,3.3
+ 193.5278ms,0.0V 193.5399ms,0.0
+ 193.5400ms,3.3V 193.5477ms,3.3
+ 193.5478ms,0.0V 193.5599ms,0.0
+ 193.5600ms,3.3V 193.5677ms,3.3
+ 193.5678ms,0.0V 193.5799ms,0.0
+ 193.5800ms,3.3V 193.5877ms,3.3
+ 193.5878ms,0.0V 193.5999ms,0.0
+ 193.6000ms,3.3V 193.6077ms,3.3
+ 193.6078ms,0.0V 193.6199ms,0.0
+ 193.6200ms,3.3V 193.6277ms,3.3
+ 193.6278ms,0.0V 193.6399ms,0.0
+ 193.6400ms,3.3V 193.6477ms,3.3
+ 193.6478ms,0.0V 193.6599ms,0.0
+ 193.6600ms,3.3V 193.6677ms,3.3
+ 193.6678ms,0.0V 193.6799ms,0.0
+ 193.6800ms,3.3V 193.6877ms,3.3
+ 193.6878ms,0.0V 193.6999ms,0.0
+ 193.7000ms,3.3V 193.7077ms,3.3
+ 193.7078ms,0.0V 193.7199ms,0.0
+ 193.7200ms,3.3V 193.7277ms,3.3
+ 193.7278ms,0.0V 193.7399ms,0.0
+ 193.7400ms,3.3V 193.7477ms,3.3
+ 193.7478ms,0.0V 193.7599ms,0.0
+ 193.7600ms,3.3V 193.7677ms,3.3
+ 193.7678ms,0.0V 193.7799ms,0.0
+ 193.7800ms,3.3V 193.7877ms,3.3
+ 193.7878ms,0.0V 193.7999ms,0.0
+ 193.8000ms,3.3V 193.8077ms,3.3
+ 193.8078ms,0.0V 193.8199ms,0.0
+ 193.8200ms,3.3V 193.8277ms,3.3
+ 193.8278ms,0.0V 193.8399ms,0.0
+ 193.8400ms,3.3V 193.8477ms,3.3
+ 193.8478ms,0.0V 193.8599ms,0.0
+ 193.8600ms,3.3V 193.8677ms,3.3
+ 193.8678ms,0.0V 193.8799ms,0.0
+ 193.8800ms,3.3V 193.8877ms,3.3
+ 193.8878ms,0.0V 193.8999ms,0.0
+ 193.9000ms,3.3V 193.9077ms,3.3
+ 193.9078ms,0.0V 193.9199ms,0.0
+ 193.9200ms,3.3V 193.9277ms,3.3
+ 193.9278ms,0.0V 193.9399ms,0.0
+ 193.9400ms,3.3V 193.9477ms,3.3
+ 193.9478ms,0.0V 193.9599ms,0.0
+ 193.9600ms,3.3V 193.9677ms,3.3
+ 193.9678ms,0.0V 193.9799ms,0.0
+ 193.9800ms,3.3V 193.9877ms,3.3
+ 193.9878ms,0.0V 193.9999ms,0.0
+ 194.0000ms,3.3V 194.0077ms,3.3
+ 194.0078ms,0.0V 194.0199ms,0.0
+ 194.0200ms,3.3V 194.0277ms,3.3
+ 194.0278ms,0.0V 194.0399ms,0.0
+ 194.0400ms,3.3V 194.0477ms,3.3
+ 194.0478ms,0.0V 194.0599ms,0.0
+ 194.0600ms,3.3V 194.0677ms,3.3
+ 194.0678ms,0.0V 194.0799ms,0.0
+ 194.0800ms,3.3V 194.0877ms,3.3
+ 194.0878ms,0.0V 194.0999ms,0.0
+ 194.1000ms,3.3V 194.1077ms,3.3
+ 194.1078ms,0.0V 194.1199ms,0.0
+ 194.1200ms,3.3V 194.1277ms,3.3
+ 194.1278ms,0.0V 194.1399ms,0.0
+ 194.1400ms,3.3V 194.1477ms,3.3
+ 194.1478ms,0.0V 194.1599ms,0.0
+ 194.1600ms,3.3V 194.1677ms,3.3
+ 194.1678ms,0.0V 194.1799ms,0.0
+ 194.1800ms,3.3V 194.1877ms,3.3
+ 194.1878ms,0.0V 194.1999ms,0.0
+ 194.2000ms,3.3V 194.2077ms,3.3
+ 194.2078ms,0.0V 194.2199ms,0.0
+ 194.2200ms,3.3V 194.2277ms,3.3
+ 194.2278ms,0.0V 194.2399ms,0.0
+ 194.2400ms,3.3V 194.2477ms,3.3
+ 194.2478ms,0.0V 194.2599ms,0.0
+ 194.2600ms,3.3V 194.2677ms,3.3
+ 194.2678ms,0.0V 194.2799ms,0.0
+ 194.2800ms,3.3V 194.2877ms,3.3
+ 194.2878ms,0.0V 194.2999ms,0.0
+ 194.3000ms,3.3V 194.3077ms,3.3
+ 194.3078ms,0.0V 194.3199ms,0.0
+ 194.3200ms,3.3V 194.3277ms,3.3
+ 194.3278ms,0.0V 194.3399ms,0.0
+ 194.3400ms,3.3V 194.3477ms,3.3
+ 194.3478ms,0.0V 194.3599ms,0.0
+ 194.3600ms,3.3V 194.3677ms,3.3
+ 194.3678ms,0.0V 194.3799ms,0.0
+ 194.3800ms,3.3V 194.3877ms,3.3
+ 194.3878ms,0.0V 194.3999ms,0.0
+ 194.4000ms,3.3V 194.4077ms,3.3
+ 194.4078ms,0.0V 194.4199ms,0.0
+ 194.4200ms,3.3V 194.4277ms,3.3
+ 194.4278ms,0.0V 194.4399ms,0.0
+ 194.4400ms,3.3V 194.4477ms,3.3
+ 194.4478ms,0.0V 194.4599ms,0.0
+ 194.4600ms,3.3V 194.4677ms,3.3
+ 194.4678ms,0.0V 194.4799ms,0.0
+ 194.4800ms,3.3V 194.4877ms,3.3
+ 194.4878ms,0.0V 194.4999ms,0.0
+ 194.5000ms,3.3V 194.5077ms,3.3
+ 194.5078ms,0.0V 194.5199ms,0.0
+ 194.5200ms,3.3V 194.5277ms,3.3
+ 194.5278ms,0.0V 194.5399ms,0.0
+ 194.5400ms,3.3V 194.5477ms,3.3
+ 194.5478ms,0.0V 194.5599ms,0.0
+ 194.5600ms,3.3V 194.5677ms,3.3
+ 194.5678ms,0.0V 194.5799ms,0.0
+ 194.5800ms,3.3V 194.5877ms,3.3
+ 194.5878ms,0.0V 194.5999ms,0.0
+ 194.6000ms,3.3V 194.6077ms,3.3
+ 194.6078ms,0.0V 194.6199ms,0.0
+ 194.6200ms,3.3V 194.6277ms,3.3
+ 194.6278ms,0.0V 194.6399ms,0.0
+ 194.6400ms,3.3V 194.6477ms,3.3
+ 194.6478ms,0.0V 194.6599ms,0.0
+ 194.6600ms,3.3V 194.6677ms,3.3
+ 194.6678ms,0.0V 194.6799ms,0.0
+ 194.6800ms,3.3V 194.6877ms,3.3
+ 194.6878ms,0.0V 194.6999ms,0.0
+ 194.7000ms,3.3V 194.7077ms,3.3
+ 194.7078ms,0.0V 194.7199ms,0.0
+ 194.7200ms,3.3V 194.7277ms,3.3
+ 194.7278ms,0.0V 194.7399ms,0.0
+ 194.7400ms,3.3V 194.7477ms,3.3
+ 194.7478ms,0.0V 194.7599ms,0.0
+ 194.7600ms,3.3V 194.7677ms,3.3
+ 194.7678ms,0.0V 194.7799ms,0.0
+ 194.7800ms,3.3V 194.7877ms,3.3
+ 194.7878ms,0.0V 194.7999ms,0.0
+ 194.8000ms,3.3V 194.8077ms,3.3
+ 194.8078ms,0.0V 194.8199ms,0.0
+ 194.8200ms,3.3V 194.8277ms,3.3
+ 194.8278ms,0.0V 194.8399ms,0.0
+ 194.8400ms,3.3V 194.8477ms,3.3
+ 194.8478ms,0.0V 194.8599ms,0.0
+ 194.8600ms,3.3V 194.8677ms,3.3
+ 194.8678ms,0.0V 194.8799ms,0.0
+ 194.8800ms,3.3V 194.8877ms,3.3
+ 194.8878ms,0.0V 194.8999ms,0.0
+ 194.9000ms,3.3V 194.9077ms,3.3
+ 194.9078ms,0.0V 194.9199ms,0.0
+ 194.9200ms,3.3V 194.9277ms,3.3
+ 194.9278ms,0.0V 194.9399ms,0.0
+ 194.9400ms,3.3V 194.9477ms,3.3
+ 194.9478ms,0.0V 194.9599ms,0.0
+ 194.9600ms,3.3V 194.9677ms,3.3
+ 194.9678ms,0.0V 194.9799ms,0.0
+ 194.9800ms,3.3V 194.9877ms,3.3
+ 194.9878ms,0.0V 194.9999ms,0.0
+ 195.0000ms,3.3V 195.0077ms,3.3
+ 195.0078ms,0.0V 195.0199ms,0.0
+ 195.0200ms,3.3V 195.0277ms,3.3
+ 195.0278ms,0.0V 195.0399ms,0.0
+ 195.0400ms,3.3V 195.0477ms,3.3
+ 195.0478ms,0.0V 195.0599ms,0.0
+ 195.0600ms,3.3V 195.0677ms,3.3
+ 195.0678ms,0.0V 195.0799ms,0.0
+ 195.0800ms,3.3V 195.0877ms,3.3
+ 195.0878ms,0.0V 195.0999ms,0.0
+ 195.1000ms,3.3V 195.1077ms,3.3
+ 195.1078ms,0.0V 195.1199ms,0.0
+ 195.1200ms,3.3V 195.1277ms,3.3
+ 195.1278ms,0.0V 195.1399ms,0.0
+ 195.1400ms,3.3V 195.1477ms,3.3
+ 195.1478ms,0.0V 195.1599ms,0.0
+ 195.1600ms,3.3V 195.1677ms,3.3
+ 195.1678ms,0.0V 195.1799ms,0.0
+ 195.1800ms,3.3V 195.1877ms,3.3
+ 195.1878ms,0.0V 195.1999ms,0.0
+ 195.2000ms,3.3V 195.2077ms,3.3
+ 195.2078ms,0.0V 195.2199ms,0.0
+ 195.2200ms,3.3V 195.2277ms,3.3
+ 195.2278ms,0.0V 195.2399ms,0.0
+ 195.2400ms,3.3V 195.2477ms,3.3
+ 195.2478ms,0.0V 195.2599ms,0.0
+ 195.2600ms,3.3V 195.2677ms,3.3
+ 195.2678ms,0.0V 195.2799ms,0.0
+ 195.2800ms,3.3V 195.2877ms,3.3
+ 195.2878ms,0.0V 195.2999ms,0.0
+ 195.3000ms,3.3V 195.3077ms,3.3
+ 195.3078ms,0.0V 195.3199ms,0.0
+ 195.3200ms,3.3V 195.3277ms,3.3
+ 195.3278ms,0.0V 195.3399ms,0.0
+ 195.3400ms,3.3V 195.3477ms,3.3
+ 195.3478ms,0.0V 195.3599ms,0.0
+ 195.3600ms,3.3V 195.3679ms,3.3
+ 195.3680ms,0.0V 195.3799ms,0.0
+ 195.3800ms,3.3V 195.3879ms,3.3
+ 195.3880ms,0.0V 195.3999ms,0.0
+ 195.4000ms,3.3V 195.4079ms,3.3
+ 195.4080ms,0.0V 195.4199ms,0.0
+ 195.4200ms,3.3V 195.4279ms,3.3
+ 195.4280ms,0.0V 195.4399ms,0.0
+ 195.4400ms,3.3V 195.4479ms,3.3
+ 195.4480ms,0.0V 195.4599ms,0.0
+ 195.4600ms,3.3V 195.4679ms,3.3
+ 195.4680ms,0.0V 195.4799ms,0.0
+ 195.4800ms,3.3V 195.4879ms,3.3
+ 195.4880ms,0.0V 195.4999ms,0.0
+ 195.5000ms,3.3V 195.5079ms,3.3
+ 195.5080ms,0.0V 195.5199ms,0.0
+ 195.5200ms,3.3V 195.5279ms,3.3
+ 195.5280ms,0.0V 195.5399ms,0.0
+ 195.5400ms,3.3V 195.5479ms,3.3
+ 195.5480ms,0.0V 195.5599ms,0.0
+ 195.5600ms,3.3V 195.5679ms,3.3
+ 195.5680ms,0.0V 195.5799ms,0.0
+ 195.5800ms,3.3V 195.5879ms,3.3
+ 195.5880ms,0.0V 195.5999ms,0.0
+ 195.6000ms,3.3V 195.6079ms,3.3
+ 195.6080ms,0.0V 195.6199ms,0.0
+ 195.6200ms,3.3V 195.6279ms,3.3
+ 195.6280ms,0.0V 195.6399ms,0.0
+ 195.6400ms,3.3V 195.6479ms,3.3
+ 195.6480ms,0.0V 195.6599ms,0.0
+ 195.6600ms,3.3V 195.6679ms,3.3
+ 195.6680ms,0.0V 195.6799ms,0.0
+ 195.6800ms,3.3V 195.6879ms,3.3
+ 195.6880ms,0.0V 195.6999ms,0.0
+ 195.7000ms,3.3V 195.7079ms,3.3
+ 195.7080ms,0.0V 195.7199ms,0.0
+ 195.7200ms,3.3V 195.7279ms,3.3
+ 195.7280ms,0.0V 195.7399ms,0.0
+ 195.7400ms,3.3V 195.7479ms,3.3
+ 195.7480ms,0.0V 195.7599ms,0.0
+ 195.7600ms,3.3V 195.7679ms,3.3
+ 195.7680ms,0.0V 195.7799ms,0.0
+ 195.7800ms,3.3V 195.7879ms,3.3
+ 195.7880ms,0.0V 195.7999ms,0.0
+ 195.8000ms,3.3V 195.8079ms,3.3
+ 195.8080ms,0.0V 195.8199ms,0.0
+ 195.8200ms,3.3V 195.8279ms,3.3
+ 195.8280ms,0.0V 195.8399ms,0.0
+ 195.8400ms,3.3V 195.8479ms,3.3
+ 195.8480ms,0.0V 195.8599ms,0.0
+ 195.8600ms,3.3V 195.8679ms,3.3
+ 195.8680ms,0.0V 195.8799ms,0.0
+ 195.8800ms,3.3V 195.8879ms,3.3
+ 195.8880ms,0.0V 195.8999ms,0.0
+ 195.9000ms,3.3V 195.9079ms,3.3
+ 195.9080ms,0.0V 195.9199ms,0.0
+ 195.9200ms,3.3V 195.9279ms,3.3
+ 195.9280ms,0.0V 195.9399ms,0.0
+ 195.9400ms,3.3V 195.9479ms,3.3
+ 195.9480ms,0.0V 195.9599ms,0.0
+ 195.9600ms,3.3V 195.9679ms,3.3
+ 195.9680ms,0.0V 195.9799ms,0.0
+ 195.9800ms,3.3V 195.9879ms,3.3
+ 195.9880ms,0.0V 195.9999ms,0.0
+ 196.0000ms,3.3V 196.0079ms,3.3
+ 196.0080ms,0.0V 196.0199ms,0.0
+ 196.0200ms,3.3V 196.0279ms,3.3
+ 196.0280ms,0.0V 196.0399ms,0.0
+ 196.0400ms,3.3V 196.0479ms,3.3
+ 196.0480ms,0.0V 196.0599ms,0.0
+ 196.0600ms,3.3V 196.0679ms,3.3
+ 196.0680ms,0.0V 196.0799ms,0.0
+ 196.0800ms,3.3V 196.0879ms,3.3
+ 196.0880ms,0.0V 196.0999ms,0.0
+ 196.1000ms,3.3V 196.1079ms,3.3
+ 196.1080ms,0.0V 196.1199ms,0.0
+ 196.1200ms,3.3V 196.1279ms,3.3
+ 196.1280ms,0.0V 196.1399ms,0.0
+ 196.1400ms,3.3V 196.1479ms,3.3
+ 196.1480ms,0.0V 196.1599ms,0.0
+ 196.1600ms,3.3V 196.1679ms,3.3
+ 196.1680ms,0.0V 196.1799ms,0.0
+ 196.1800ms,3.3V 196.1879ms,3.3
+ 196.1880ms,0.0V 196.1999ms,0.0
+ 196.2000ms,3.3V 196.2079ms,3.3
+ 196.2080ms,0.0V 196.2199ms,0.0
+ 196.2200ms,3.3V 196.2279ms,3.3
+ 196.2280ms,0.0V 196.2399ms,0.0
+ 196.2400ms,3.3V 196.2479ms,3.3
+ 196.2480ms,0.0V 196.2599ms,0.0
+ 196.2600ms,3.3V 196.2679ms,3.3
+ 196.2680ms,0.0V 196.2799ms,0.0
+ 196.2800ms,3.3V 196.2879ms,3.3
+ 196.2880ms,0.0V 196.2999ms,0.0
+ 196.3000ms,3.3V 196.3079ms,3.3
+ 196.3080ms,0.0V 196.3199ms,0.0
+ 196.3200ms,3.3V 196.3279ms,3.3
+ 196.3280ms,0.0V 196.3399ms,0.0
+ 196.3400ms,3.3V 196.3479ms,3.3
+ 196.3480ms,0.0V 196.3599ms,0.0
+ 196.3600ms,3.3V 196.3679ms,3.3
+ 196.3680ms,0.0V 196.3799ms,0.0
+ 196.3800ms,3.3V 196.3879ms,3.3
+ 196.3880ms,0.0V 196.3999ms,0.0
+ 196.4000ms,3.3V 196.4079ms,3.3
+ 196.4080ms,0.0V 196.4199ms,0.0
+ 196.4200ms,3.3V 196.4279ms,3.3
+ 196.4280ms,0.0V 196.4399ms,0.0
+ 196.4400ms,3.3V 196.4479ms,3.3
+ 196.4480ms,0.0V 196.4599ms,0.0
+ 196.4600ms,3.3V 196.4679ms,3.3
+ 196.4680ms,0.0V 196.4799ms,0.0
+ 196.4800ms,3.3V 196.4879ms,3.3
+ 196.4880ms,0.0V 196.4999ms,0.0
+ 196.5000ms,3.3V 196.5079ms,3.3
+ 196.5080ms,0.0V 196.5199ms,0.0
+ 196.5200ms,3.3V 196.5279ms,3.3
+ 196.5280ms,0.0V 196.5399ms,0.0
+ 196.5400ms,3.3V 196.5479ms,3.3
+ 196.5480ms,0.0V 196.5599ms,0.0
+ 196.5600ms,3.3V 196.5679ms,3.3
+ 196.5680ms,0.0V 196.5799ms,0.0
+ 196.5800ms,3.3V 196.5879ms,3.3
+ 196.5880ms,0.0V 196.5999ms,0.0
+ 196.6000ms,3.3V 196.6079ms,3.3
+ 196.6080ms,0.0V 196.6199ms,0.0
+ 196.6200ms,3.3V 196.6279ms,3.3
+ 196.6280ms,0.0V 196.6399ms,0.0
+ 196.6400ms,3.3V 196.6479ms,3.3
+ 196.6480ms,0.0V 196.6599ms,0.0
+ 196.6600ms,3.3V 196.6679ms,3.3
+ 196.6680ms,0.0V 196.6799ms,0.0
+ 196.6800ms,3.3V 196.6879ms,3.3
+ 196.6880ms,0.0V 196.6999ms,0.0
+ 196.7000ms,3.3V 196.7079ms,3.3
+ 196.7080ms,0.0V 196.7199ms,0.0
+ 196.7200ms,3.3V 196.7279ms,3.3
+ 196.7280ms,0.0V 196.7399ms,0.0
+ 196.7400ms,3.3V 196.7479ms,3.3
+ 196.7480ms,0.0V 196.7599ms,0.0
+ 196.7600ms,3.3V 196.7679ms,3.3
+ 196.7680ms,0.0V 196.7799ms,0.0
+ 196.7800ms,3.3V 196.7879ms,3.3
+ 196.7880ms,0.0V 196.7999ms,0.0
+ 196.8000ms,3.3V 196.8079ms,3.3
+ 196.8080ms,0.0V 196.8199ms,0.0
+ 196.8200ms,3.3V 196.8279ms,3.3
+ 196.8280ms,0.0V 196.8399ms,0.0
+ 196.8400ms,3.3V 196.8479ms,3.3
+ 196.8480ms,0.0V 196.8599ms,0.0
+ 196.8600ms,3.3V 196.8679ms,3.3
+ 196.8680ms,0.0V 196.8799ms,0.0
+ 196.8800ms,3.3V 196.8879ms,3.3
+ 196.8880ms,0.0V 196.8999ms,0.0
+ 196.9000ms,3.3V 196.9079ms,3.3
+ 196.9080ms,0.0V 196.9199ms,0.0
+ 196.9200ms,3.3V 196.9279ms,3.3
+ 196.9280ms,0.0V 196.9399ms,0.0
+ 196.9400ms,3.3V 196.9479ms,3.3
+ 196.9480ms,0.0V 196.9599ms,0.0
+ 196.9600ms,3.3V 196.9679ms,3.3
+ 196.9680ms,0.0V 196.9799ms,0.0
+ 196.9800ms,3.3V 196.9879ms,3.3
+ 196.9880ms,0.0V 196.9999ms,0.0
+ 197.0000ms,3.3V 197.0079ms,3.3
+ 197.0080ms,0.0V 197.0199ms,0.0
+ 197.0200ms,3.3V 197.0279ms,3.3
+ 197.0280ms,0.0V 197.0399ms,0.0
+ 197.0400ms,3.3V 197.0479ms,3.3
+ 197.0480ms,0.0V 197.0599ms,0.0
+ 197.0600ms,3.3V 197.0679ms,3.3
+ 197.0680ms,0.0V 197.0799ms,0.0
+ 197.0800ms,3.3V 197.0879ms,3.3
+ 197.0880ms,0.0V 197.0999ms,0.0
+ 197.1000ms,3.3V 197.1079ms,3.3
+ 197.1080ms,0.0V 197.1199ms,0.0
+ 197.1200ms,3.3V 197.1279ms,3.3
+ 197.1280ms,0.0V 197.1399ms,0.0
+ 197.1400ms,3.3V 197.1479ms,3.3
+ 197.1480ms,0.0V 197.1599ms,0.0
+ 197.1600ms,3.3V 197.1679ms,3.3
+ 197.1680ms,0.0V 197.1799ms,0.0
+ 197.1800ms,3.3V 197.1879ms,3.3
+ 197.1880ms,0.0V 197.1999ms,0.0
+ 197.2000ms,3.3V 197.2079ms,3.3
+ 197.2080ms,0.0V 197.2199ms,0.0
+ 197.2200ms,3.3V 197.2279ms,3.3
+ 197.2280ms,0.0V 197.2399ms,0.0
+ 197.2400ms,3.3V 197.2479ms,3.3
+ 197.2480ms,0.0V 197.2599ms,0.0
+ 197.2600ms,3.3V 197.2679ms,3.3
+ 197.2680ms,0.0V 197.2799ms,0.0
+ 197.2800ms,3.3V 197.2879ms,3.3
+ 197.2880ms,0.0V 197.2999ms,0.0
+ 197.3000ms,3.3V 197.3079ms,3.3
+ 197.3080ms,0.0V 197.3199ms,0.0
+ 197.3200ms,3.3V 197.3279ms,3.3
+ 197.3280ms,0.0V 197.3399ms,0.0
+ 197.3400ms,3.3V 197.3479ms,3.3
+ 197.3480ms,0.0V 197.3599ms,0.0
+ 197.3600ms,3.3V 197.3679ms,3.3
+ 197.3680ms,0.0V 197.3799ms,0.0
+ 197.3800ms,3.3V 197.3879ms,3.3
+ 197.3880ms,0.0V 197.3999ms,0.0
+ 197.4000ms,3.3V 197.4079ms,3.3
+ 197.4080ms,0.0V 197.4199ms,0.0
+ 197.4200ms,3.3V 197.4279ms,3.3
+ 197.4280ms,0.0V 197.4399ms,0.0
+ 197.4400ms,3.3V 197.4479ms,3.3
+ 197.4480ms,0.0V 197.4599ms,0.0
+ 197.4600ms,3.3V 197.4679ms,3.3
+ 197.4680ms,0.0V 197.4799ms,0.0
+ 197.4800ms,3.3V 197.4879ms,3.3
+ 197.4880ms,0.0V 197.4999ms,0.0
+ 197.5000ms,3.3V 197.5079ms,3.3
+ 197.5080ms,0.0V 197.5199ms,0.0
+ 197.5200ms,3.3V 197.5279ms,3.3
+ 197.5280ms,0.0V 197.5399ms,0.0
+ 197.5400ms,3.3V 197.5479ms,3.3
+ 197.5480ms,0.0V 197.5599ms,0.0
+ 197.5600ms,3.3V 197.5679ms,3.3
+ 197.5680ms,0.0V 197.5799ms,0.0
+ 197.5800ms,3.3V 197.5879ms,3.3
+ 197.5880ms,0.0V 197.5999ms,0.0
+ 197.6000ms,3.3V 197.6079ms,3.3
+ 197.6080ms,0.0V 197.6199ms,0.0
+ 197.6200ms,3.3V 197.6279ms,3.3
+ 197.6280ms,0.0V 197.6399ms,0.0
+ 197.6400ms,3.3V 197.6479ms,3.3
+ 197.6480ms,0.0V 197.6599ms,0.0
+ 197.6600ms,3.3V 197.6679ms,3.3
+ 197.6680ms,0.0V 197.6799ms,0.0
+ 197.6800ms,3.3V 197.6879ms,3.3
+ 197.6880ms,0.0V 197.6999ms,0.0
+ 197.7000ms,3.3V 197.7079ms,3.3
+ 197.7080ms,0.0V 197.7199ms,0.0
+ 197.7200ms,3.3V 197.7279ms,3.3
+ 197.7280ms,0.0V 197.7399ms,0.0
+ 197.7400ms,3.3V 197.7479ms,3.3
+ 197.7480ms,0.0V 197.7599ms,0.0
+ 197.7600ms,3.3V 197.7679ms,3.3
+ 197.7680ms,0.0V 197.7799ms,0.0
+ 197.7800ms,3.3V 197.7879ms,3.3
+ 197.7880ms,0.0V 197.7999ms,0.0
+ 197.8000ms,3.3V 197.8079ms,3.3
+ 197.8080ms,0.0V 197.8199ms,0.0
+ 197.8200ms,3.3V 197.8279ms,3.3
+ 197.8280ms,0.0V 197.8399ms,0.0
+ 197.8400ms,3.3V 197.8479ms,3.3
+ 197.8480ms,0.0V 197.8599ms,0.0
+ 197.8600ms,3.3V 197.8679ms,3.3
+ 197.8680ms,0.0V 197.8799ms,0.0
+ 197.8800ms,3.3V 197.8879ms,3.3
+ 197.8880ms,0.0V 197.8999ms,0.0
+ 197.9000ms,3.3V 197.9079ms,3.3
+ 197.9080ms,0.0V 197.9199ms,0.0
+ 197.9200ms,3.3V 197.9279ms,3.3
+ 197.9280ms,0.0V 197.9399ms,0.0
+ 197.9400ms,3.3V 197.9479ms,3.3
+ 197.9480ms,0.0V 197.9599ms,0.0
+ 197.9600ms,3.3V 197.9679ms,3.3
+ 197.9680ms,0.0V 197.9799ms,0.0
+ 197.9800ms,3.3V 197.9879ms,3.3
+ 197.9880ms,0.0V 197.9999ms,0.0
+ 198.0000ms,3.3V 198.0079ms,3.3
+ 198.0080ms,0.0V 198.0199ms,0.0
+ 198.0200ms,3.3V 198.0279ms,3.3
+ 198.0280ms,0.0V 198.0399ms,0.0
+ 198.0400ms,3.3V 198.0479ms,3.3
+ 198.0480ms,0.0V 198.0599ms,0.0
+ 198.0600ms,3.3V 198.0679ms,3.3
+ 198.0680ms,0.0V 198.0799ms,0.0
+ 198.0800ms,3.3V 198.0879ms,3.3
+ 198.0880ms,0.0V 198.0999ms,0.0
+ 198.1000ms,3.3V 198.1079ms,3.3
+ 198.1080ms,0.0V 198.1199ms,0.0
+ 198.1200ms,3.3V 198.1279ms,3.3
+ 198.1280ms,0.0V 198.1399ms,0.0
+ 198.1400ms,3.3V 198.1479ms,3.3
+ 198.1480ms,0.0V 198.1599ms,0.0
+ 198.1600ms,3.3V 198.1679ms,3.3
+ 198.1680ms,0.0V 198.1799ms,0.0
+ 198.1800ms,3.3V 198.1879ms,3.3
+ 198.1880ms,0.0V 198.1999ms,0.0
+ 198.2000ms,3.3V 198.2079ms,3.3
+ 198.2080ms,0.0V 198.2199ms,0.0
+ 198.2200ms,3.3V 198.2279ms,3.3
+ 198.2280ms,0.0V 198.2399ms,0.0
+ 198.2400ms,3.3V 198.2479ms,3.3
+ 198.2480ms,0.0V 198.2599ms,0.0
+ 198.2600ms,3.3V 198.2679ms,3.3
+ 198.2680ms,0.0V 198.2799ms,0.0
+ 198.2800ms,3.3V 198.2879ms,3.3
+ 198.2880ms,0.0V 198.2999ms,0.0
+ 198.3000ms,3.3V 198.3079ms,3.3
+ 198.3080ms,0.0V 198.3199ms,0.0
+ 198.3200ms,3.3V 198.3279ms,3.3
+ 198.3280ms,0.0V 198.3399ms,0.0
+ 198.3400ms,3.3V 198.3479ms,3.3
+ 198.3480ms,0.0V 198.3599ms,0.0
+ 198.3600ms,3.3V 198.3679ms,3.3
+ 198.3680ms,0.0V 198.3799ms,0.0
+ 198.3800ms,3.3V 198.3879ms,3.3
+ 198.3880ms,0.0V 198.3999ms,0.0
+ 198.4000ms,3.3V 198.4079ms,3.3
+ 198.4080ms,0.0V 198.4199ms,0.0
+ 198.4200ms,3.3V 198.4279ms,3.3
+ 198.4280ms,0.0V 198.4399ms,0.0
+ 198.4400ms,3.3V 198.4479ms,3.3
+ 198.4480ms,0.0V 198.4599ms,0.0
+ 198.4600ms,3.3V 198.4679ms,3.3
+ 198.4680ms,0.0V 198.4799ms,0.0
+ 198.4800ms,3.3V 198.4879ms,3.3
+ 198.4880ms,0.0V 198.4999ms,0.0
+ 198.5000ms,3.3V 198.5079ms,3.3
+ 198.5080ms,0.0V 198.5199ms,0.0
+ 198.5200ms,3.3V 198.5279ms,3.3
+ 198.5280ms,0.0V 198.5399ms,0.0
+ 198.5400ms,3.3V 198.5479ms,3.3
+ 198.5480ms,0.0V 198.5599ms,0.0
+ 198.5600ms,3.3V 198.5679ms,3.3
+ 198.5680ms,0.0V 198.5799ms,0.0
+ 198.5800ms,3.3V 198.5879ms,3.3
+ 198.5880ms,0.0V 198.5999ms,0.0
+ 198.6000ms,3.3V 198.6079ms,3.3
+ 198.6080ms,0.0V 198.6199ms,0.0
+ 198.6200ms,3.3V 198.6279ms,3.3
+ 198.6280ms,0.0V 198.6399ms,0.0
+ 198.6400ms,3.3V 198.6479ms,3.3
+ 198.6480ms,0.0V 198.6599ms,0.0
+ 198.6600ms,3.3V 198.6679ms,3.3
+ 198.6680ms,0.0V 198.6799ms,0.0
+ 198.6800ms,3.3V 198.6879ms,3.3
+ 198.6880ms,0.0V 198.6999ms,0.0
+ 198.7000ms,3.3V 198.7079ms,3.3
+ 198.7080ms,0.0V 198.7199ms,0.0
+ 198.7200ms,3.3V 198.7279ms,3.3
+ 198.7280ms,0.0V 198.7399ms,0.0
+ 198.7400ms,3.3V 198.7479ms,3.3
+ 198.7480ms,0.0V 198.7599ms,0.0
+ 198.7600ms,3.3V 198.7679ms,3.3
+ 198.7680ms,0.0V 198.7799ms,0.0
+ 198.7800ms,3.3V 198.7879ms,3.3
+ 198.7880ms,0.0V 198.7999ms,0.0
+ 198.8000ms,3.3V 198.8079ms,3.3
+ 198.8080ms,0.0V 198.8199ms,0.0
+ 198.8200ms,3.3V 198.8279ms,3.3
+ 198.8280ms,0.0V 198.8399ms,0.0
+ 198.8400ms,3.3V 198.8479ms,3.3
+ 198.8480ms,0.0V 198.8599ms,0.0
+ 198.8600ms,3.3V 198.8679ms,3.3
+ 198.8680ms,0.0V 198.8799ms,0.0
+ 198.8800ms,3.3V 198.8879ms,3.3
+ 198.8880ms,0.0V 198.8999ms,0.0
+ 198.9000ms,3.3V 198.9079ms,3.3
+ 198.9080ms,0.0V 198.9199ms,0.0
+ 198.9200ms,3.3V 198.9279ms,3.3
+ 198.9280ms,0.0V 198.9399ms,0.0
+ 198.9400ms,3.3V 198.9479ms,3.3
+ 198.9480ms,0.0V 198.9599ms,0.0
+ 198.9600ms,3.3V 198.9679ms,3.3
+ 198.9680ms,0.0V 198.9799ms,0.0
+ 198.9800ms,3.3V 198.9879ms,3.3
+ 198.9880ms,0.0V 198.9999ms,0.0
+ 199.0000ms,3.3V 199.0079ms,3.3
+ 199.0080ms,0.0V 199.0199ms,0.0
+ 199.0200ms,3.3V 199.0279ms,3.3
+ 199.0280ms,0.0V 199.0399ms,0.0
+ 199.0400ms,3.3V 199.0479ms,3.3
+ 199.0480ms,0.0V 199.0599ms,0.0
+ 199.0600ms,3.3V 199.0679ms,3.3
+ 199.0680ms,0.0V 199.0799ms,0.0
+ 199.0800ms,3.3V 199.0879ms,3.3
+ 199.0880ms,0.0V 199.0999ms,0.0
+ 199.1000ms,3.3V 199.1079ms,3.3
+ 199.1080ms,0.0V 199.1199ms,0.0
+ 199.1200ms,3.3V 199.1279ms,3.3
+ 199.1280ms,0.0V 199.1399ms,0.0
+ 199.1400ms,3.3V 199.1479ms,3.3
+ 199.1480ms,0.0V 199.1599ms,0.0
+ 199.1600ms,3.3V 199.1679ms,3.3
+ 199.1680ms,0.0V 199.1799ms,0.0
+ 199.1800ms,3.3V 199.1879ms,3.3
+ 199.1880ms,0.0V 199.1999ms,0.0
+ 199.2000ms,3.3V 199.2079ms,3.3
+ 199.2080ms,0.0V 199.2199ms,0.0
+ 199.2200ms,3.3V 199.2279ms,3.3
+ 199.2280ms,0.0V 199.2399ms,0.0
+ 199.2400ms,3.3V 199.2479ms,3.3
+ 199.2480ms,0.0V 199.2599ms,0.0
+ 199.2600ms,3.3V 199.2679ms,3.3
+ 199.2680ms,0.0V 199.2799ms,0.0
+ 199.2800ms,3.3V 199.2879ms,3.3
+ 199.2880ms,0.0V 199.2999ms,0.0
+ 199.3000ms,3.3V 199.3079ms,3.3
+ 199.3080ms,0.0V 199.3199ms,0.0
+ 199.3200ms,3.3V 199.3279ms,3.3
+ 199.3280ms,0.0V 199.3399ms,0.0
+ 199.3400ms,3.3V 199.3479ms,3.3
+ 199.3480ms,0.0V 199.3599ms,0.0
+ 199.3600ms,3.3V 199.3679ms,3.3
+ 199.3680ms,0.0V 199.3799ms,0.0
+ 199.3800ms,3.3V 199.3879ms,3.3
+ 199.3880ms,0.0V 199.3999ms,0.0
+ 199.4000ms,3.3V 199.4079ms,3.3
+ 199.4080ms,0.0V 199.4199ms,0.0
+ 199.4200ms,3.3V 199.4279ms,3.3
+ 199.4280ms,0.0V 199.4399ms,0.0
+ 199.4400ms,3.3V 199.4479ms,3.3
+ 199.4480ms,0.0V 199.4599ms,0.0
+ 199.4600ms,3.3V 199.4679ms,3.3
+ 199.4680ms,0.0V 199.4799ms,0.0
+ 199.4800ms,3.3V 199.4879ms,3.3
+ 199.4880ms,0.0V 199.4999ms,0.0
+ 199.5000ms,3.3V 199.5079ms,3.3
+ 199.5080ms,0.0V 199.5199ms,0.0
+ 199.5200ms,3.3V 199.5279ms,3.3
+ 199.5280ms,0.0V 199.5399ms,0.0
+ 199.5400ms,3.3V 199.5479ms,3.3
+ 199.5480ms,0.0V 199.5599ms,0.0
+ 199.5600ms,3.3V 199.5679ms,3.3
+ 199.5680ms,0.0V 199.5799ms,0.0
+ 199.5800ms,3.3V 199.5879ms,3.3
+ 199.5880ms,0.0V 199.5999ms,0.0
+ 199.6000ms,3.3V 199.6079ms,3.3
+ 199.6080ms,0.0V 199.6199ms,0.0
+ 199.6200ms,3.3V 199.6279ms,3.3
+ 199.6280ms,0.0V 199.6399ms,0.0
+ 199.6400ms,3.3V 199.6479ms,3.3
+ 199.6480ms,0.0V 199.6599ms,0.0
+ 199.6600ms,3.3V 199.6679ms,3.3
+ 199.6680ms,0.0V 199.6799ms,0.0
+ 199.6800ms,3.3V 199.6879ms,3.3
+ 199.6880ms,0.0V 199.6999ms,0.0
+ 199.7000ms,3.3V 199.7079ms,3.3
+ 199.7080ms,0.0V 199.7199ms,0.0
+ 199.7200ms,3.3V 199.7279ms,3.3
+ 199.7280ms,0.0V 199.7399ms,0.0
+ 199.7400ms,3.3V 199.7479ms,3.3
+ 199.7480ms,0.0V 199.7599ms,0.0
+ 199.7600ms,3.3V 199.7679ms,3.3
+ 199.7680ms,0.0V 199.7799ms,0.0
+ 199.7800ms,3.3V 199.7879ms,3.3
+ 199.7880ms,0.0V 199.7999ms,0.0
+ 199.8000ms,3.3V 199.8079ms,3.3
+ 199.8080ms,0.0V 199.8199ms,0.0
+ 199.8200ms,3.3V 199.8279ms,3.3
+ 199.8280ms,0.0V 199.8399ms,0.0
+ 199.8400ms,3.3V 199.8479ms,3.3
+ 199.8480ms,0.0V 199.8599ms,0.0
+ 199.8600ms,3.3V 199.8679ms,3.3
+ 199.8680ms,0.0V 199.8799ms,0.0
+ 199.8800ms,3.3V 199.8879ms,3.3
+ 199.8880ms,0.0V 199.8999ms,0.0
+ 199.9000ms,3.3V 199.9079ms,3.3
+ 199.9080ms,0.0V 199.9199ms,0.0
+ 199.9200ms,3.3V 199.9279ms,3.3
+ 199.9280ms,0.0V 199.9399ms,0.0
+ 199.9400ms,3.3V 199.9479ms,3.3
+ 199.9480ms,0.0V 199.9599ms,0.0
+ 199.9600ms,3.3V 199.9679ms,3.3
+ 199.9680ms,0.0V 199.9799ms,0.0
+ 199.9800ms,3.3V 199.9879ms,3.3
+ 199.9880ms,0.0V 199.9999ms,0.0
+ 200.0000ms,3.3V 200.0079ms,3.3
+ 200.0080ms,0.0V 200.0199ms,0.0
+ 200.0200ms,3.3V 200.0279ms,3.3
+ 200.0280ms,0.0V 200.0399ms,0.0
+ 200.0400ms,3.3V 200.0479ms,3.3
+ 200.0480ms,0.0V 200.0599ms,0.0
+ 200.0600ms,3.3V 200.0679ms,3.3
+ 200.0680ms,0.0V 200.0799ms,0.0
+ 200.0800ms,3.3V 200.0879ms,3.3
+ 200.0880ms,0.0V 200.0999ms,0.0
+ 200.1000ms,3.3V 200.1079ms,3.3
+ 200.1080ms,0.0V 200.1199ms,0.0
+ 200.1200ms,3.3V 200.1279ms,3.3
+ 200.1280ms,0.0V 200.1399ms,0.0
+ 200.1400ms,3.3V 200.1479ms,3.3
+ 200.1480ms,0.0V 200.1599ms,0.0
+ 200.1600ms,3.3V 200.1679ms,3.3
+ 200.1680ms,0.0V 200.1799ms,0.0
+ 200.1800ms,3.3V 200.1879ms,3.3
+ 200.1880ms,0.0V 200.1999ms,0.0
+ 200.2000ms,3.3V 200.2079ms,3.3
+ 200.2080ms,0.0V 200.2199ms,0.0
+ 200.2200ms,3.3V 200.2279ms,3.3
+ 200.2280ms,0.0V 200.2399ms,0.0
+ 200.2400ms,3.3V 200.2479ms,3.3
+ 200.2480ms,0.0V 200.2599ms,0.0
+ 200.2600ms,3.3V 200.2679ms,3.3
+ 200.2680ms,0.0V 200.2799ms,0.0
+ 200.2800ms,3.3V 200.2879ms,3.3
+ 200.2880ms,0.0V 200.2999ms,0.0
+ 200.3000ms,3.3V 200.3079ms,3.3
+ 200.3080ms,0.0V 200.3199ms,0.0
+ 200.3200ms,3.3V 200.3279ms,3.3
+ 200.3280ms,0.0V 200.3399ms,0.0
+ 200.3400ms,3.3V 200.3479ms,3.3
+ 200.3480ms,0.0V 200.3599ms,0.0
+ 200.3600ms,3.3V 200.3681ms,3.3
+ 200.3682ms,0.0V 200.3799ms,0.0
+ 200.3800ms,3.3V 200.3881ms,3.3
+ 200.3882ms,0.0V 200.3999ms,0.0
+ 200.4000ms,3.3V 200.4081ms,3.3
+ 200.4082ms,0.0V 200.4199ms,0.0
+ 200.4200ms,3.3V 200.4281ms,3.3
+ 200.4282ms,0.0V 200.4399ms,0.0
+ 200.4400ms,3.3V 200.4481ms,3.3
+ 200.4482ms,0.0V 200.4599ms,0.0
+ 200.4600ms,3.3V 200.4681ms,3.3
+ 200.4682ms,0.0V 200.4799ms,0.0
+ 200.4800ms,3.3V 200.4881ms,3.3
+ 200.4882ms,0.0V 200.4999ms,0.0
+ 200.5000ms,3.3V 200.5081ms,3.3
+ 200.5082ms,0.0V 200.5199ms,0.0
+ 200.5200ms,3.3V 200.5281ms,3.3
+ 200.5282ms,0.0V 200.5399ms,0.0
+ 200.5400ms,3.3V 200.5481ms,3.3
+ 200.5482ms,0.0V 200.5599ms,0.0
+ 200.5600ms,3.3V 200.5681ms,3.3
+ 200.5682ms,0.0V 200.5799ms,0.0
+ 200.5800ms,3.3V 200.5881ms,3.3
+ 200.5882ms,0.0V 200.5999ms,0.0
+ 200.6000ms,3.3V 200.6081ms,3.3
+ 200.6082ms,0.0V 200.6199ms,0.0
+ 200.6200ms,3.3V 200.6281ms,3.3
+ 200.6282ms,0.0V 200.6399ms,0.0
+ 200.6400ms,3.3V 200.6481ms,3.3
+ 200.6482ms,0.0V 200.6599ms,0.0
+ 200.6600ms,3.3V 200.6681ms,3.3
+ 200.6682ms,0.0V 200.6799ms,0.0
+ 200.6800ms,3.3V 200.6881ms,3.3
+ 200.6882ms,0.0V 200.6999ms,0.0
+ 200.7000ms,3.3V 200.7081ms,3.3
+ 200.7082ms,0.0V 200.7199ms,0.0
+ 200.7200ms,3.3V 200.7281ms,3.3
+ 200.7282ms,0.0V 200.7399ms,0.0
+ 200.7400ms,3.3V 200.7481ms,3.3
+ 200.7482ms,0.0V 200.7599ms,0.0
+ 200.7600ms,3.3V 200.7681ms,3.3
+ 200.7682ms,0.0V 200.7799ms,0.0
+ 200.7800ms,3.3V 200.7881ms,3.3
+ 200.7882ms,0.0V 200.7999ms,0.0
+ 200.8000ms,3.3V 200.8081ms,3.3
+ 200.8082ms,0.0V 200.8199ms,0.0
+ 200.8200ms,3.3V 200.8281ms,3.3
+ 200.8282ms,0.0V 200.8399ms,0.0
+ 200.8400ms,3.3V 200.8481ms,3.3
+ 200.8482ms,0.0V 200.8599ms,0.0
+ 200.8600ms,3.3V 200.8681ms,3.3
+ 200.8682ms,0.0V 200.8799ms,0.0
+ 200.8800ms,3.3V 200.8881ms,3.3
+ 200.8882ms,0.0V 200.8999ms,0.0
+ 200.9000ms,3.3V 200.9081ms,3.3
+ 200.9082ms,0.0V 200.9199ms,0.0
+ 200.9200ms,3.3V 200.9281ms,3.3
+ 200.9282ms,0.0V 200.9399ms,0.0
+ 200.9400ms,3.3V 200.9481ms,3.3
+ 200.9482ms,0.0V 200.9599ms,0.0
+ 200.9600ms,3.3V 200.9681ms,3.3
+ 200.9682ms,0.0V 200.9799ms,0.0
+ 200.9800ms,3.3V 200.9881ms,3.3
+ 200.9882ms,0.0V 200.9999ms,0.0
+ 201.0000ms,3.3V 201.0081ms,3.3
+ 201.0082ms,0.0V 201.0199ms,0.0
+ 201.0200ms,3.3V 201.0281ms,3.3
+ 201.0282ms,0.0V 201.0399ms,0.0
+ 201.0400ms,3.3V 201.0481ms,3.3
+ 201.0482ms,0.0V 201.0599ms,0.0
+ 201.0600ms,3.3V 201.0681ms,3.3
+ 201.0682ms,0.0V 201.0799ms,0.0
+ 201.0800ms,3.3V 201.0881ms,3.3
+ 201.0882ms,0.0V 201.0999ms,0.0
+ 201.1000ms,3.3V 201.1081ms,3.3
+ 201.1082ms,0.0V 201.1199ms,0.0
+ 201.1200ms,3.3V 201.1281ms,3.3
+ 201.1282ms,0.0V 201.1399ms,0.0
+ 201.1400ms,3.3V 201.1481ms,3.3
+ 201.1482ms,0.0V 201.1599ms,0.0
+ 201.1600ms,3.3V 201.1681ms,3.3
+ 201.1682ms,0.0V 201.1799ms,0.0
+ 201.1800ms,3.3V 201.1881ms,3.3
+ 201.1882ms,0.0V 201.1999ms,0.0
+ 201.2000ms,3.3V 201.2081ms,3.3
+ 201.2082ms,0.0V 201.2199ms,0.0
+ 201.2200ms,3.3V 201.2281ms,3.3
+ 201.2282ms,0.0V 201.2399ms,0.0
+ 201.2400ms,3.3V 201.2481ms,3.3
+ 201.2482ms,0.0V 201.2599ms,0.0
+ 201.2600ms,3.3V 201.2681ms,3.3
+ 201.2682ms,0.0V 201.2799ms,0.0
+ 201.2800ms,3.3V 201.2881ms,3.3
+ 201.2882ms,0.0V 201.2999ms,0.0
+ 201.3000ms,3.3V 201.3081ms,3.3
+ 201.3082ms,0.0V 201.3199ms,0.0
+ 201.3200ms,3.3V 201.3281ms,3.3
+ 201.3282ms,0.0V 201.3399ms,0.0
+ 201.3400ms,3.3V 201.3481ms,3.3
+ 201.3482ms,0.0V 201.3599ms,0.0
+ 201.3600ms,3.3V 201.3681ms,3.3
+ 201.3682ms,0.0V 201.3799ms,0.0
+ 201.3800ms,3.3V 201.3881ms,3.3
+ 201.3882ms,0.0V 201.3999ms,0.0
+ 201.4000ms,3.3V 201.4081ms,3.3
+ 201.4082ms,0.0V 201.4199ms,0.0
+ 201.4200ms,3.3V 201.4281ms,3.3
+ 201.4282ms,0.0V 201.4399ms,0.0
+ 201.4400ms,3.3V 201.4481ms,3.3
+ 201.4482ms,0.0V 201.4599ms,0.0
+ 201.4600ms,3.3V 201.4681ms,3.3
+ 201.4682ms,0.0V 201.4799ms,0.0
+ 201.4800ms,3.3V 201.4881ms,3.3
+ 201.4882ms,0.0V 201.4999ms,0.0
+ 201.5000ms,3.3V 201.5081ms,3.3
+ 201.5082ms,0.0V 201.5199ms,0.0
+ 201.5200ms,3.3V 201.5281ms,3.3
+ 201.5282ms,0.0V 201.5399ms,0.0
+ 201.5400ms,3.3V 201.5481ms,3.3
+ 201.5482ms,0.0V 201.5599ms,0.0
+ 201.5600ms,3.3V 201.5681ms,3.3
+ 201.5682ms,0.0V 201.5799ms,0.0
+ 201.5800ms,3.3V 201.5881ms,3.3
+ 201.5882ms,0.0V 201.5999ms,0.0
+ 201.6000ms,3.3V 201.6081ms,3.3
+ 201.6082ms,0.0V 201.6199ms,0.0
+ 201.6200ms,3.3V 201.6281ms,3.3
+ 201.6282ms,0.0V 201.6399ms,0.0
+ 201.6400ms,3.3V 201.6481ms,3.3
+ 201.6482ms,0.0V 201.6599ms,0.0
+ 201.6600ms,3.3V 201.6681ms,3.3
+ 201.6682ms,0.0V 201.6799ms,0.0
+ 201.6800ms,3.3V 201.6881ms,3.3
+ 201.6882ms,0.0V 201.6999ms,0.0
+ 201.7000ms,3.3V 201.7081ms,3.3
+ 201.7082ms,0.0V 201.7199ms,0.0
+ 201.7200ms,3.3V 201.7281ms,3.3
+ 201.7282ms,0.0V 201.7399ms,0.0
+ 201.7400ms,3.3V 201.7481ms,3.3
+ 201.7482ms,0.0V 201.7599ms,0.0
+ 201.7600ms,3.3V 201.7681ms,3.3
+ 201.7682ms,0.0V 201.7799ms,0.0
+ 201.7800ms,3.3V 201.7881ms,3.3
+ 201.7882ms,0.0V 201.7999ms,0.0
+ 201.8000ms,3.3V 201.8081ms,3.3
+ 201.8082ms,0.0V 201.8199ms,0.0
+ 201.8200ms,3.3V 201.8281ms,3.3
+ 201.8282ms,0.0V 201.8399ms,0.0
+ 201.8400ms,3.3V 201.8481ms,3.3
+ 201.8482ms,0.0V 201.8599ms,0.0
+ 201.8600ms,3.3V 201.8681ms,3.3
+ 201.8682ms,0.0V 201.8799ms,0.0
+ 201.8800ms,3.3V 201.8881ms,3.3
+ 201.8882ms,0.0V 201.8999ms,0.0
+ 201.9000ms,3.3V 201.9081ms,3.3
+ 201.9082ms,0.0V 201.9199ms,0.0
+ 201.9200ms,3.3V 201.9281ms,3.3
+ 201.9282ms,0.0V 201.9399ms,0.0
+ 201.9400ms,3.3V 201.9481ms,3.3
+ 201.9482ms,0.0V 201.9599ms,0.0
+ 201.9600ms,3.3V 201.9681ms,3.3
+ 201.9682ms,0.0V 201.9799ms,0.0
+ 201.9800ms,3.3V 201.9881ms,3.3
+ 201.9882ms,0.0V 201.9999ms,0.0
+ 202.0000ms,3.3V 202.0081ms,3.3
+ 202.0082ms,0.0V 202.0199ms,0.0
+ 202.0200ms,3.3V 202.0281ms,3.3
+ 202.0282ms,0.0V 202.0399ms,0.0
+ 202.0400ms,3.3V 202.0481ms,3.3
+ 202.0482ms,0.0V 202.0599ms,0.0
+ 202.0600ms,3.3V 202.0681ms,3.3
+ 202.0682ms,0.0V 202.0799ms,0.0
+ 202.0800ms,3.3V 202.0881ms,3.3
+ 202.0882ms,0.0V 202.0999ms,0.0
+ 202.1000ms,3.3V 202.1081ms,3.3
+ 202.1082ms,0.0V 202.1199ms,0.0
+ 202.1200ms,3.3V 202.1281ms,3.3
+ 202.1282ms,0.0V 202.1399ms,0.0
+ 202.1400ms,3.3V 202.1481ms,3.3
+ 202.1482ms,0.0V 202.1599ms,0.0
+ 202.1600ms,3.3V 202.1681ms,3.3
+ 202.1682ms,0.0V 202.1799ms,0.0
+ 202.1800ms,3.3V 202.1881ms,3.3
+ 202.1882ms,0.0V 202.1999ms,0.0
+ 202.2000ms,3.3V 202.2081ms,3.3
+ 202.2082ms,0.0V 202.2199ms,0.0
+ 202.2200ms,3.3V 202.2281ms,3.3
+ 202.2282ms,0.0V 202.2399ms,0.0
+ 202.2400ms,3.3V 202.2481ms,3.3
+ 202.2482ms,0.0V 202.2599ms,0.0
+ 202.2600ms,3.3V 202.2681ms,3.3
+ 202.2682ms,0.0V 202.2799ms,0.0
+ 202.2800ms,3.3V 202.2881ms,3.3
+ 202.2882ms,0.0V 202.2999ms,0.0
+ 202.3000ms,3.3V 202.3081ms,3.3
+ 202.3082ms,0.0V 202.3199ms,0.0
+ 202.3200ms,3.3V 202.3281ms,3.3
+ 202.3282ms,0.0V 202.3399ms,0.0
+ 202.3400ms,3.3V 202.3481ms,3.3
+ 202.3482ms,0.0V 202.3599ms,0.0
+ 202.3600ms,3.3V 202.3681ms,3.3
+ 202.3682ms,0.0V 202.3799ms,0.0
+ 202.3800ms,3.3V 202.3881ms,3.3
+ 202.3882ms,0.0V 202.3999ms,0.0
+ 202.4000ms,3.3V 202.4081ms,3.3
+ 202.4082ms,0.0V 202.4199ms,0.0
+ 202.4200ms,3.3V 202.4281ms,3.3
+ 202.4282ms,0.0V 202.4399ms,0.0
+ 202.4400ms,3.3V 202.4481ms,3.3
+ 202.4482ms,0.0V 202.4599ms,0.0
+ 202.4600ms,3.3V 202.4681ms,3.3
+ 202.4682ms,0.0V 202.4799ms,0.0
+ 202.4800ms,3.3V 202.4881ms,3.3
+ 202.4882ms,0.0V 202.4999ms,0.0
+ 202.5000ms,3.3V 202.5081ms,3.3
+ 202.5082ms,0.0V 202.5199ms,0.0
+ 202.5200ms,3.3V 202.5281ms,3.3
+ 202.5282ms,0.0V 202.5399ms,0.0
+ 202.5400ms,3.3V 202.5481ms,3.3
+ 202.5482ms,0.0V 202.5599ms,0.0
+ 202.5600ms,3.3V 202.5681ms,3.3
+ 202.5682ms,0.0V 202.5799ms,0.0
+ 202.5800ms,3.3V 202.5881ms,3.3
+ 202.5882ms,0.0V 202.5999ms,0.0
+ 202.6000ms,3.3V 202.6081ms,3.3
+ 202.6082ms,0.0V 202.6199ms,0.0
+ 202.6200ms,3.3V 202.6281ms,3.3
+ 202.6282ms,0.0V 202.6399ms,0.0
+ 202.6400ms,3.3V 202.6481ms,3.3
+ 202.6482ms,0.0V 202.6599ms,0.0
+ 202.6600ms,3.3V 202.6681ms,3.3
+ 202.6682ms,0.0V 202.6799ms,0.0
+ 202.6800ms,3.3V 202.6881ms,3.3
+ 202.6882ms,0.0V 202.6999ms,0.0
+ 202.7000ms,3.3V 202.7081ms,3.3
+ 202.7082ms,0.0V 202.7199ms,0.0
+ 202.7200ms,3.3V 202.7281ms,3.3
+ 202.7282ms,0.0V 202.7399ms,0.0
+ 202.7400ms,3.3V 202.7481ms,3.3
+ 202.7482ms,0.0V 202.7599ms,0.0
+ 202.7600ms,3.3V 202.7681ms,3.3
+ 202.7682ms,0.0V 202.7799ms,0.0
+ 202.7800ms,3.3V 202.7881ms,3.3
+ 202.7882ms,0.0V 202.7999ms,0.0
+ 202.8000ms,3.3V 202.8081ms,3.3
+ 202.8082ms,0.0V 202.8199ms,0.0
+ 202.8200ms,3.3V 202.8281ms,3.3
+ 202.8282ms,0.0V 202.8399ms,0.0
+ 202.8400ms,3.3V 202.8481ms,3.3
+ 202.8482ms,0.0V 202.8599ms,0.0
+ 202.8600ms,3.3V 202.8681ms,3.3
+ 202.8682ms,0.0V 202.8799ms,0.0
+ 202.8800ms,3.3V 202.8881ms,3.3
+ 202.8882ms,0.0V 202.8999ms,0.0
+ 202.9000ms,3.3V 202.9081ms,3.3
+ 202.9082ms,0.0V 202.9199ms,0.0
+ 202.9200ms,3.3V 202.9281ms,3.3
+ 202.9282ms,0.0V 202.9399ms,0.0
+ 202.9400ms,3.3V 202.9481ms,3.3
+ 202.9482ms,0.0V 202.9599ms,0.0
+ 202.9600ms,3.3V 202.9681ms,3.3
+ 202.9682ms,0.0V 202.9799ms,0.0
+ 202.9800ms,3.3V 202.9881ms,3.3
+ 202.9882ms,0.0V 202.9999ms,0.0
+ 203.0000ms,3.3V 203.0081ms,3.3
+ 203.0082ms,0.0V 203.0199ms,0.0
+ 203.0200ms,3.3V 203.0281ms,3.3
+ 203.0282ms,0.0V 203.0399ms,0.0
+ 203.0400ms,3.3V 203.0481ms,3.3
+ 203.0482ms,0.0V 203.0599ms,0.0
+ 203.0600ms,3.3V 203.0681ms,3.3
+ 203.0682ms,0.0V 203.0799ms,0.0
+ 203.0800ms,3.3V 203.0881ms,3.3
+ 203.0882ms,0.0V 203.0999ms,0.0
+ 203.1000ms,3.3V 203.1081ms,3.3
+ 203.1082ms,0.0V 203.1199ms,0.0
+ 203.1200ms,3.3V 203.1281ms,3.3
+ 203.1282ms,0.0V 203.1399ms,0.0
+ 203.1400ms,3.3V 203.1481ms,3.3
+ 203.1482ms,0.0V 203.1599ms,0.0
+ 203.1600ms,3.3V 203.1681ms,3.3
+ 203.1682ms,0.0V 203.1799ms,0.0
+ 203.1800ms,3.3V 203.1881ms,3.3
+ 203.1882ms,0.0V 203.1999ms,0.0
+ 203.2000ms,3.3V 203.2081ms,3.3
+ 203.2082ms,0.0V 203.2199ms,0.0
+ 203.2200ms,3.3V 203.2281ms,3.3
+ 203.2282ms,0.0V 203.2399ms,0.0
+ 203.2400ms,3.3V 203.2481ms,3.3
+ 203.2482ms,0.0V 203.2599ms,0.0
+ 203.2600ms,3.3V 203.2681ms,3.3
+ 203.2682ms,0.0V 203.2799ms,0.0
+ 203.2800ms,3.3V 203.2881ms,3.3
+ 203.2882ms,0.0V 203.2999ms,0.0
+ 203.3000ms,3.3V 203.3081ms,3.3
+ 203.3082ms,0.0V 203.3199ms,0.0
+ 203.3200ms,3.3V 203.3281ms,3.3
+ 203.3282ms,0.0V 203.3399ms,0.0
+ 203.3400ms,3.3V 203.3481ms,3.3
+ 203.3482ms,0.0V 203.3599ms,0.0
+ 203.3600ms,3.3V 203.3681ms,3.3
+ 203.3682ms,0.0V 203.3799ms,0.0
+ 203.3800ms,3.3V 203.3881ms,3.3
+ 203.3882ms,0.0V 203.3999ms,0.0
+ 203.4000ms,3.3V 203.4081ms,3.3
+ 203.4082ms,0.0V 203.4199ms,0.0
+ 203.4200ms,3.3V 203.4281ms,3.3
+ 203.4282ms,0.0V 203.4399ms,0.0
+ 203.4400ms,3.3V 203.4481ms,3.3
+ 203.4482ms,0.0V 203.4599ms,0.0
+ 203.4600ms,3.3V 203.4681ms,3.3
+ 203.4682ms,0.0V 203.4799ms,0.0
+ 203.4800ms,3.3V 203.4881ms,3.3
+ 203.4882ms,0.0V 203.4999ms,0.0
+ 203.5000ms,3.3V 203.5081ms,3.3
+ 203.5082ms,0.0V 203.5199ms,0.0
+ 203.5200ms,3.3V 203.5281ms,3.3
+ 203.5282ms,0.0V 203.5399ms,0.0
+ 203.5400ms,3.3V 203.5481ms,3.3
+ 203.5482ms,0.0V 203.5599ms,0.0
+ 203.5600ms,3.3V 203.5681ms,3.3
+ 203.5682ms,0.0V 203.5799ms,0.0
+ 203.5800ms,3.3V 203.5881ms,3.3
+ 203.5882ms,0.0V 203.5999ms,0.0
+ 203.6000ms,3.3V 203.6081ms,3.3
+ 203.6082ms,0.0V 203.6199ms,0.0
+ 203.6200ms,3.3V 203.6281ms,3.3
+ 203.6282ms,0.0V 203.6399ms,0.0
+ 203.6400ms,3.3V 203.6481ms,3.3
+ 203.6482ms,0.0V 203.6599ms,0.0
+ 203.6600ms,3.3V 203.6681ms,3.3
+ 203.6682ms,0.0V 203.6799ms,0.0
+ 203.6800ms,3.3V 203.6881ms,3.3
+ 203.6882ms,0.0V 203.6999ms,0.0
+ 203.7000ms,3.3V 203.7081ms,3.3
+ 203.7082ms,0.0V 203.7199ms,0.0
+ 203.7200ms,3.3V 203.7281ms,3.3
+ 203.7282ms,0.0V 203.7399ms,0.0
+ 203.7400ms,3.3V 203.7481ms,3.3
+ 203.7482ms,0.0V 203.7599ms,0.0
+ 203.7600ms,3.3V 203.7681ms,3.3
+ 203.7682ms,0.0V 203.7799ms,0.0
+ 203.7800ms,3.3V 203.7881ms,3.3
+ 203.7882ms,0.0V 203.7999ms,0.0
+ 203.8000ms,3.3V 203.8081ms,3.3
+ 203.8082ms,0.0V 203.8199ms,0.0
+ 203.8200ms,3.3V 203.8281ms,3.3
+ 203.8282ms,0.0V 203.8399ms,0.0
+ 203.8400ms,3.3V 203.8481ms,3.3
+ 203.8482ms,0.0V 203.8599ms,0.0
+ 203.8600ms,3.3V 203.8681ms,3.3
+ 203.8682ms,0.0V 203.8799ms,0.0
+ 203.8800ms,3.3V 203.8881ms,3.3
+ 203.8882ms,0.0V 203.8999ms,0.0
+ 203.9000ms,3.3V 203.9081ms,3.3
+ 203.9082ms,0.0V 203.9199ms,0.0
+ 203.9200ms,3.3V 203.9281ms,3.3
+ 203.9282ms,0.0V 203.9399ms,0.0
+ 203.9400ms,3.3V 203.9481ms,3.3
+ 203.9482ms,0.0V 203.9599ms,0.0
+ 203.9600ms,3.3V 203.9681ms,3.3
+ 203.9682ms,0.0V 203.9799ms,0.0
+ 203.9800ms,3.3V 203.9881ms,3.3
+ 203.9882ms,0.0V 203.9999ms,0.0
+ 204.0000ms,3.3V 204.0081ms,3.3
+ 204.0082ms,0.0V 204.0199ms,0.0
+ 204.0200ms,3.3V 204.0281ms,3.3
+ 204.0282ms,0.0V 204.0399ms,0.0
+ 204.0400ms,3.3V 204.0481ms,3.3
+ 204.0482ms,0.0V 204.0599ms,0.0
+ 204.0600ms,3.3V 204.0681ms,3.3
+ 204.0682ms,0.0V 204.0799ms,0.0
+ 204.0800ms,3.3V 204.0881ms,3.3
+ 204.0882ms,0.0V 204.0999ms,0.0
+ 204.1000ms,3.3V 204.1081ms,3.3
+ 204.1082ms,0.0V 204.1199ms,0.0
+ 204.1200ms,3.3V 204.1281ms,3.3
+ 204.1282ms,0.0V 204.1399ms,0.0
+ 204.1400ms,3.3V 204.1481ms,3.3
+ 204.1482ms,0.0V 204.1599ms,0.0
+ 204.1600ms,3.3V 204.1681ms,3.3
+ 204.1682ms,0.0V 204.1799ms,0.0
+ 204.1800ms,3.3V 204.1881ms,3.3
+ 204.1882ms,0.0V 204.1999ms,0.0
+ 204.2000ms,3.3V 204.2081ms,3.3
+ 204.2082ms,0.0V 204.2199ms,0.0
+ 204.2200ms,3.3V 204.2281ms,3.3
+ 204.2282ms,0.0V 204.2399ms,0.0
+ 204.2400ms,3.3V 204.2481ms,3.3
+ 204.2482ms,0.0V 204.2599ms,0.0
+ 204.2600ms,3.3V 204.2681ms,3.3
+ 204.2682ms,0.0V 204.2799ms,0.0
+ 204.2800ms,3.3V 204.2881ms,3.3
+ 204.2882ms,0.0V 204.2999ms,0.0
+ 204.3000ms,3.3V 204.3081ms,3.3
+ 204.3082ms,0.0V 204.3199ms,0.0
+ 204.3200ms,3.3V 204.3281ms,3.3
+ 204.3282ms,0.0V 204.3399ms,0.0
+ 204.3400ms,3.3V 204.3481ms,3.3
+ 204.3482ms,0.0V 204.3599ms,0.0
+ 204.3600ms,3.3V 204.3681ms,3.3
+ 204.3682ms,0.0V 204.3799ms,0.0
+ 204.3800ms,3.3V 204.3881ms,3.3
+ 204.3882ms,0.0V 204.3999ms,0.0
+ 204.4000ms,3.3V 204.4081ms,3.3
+ 204.4082ms,0.0V 204.4199ms,0.0
+ 204.4200ms,3.3V 204.4281ms,3.3
+ 204.4282ms,0.0V 204.4399ms,0.0
+ 204.4400ms,3.3V 204.4481ms,3.3
+ 204.4482ms,0.0V 204.4599ms,0.0
+ 204.4600ms,3.3V 204.4681ms,3.3
+ 204.4682ms,0.0V 204.4799ms,0.0
+ 204.4800ms,3.3V 204.4881ms,3.3
+ 204.4882ms,0.0V 204.4999ms,0.0
+ 204.5000ms,3.3V 204.5081ms,3.3
+ 204.5082ms,0.0V 204.5199ms,0.0
+ 204.5200ms,3.3V 204.5281ms,3.3
+ 204.5282ms,0.0V 204.5399ms,0.0
+ 204.5400ms,3.3V 204.5481ms,3.3
+ 204.5482ms,0.0V 204.5599ms,0.0
+ 204.5600ms,3.3V 204.5681ms,3.3
+ 204.5682ms,0.0V 204.5799ms,0.0
+ 204.5800ms,3.3V 204.5881ms,3.3
+ 204.5882ms,0.0V 204.5999ms,0.0
+ 204.6000ms,3.3V 204.6081ms,3.3
+ 204.6082ms,0.0V 204.6199ms,0.0
+ 204.6200ms,3.3V 204.6281ms,3.3
+ 204.6282ms,0.0V 204.6399ms,0.0
+ 204.6400ms,3.3V 204.6481ms,3.3
+ 204.6482ms,0.0V 204.6599ms,0.0
+ 204.6600ms,3.3V 204.6681ms,3.3
+ 204.6682ms,0.0V 204.6799ms,0.0
+ 204.6800ms,3.3V 204.6881ms,3.3
+ 204.6882ms,0.0V 204.6999ms,0.0
+ 204.7000ms,3.3V 204.7081ms,3.3
+ 204.7082ms,0.0V 204.7199ms,0.0
+ 204.7200ms,3.3V 204.7281ms,3.3
+ 204.7282ms,0.0V 204.7399ms,0.0
+ 204.7400ms,3.3V 204.7481ms,3.3
+ 204.7482ms,0.0V 204.7599ms,0.0
+ 204.7600ms,3.3V 204.7681ms,3.3
+ 204.7682ms,0.0V 204.7799ms,0.0
+ 204.7800ms,3.3V 204.7881ms,3.3
+ 204.7882ms,0.0V 204.7999ms,0.0
+ 204.8000ms,3.3V 204.8081ms,3.3
+ 204.8082ms,0.0V 204.8199ms,0.0
+ 204.8200ms,3.3V 204.8281ms,3.3
+ 204.8282ms,0.0V 204.8399ms,0.0
+ 204.8400ms,3.3V 204.8481ms,3.3
+ 204.8482ms,0.0V 204.8599ms,0.0
+ 204.8600ms,3.3V 204.8681ms,3.3
+ 204.8682ms,0.0V 204.8799ms,0.0
+ 204.8800ms,3.3V 204.8881ms,3.3
+ 204.8882ms,0.0V 204.8999ms,0.0
+ 204.9000ms,3.3V 204.9081ms,3.3
+ 204.9082ms,0.0V 204.9199ms,0.0
+ 204.9200ms,3.3V 204.9281ms,3.3
+ 204.9282ms,0.0V 204.9399ms,0.0
+ 204.9400ms,3.3V 204.9481ms,3.3
+ 204.9482ms,0.0V 204.9599ms,0.0
+ 204.9600ms,3.3V 204.9681ms,3.3
+ 204.9682ms,0.0V 204.9799ms,0.0
+ 204.9800ms,3.3V 204.9881ms,3.3
+ 204.9882ms,0.0V 204.9999ms,0.0
+ 205.0000ms,3.3V 205.0081ms,3.3
+ 205.0082ms,0.0V 205.0199ms,0.0
+ 205.0200ms,3.3V 205.0281ms,3.3
+ 205.0282ms,0.0V 205.0399ms,0.0
+ 205.0400ms,3.3V 205.0481ms,3.3
+ 205.0482ms,0.0V 205.0599ms,0.0
+ 205.0600ms,3.3V 205.0681ms,3.3
+ 205.0682ms,0.0V 205.0799ms,0.0
+ 205.0800ms,3.3V 205.0881ms,3.3
+ 205.0882ms,0.0V 205.0999ms,0.0
+ 205.1000ms,3.3V 205.1081ms,3.3
+ 205.1082ms,0.0V 205.1199ms,0.0
+ 205.1200ms,3.3V 205.1281ms,3.3
+ 205.1282ms,0.0V 205.1399ms,0.0
+ 205.1400ms,3.3V 205.1481ms,3.3
+ 205.1482ms,0.0V 205.1599ms,0.0
+ 205.1600ms,3.3V 205.1681ms,3.3
+ 205.1682ms,0.0V 205.1799ms,0.0
+ 205.1800ms,3.3V 205.1881ms,3.3
+ 205.1882ms,0.0V 205.1999ms,0.0
+ 205.2000ms,3.3V 205.2081ms,3.3
+ 205.2082ms,0.0V 205.2199ms,0.0
+ 205.2200ms,3.3V 205.2281ms,3.3
+ 205.2282ms,0.0V 205.2399ms,0.0
+ 205.2400ms,3.3V 205.2481ms,3.3
+ 205.2482ms,0.0V 205.2599ms,0.0
+ 205.2600ms,3.3V 205.2681ms,3.3
+ 205.2682ms,0.0V 205.2799ms,0.0
+ 205.2800ms,3.3V 205.2881ms,3.3
+ 205.2882ms,0.0V 205.2999ms,0.0
+ 205.3000ms,3.3V 205.3081ms,3.3
+ 205.3082ms,0.0V 205.3199ms,0.0
+ 205.3200ms,3.3V 205.3281ms,3.3
+ 205.3282ms,0.0V 205.3399ms,0.0
+ 205.3400ms,3.3V 205.3481ms,3.3
+ 205.3482ms,0.0V 205.3599ms,0.0
+ 205.3600ms,3.3V 205.3683ms,3.3
+ 205.3684ms,0.0V 205.3799ms,0.0
+ 205.3800ms,3.3V 205.3883ms,3.3
+ 205.3884ms,0.0V 205.3999ms,0.0
+ 205.4000ms,3.3V 205.4083ms,3.3
+ 205.4084ms,0.0V 205.4199ms,0.0
+ 205.4200ms,3.3V 205.4283ms,3.3
+ 205.4284ms,0.0V 205.4399ms,0.0
+ 205.4400ms,3.3V 205.4483ms,3.3
+ 205.4484ms,0.0V 205.4599ms,0.0
+ 205.4600ms,3.3V 205.4683ms,3.3
+ 205.4684ms,0.0V 205.4799ms,0.0
+ 205.4800ms,3.3V 205.4883ms,3.3
+ 205.4884ms,0.0V 205.4999ms,0.0
+ 205.5000ms,3.3V 205.5083ms,3.3
+ 205.5084ms,0.0V 205.5199ms,0.0
+ 205.5200ms,3.3V 205.5283ms,3.3
+ 205.5284ms,0.0V 205.5399ms,0.0
+ 205.5400ms,3.3V 205.5483ms,3.3
+ 205.5484ms,0.0V 205.5599ms,0.0
+ 205.5600ms,3.3V 205.5683ms,3.3
+ 205.5684ms,0.0V 205.5799ms,0.0
+ 205.5800ms,3.3V 205.5883ms,3.3
+ 205.5884ms,0.0V 205.5999ms,0.0
+ 205.6000ms,3.3V 205.6083ms,3.3
+ 205.6084ms,0.0V 205.6199ms,0.0
+ 205.6200ms,3.3V 205.6283ms,3.3
+ 205.6284ms,0.0V 205.6399ms,0.0
+ 205.6400ms,3.3V 205.6483ms,3.3
+ 205.6484ms,0.0V 205.6599ms,0.0
+ 205.6600ms,3.3V 205.6683ms,3.3
+ 205.6684ms,0.0V 205.6799ms,0.0
+ 205.6800ms,3.3V 205.6883ms,3.3
+ 205.6884ms,0.0V 205.6999ms,0.0
+ 205.7000ms,3.3V 205.7083ms,3.3
+ 205.7084ms,0.0V 205.7199ms,0.0
+ 205.7200ms,3.3V 205.7283ms,3.3
+ 205.7284ms,0.0V 205.7399ms,0.0
+ 205.7400ms,3.3V 205.7483ms,3.3
+ 205.7484ms,0.0V 205.7599ms,0.0
+ 205.7600ms,3.3V 205.7683ms,3.3
+ 205.7684ms,0.0V 205.7799ms,0.0
+ 205.7800ms,3.3V 205.7883ms,3.3
+ 205.7884ms,0.0V 205.7999ms,0.0
+ 205.8000ms,3.3V 205.8083ms,3.3
+ 205.8084ms,0.0V 205.8199ms,0.0
+ 205.8200ms,3.3V 205.8283ms,3.3
+ 205.8284ms,0.0V 205.8399ms,0.0
+ 205.8400ms,3.3V 205.8483ms,3.3
+ 205.8484ms,0.0V 205.8599ms,0.0
+ 205.8600ms,3.3V 205.8683ms,3.3
+ 205.8684ms,0.0V 205.8799ms,0.0
+ 205.8800ms,3.3V 205.8883ms,3.3
+ 205.8884ms,0.0V 205.8999ms,0.0
+ 205.9000ms,3.3V 205.9083ms,3.3
+ 205.9084ms,0.0V 205.9199ms,0.0
+ 205.9200ms,3.3V 205.9283ms,3.3
+ 205.9284ms,0.0V 205.9399ms,0.0
+ 205.9400ms,3.3V 205.9483ms,3.3
+ 205.9484ms,0.0V 205.9599ms,0.0
+ 205.9600ms,3.3V 205.9683ms,3.3
+ 205.9684ms,0.0V 205.9799ms,0.0
+ 205.9800ms,3.3V 205.9883ms,3.3
+ 205.9884ms,0.0V 205.9999ms,0.0
+ 206.0000ms,3.3V 206.0083ms,3.3
+ 206.0084ms,0.0V 206.0199ms,0.0
+ 206.0200ms,3.3V 206.0283ms,3.3
+ 206.0284ms,0.0V 206.0399ms,0.0
+ 206.0400ms,3.3V 206.0483ms,3.3
+ 206.0484ms,0.0V 206.0599ms,0.0
+ 206.0600ms,3.3V 206.0683ms,3.3
+ 206.0684ms,0.0V 206.0799ms,0.0
+ 206.0800ms,3.3V 206.0883ms,3.3
+ 206.0884ms,0.0V 206.0999ms,0.0
+ 206.1000ms,3.3V 206.1083ms,3.3
+ 206.1084ms,0.0V 206.1199ms,0.0
+ 206.1200ms,3.3V 206.1283ms,3.3
+ 206.1284ms,0.0V 206.1399ms,0.0
+ 206.1400ms,3.3V 206.1483ms,3.3
+ 206.1484ms,0.0V 206.1599ms,0.0
+ 206.1600ms,3.3V 206.1683ms,3.3
+ 206.1684ms,0.0V 206.1799ms,0.0
+ 206.1800ms,3.3V 206.1883ms,3.3
+ 206.1884ms,0.0V 206.1999ms,0.0
+ 206.2000ms,3.3V 206.2083ms,3.3
+ 206.2084ms,0.0V 206.2199ms,0.0
+ 206.2200ms,3.3V 206.2283ms,3.3
+ 206.2284ms,0.0V 206.2399ms,0.0
+ 206.2400ms,3.3V 206.2483ms,3.3
+ 206.2484ms,0.0V 206.2599ms,0.0
+ 206.2600ms,3.3V 206.2683ms,3.3
+ 206.2684ms,0.0V 206.2799ms,0.0
+ 206.2800ms,3.3V 206.2883ms,3.3
+ 206.2884ms,0.0V 206.2999ms,0.0
+ 206.3000ms,3.3V 206.3083ms,3.3
+ 206.3084ms,0.0V 206.3199ms,0.0
+ 206.3200ms,3.3V 206.3283ms,3.3
+ 206.3284ms,0.0V 206.3399ms,0.0
+ 206.3400ms,3.3V 206.3483ms,3.3
+ 206.3484ms,0.0V 206.3599ms,0.0
+ 206.3600ms,3.3V 206.3683ms,3.3
+ 206.3684ms,0.0V 206.3799ms,0.0
+ 206.3800ms,3.3V 206.3883ms,3.3
+ 206.3884ms,0.0V 206.3999ms,0.0
+ 206.4000ms,3.3V 206.4083ms,3.3
+ 206.4084ms,0.0V 206.4199ms,0.0
+ 206.4200ms,3.3V 206.4283ms,3.3
+ 206.4284ms,0.0V 206.4399ms,0.0
+ 206.4400ms,3.3V 206.4483ms,3.3
+ 206.4484ms,0.0V 206.4599ms,0.0
+ 206.4600ms,3.3V 206.4683ms,3.3
+ 206.4684ms,0.0V 206.4799ms,0.0
+ 206.4800ms,3.3V 206.4883ms,3.3
+ 206.4884ms,0.0V 206.4999ms,0.0
+ 206.5000ms,3.3V 206.5083ms,3.3
+ 206.5084ms,0.0V 206.5199ms,0.0
+ 206.5200ms,3.3V 206.5283ms,3.3
+ 206.5284ms,0.0V 206.5399ms,0.0
+ 206.5400ms,3.3V 206.5483ms,3.3
+ 206.5484ms,0.0V 206.5599ms,0.0
+ 206.5600ms,3.3V 206.5683ms,3.3
+ 206.5684ms,0.0V 206.5799ms,0.0
+ 206.5800ms,3.3V 206.5883ms,3.3
+ 206.5884ms,0.0V 206.5999ms,0.0
+ 206.6000ms,3.3V 206.6083ms,3.3
+ 206.6084ms,0.0V 206.6199ms,0.0
+ 206.6200ms,3.3V 206.6283ms,3.3
+ 206.6284ms,0.0V 206.6399ms,0.0
+ 206.6400ms,3.3V 206.6483ms,3.3
+ 206.6484ms,0.0V 206.6599ms,0.0
+ 206.6600ms,3.3V 206.6683ms,3.3
+ 206.6684ms,0.0V 206.6799ms,0.0
+ 206.6800ms,3.3V 206.6883ms,3.3
+ 206.6884ms,0.0V 206.6999ms,0.0
+ 206.7000ms,3.3V 206.7083ms,3.3
+ 206.7084ms,0.0V 206.7199ms,0.0
+ 206.7200ms,3.3V 206.7283ms,3.3
+ 206.7284ms,0.0V 206.7399ms,0.0
+ 206.7400ms,3.3V 206.7483ms,3.3
+ 206.7484ms,0.0V 206.7599ms,0.0
+ 206.7600ms,3.3V 206.7683ms,3.3
+ 206.7684ms,0.0V 206.7799ms,0.0
+ 206.7800ms,3.3V 206.7883ms,3.3
+ 206.7884ms,0.0V 206.7999ms,0.0
+ 206.8000ms,3.3V 206.8083ms,3.3
+ 206.8084ms,0.0V 206.8199ms,0.0
+ 206.8200ms,3.3V 206.8283ms,3.3
+ 206.8284ms,0.0V 206.8399ms,0.0
+ 206.8400ms,3.3V 206.8483ms,3.3
+ 206.8484ms,0.0V 206.8599ms,0.0
+ 206.8600ms,3.3V 206.8683ms,3.3
+ 206.8684ms,0.0V 206.8799ms,0.0
+ 206.8800ms,3.3V 206.8883ms,3.3
+ 206.8884ms,0.0V 206.8999ms,0.0
+ 206.9000ms,3.3V 206.9083ms,3.3
+ 206.9084ms,0.0V 206.9199ms,0.0
+ 206.9200ms,3.3V 206.9283ms,3.3
+ 206.9284ms,0.0V 206.9399ms,0.0
+ 206.9400ms,3.3V 206.9483ms,3.3
+ 206.9484ms,0.0V 206.9599ms,0.0
+ 206.9600ms,3.3V 206.9683ms,3.3
+ 206.9684ms,0.0V 206.9799ms,0.0
+ 206.9800ms,3.3V 206.9883ms,3.3
+ 206.9884ms,0.0V 206.9999ms,0.0
+ 207.0000ms,3.3V 207.0083ms,3.3
+ 207.0084ms,0.0V 207.0199ms,0.0
+ 207.0200ms,3.3V 207.0283ms,3.3
+ 207.0284ms,0.0V 207.0399ms,0.0
+ 207.0400ms,3.3V 207.0483ms,3.3
+ 207.0484ms,0.0V 207.0599ms,0.0
+ 207.0600ms,3.3V 207.0683ms,3.3
+ 207.0684ms,0.0V 207.0799ms,0.0
+ 207.0800ms,3.3V 207.0883ms,3.3
+ 207.0884ms,0.0V 207.0999ms,0.0
+ 207.1000ms,3.3V 207.1083ms,3.3
+ 207.1084ms,0.0V 207.1199ms,0.0
+ 207.1200ms,3.3V 207.1283ms,3.3
+ 207.1284ms,0.0V 207.1399ms,0.0
+ 207.1400ms,3.3V 207.1483ms,3.3
+ 207.1484ms,0.0V 207.1599ms,0.0
+ 207.1600ms,3.3V 207.1683ms,3.3
+ 207.1684ms,0.0V 207.1799ms,0.0
+ 207.1800ms,3.3V 207.1883ms,3.3
+ 207.1884ms,0.0V 207.1999ms,0.0
+ 207.2000ms,3.3V 207.2083ms,3.3
+ 207.2084ms,0.0V 207.2199ms,0.0
+ 207.2200ms,3.3V 207.2283ms,3.3
+ 207.2284ms,0.0V 207.2399ms,0.0
+ 207.2400ms,3.3V 207.2483ms,3.3
+ 207.2484ms,0.0V 207.2599ms,0.0
+ 207.2600ms,3.3V 207.2683ms,3.3
+ 207.2684ms,0.0V 207.2799ms,0.0
+ 207.2800ms,3.3V 207.2883ms,3.3
+ 207.2884ms,0.0V 207.2999ms,0.0
+ 207.3000ms,3.3V 207.3083ms,3.3
+ 207.3084ms,0.0V 207.3199ms,0.0
+ 207.3200ms,3.3V 207.3283ms,3.3
+ 207.3284ms,0.0V 207.3399ms,0.0
+ 207.3400ms,3.3V 207.3483ms,3.3
+ 207.3484ms,0.0V 207.3599ms,0.0
+ 207.3600ms,3.3V 207.3683ms,3.3
+ 207.3684ms,0.0V 207.3799ms,0.0
+ 207.3800ms,3.3V 207.3883ms,3.3
+ 207.3884ms,0.0V 207.3999ms,0.0
+ 207.4000ms,3.3V 207.4083ms,3.3
+ 207.4084ms,0.0V 207.4199ms,0.0
+ 207.4200ms,3.3V 207.4283ms,3.3
+ 207.4284ms,0.0V 207.4399ms,0.0
+ 207.4400ms,3.3V 207.4483ms,3.3
+ 207.4484ms,0.0V 207.4599ms,0.0
+ 207.4600ms,3.3V 207.4683ms,3.3
+ 207.4684ms,0.0V 207.4799ms,0.0
+ 207.4800ms,3.3V 207.4883ms,3.3
+ 207.4884ms,0.0V 207.4999ms,0.0
+ 207.5000ms,3.3V 207.5083ms,3.3
+ 207.5084ms,0.0V 207.5199ms,0.0
+ 207.5200ms,3.3V 207.5283ms,3.3
+ 207.5284ms,0.0V 207.5399ms,0.0
+ 207.5400ms,3.3V 207.5483ms,3.3
+ 207.5484ms,0.0V 207.5599ms,0.0
+ 207.5600ms,3.3V 207.5683ms,3.3
+ 207.5684ms,0.0V 207.5799ms,0.0
+ 207.5800ms,3.3V 207.5883ms,3.3
+ 207.5884ms,0.0V 207.5999ms,0.0
+ 207.6000ms,3.3V 207.6083ms,3.3
+ 207.6084ms,0.0V 207.6199ms,0.0
+ 207.6200ms,3.3V 207.6283ms,3.3
+ 207.6284ms,0.0V 207.6399ms,0.0
+ 207.6400ms,3.3V 207.6483ms,3.3
+ 207.6484ms,0.0V 207.6599ms,0.0
+ 207.6600ms,3.3V 207.6683ms,3.3
+ 207.6684ms,0.0V 207.6799ms,0.0
+ 207.6800ms,3.3V 207.6883ms,3.3
+ 207.6884ms,0.0V 207.6999ms,0.0
+ 207.7000ms,3.3V 207.7083ms,3.3
+ 207.7084ms,0.0V 207.7199ms,0.0
+ 207.7200ms,3.3V 207.7283ms,3.3
+ 207.7284ms,0.0V 207.7399ms,0.0
+ 207.7400ms,3.3V 207.7483ms,3.3
+ 207.7484ms,0.0V 207.7599ms,0.0
+ 207.7600ms,3.3V 207.7683ms,3.3
+ 207.7684ms,0.0V 207.7799ms,0.0
+ 207.7800ms,3.3V 207.7883ms,3.3
+ 207.7884ms,0.0V 207.7999ms,0.0
+ 207.8000ms,3.3V 207.8083ms,3.3
+ 207.8084ms,0.0V 207.8199ms,0.0
+ 207.8200ms,3.3V 207.8283ms,3.3
+ 207.8284ms,0.0V 207.8399ms,0.0
+ 207.8400ms,3.3V 207.8483ms,3.3
+ 207.8484ms,0.0V 207.8599ms,0.0
+ 207.8600ms,3.3V 207.8683ms,3.3
+ 207.8684ms,0.0V 207.8799ms,0.0
+ 207.8800ms,3.3V 207.8883ms,3.3
+ 207.8884ms,0.0V 207.8999ms,0.0
+ 207.9000ms,3.3V 207.9083ms,3.3
+ 207.9084ms,0.0V 207.9199ms,0.0
+ 207.9200ms,3.3V 207.9283ms,3.3
+ 207.9284ms,0.0V 207.9399ms,0.0
+ 207.9400ms,3.3V 207.9483ms,3.3
+ 207.9484ms,0.0V 207.9599ms,0.0
+ 207.9600ms,3.3V 207.9683ms,3.3
+ 207.9684ms,0.0V 207.9799ms,0.0
+ 207.9800ms,3.3V 207.9883ms,3.3
+ 207.9884ms,0.0V 207.9999ms,0.0
+ 208.0000ms,3.3V 208.0083ms,3.3
+ 208.0084ms,0.0V 208.0199ms,0.0
+ 208.0200ms,3.3V 208.0283ms,3.3
+ 208.0284ms,0.0V 208.0399ms,0.0
+ 208.0400ms,3.3V 208.0483ms,3.3
+ 208.0484ms,0.0V 208.0599ms,0.0
+ 208.0600ms,3.3V 208.0683ms,3.3
+ 208.0684ms,0.0V 208.0799ms,0.0
+ 208.0800ms,3.3V 208.0883ms,3.3
+ 208.0884ms,0.0V 208.0999ms,0.0
+ 208.1000ms,3.3V 208.1083ms,3.3
+ 208.1084ms,0.0V 208.1199ms,0.0
+ 208.1200ms,3.3V 208.1283ms,3.3
+ 208.1284ms,0.0V 208.1399ms,0.0
+ 208.1400ms,3.3V 208.1483ms,3.3
+ 208.1484ms,0.0V 208.1599ms,0.0
+ 208.1600ms,3.3V 208.1683ms,3.3
+ 208.1684ms,0.0V 208.1799ms,0.0
+ 208.1800ms,3.3V 208.1883ms,3.3
+ 208.1884ms,0.0V 208.1999ms,0.0
+ 208.2000ms,3.3V 208.2083ms,3.3
+ 208.2084ms,0.0V 208.2199ms,0.0
+ 208.2200ms,3.3V 208.2283ms,3.3
+ 208.2284ms,0.0V 208.2399ms,0.0
+ 208.2400ms,3.3V 208.2483ms,3.3
+ 208.2484ms,0.0V 208.2599ms,0.0
+ 208.2600ms,3.3V 208.2683ms,3.3
+ 208.2684ms,0.0V 208.2799ms,0.0
+ 208.2800ms,3.3V 208.2883ms,3.3
+ 208.2884ms,0.0V 208.2999ms,0.0
+ 208.3000ms,3.3V 208.3083ms,3.3
+ 208.3084ms,0.0V 208.3199ms,0.0
+ 208.3200ms,3.3V 208.3283ms,3.3
+ 208.3284ms,0.0V 208.3399ms,0.0
+ 208.3400ms,3.3V 208.3483ms,3.3
+ 208.3484ms,0.0V 208.3599ms,0.0
+ 208.3600ms,3.3V 208.3683ms,3.3
+ 208.3684ms,0.0V 208.3799ms,0.0
+ 208.3800ms,3.3V 208.3883ms,3.3
+ 208.3884ms,0.0V 208.3999ms,0.0
+ 208.4000ms,3.3V 208.4083ms,3.3
+ 208.4084ms,0.0V 208.4199ms,0.0
+ 208.4200ms,3.3V 208.4283ms,3.3
+ 208.4284ms,0.0V 208.4399ms,0.0
+ 208.4400ms,3.3V 208.4483ms,3.3
+ 208.4484ms,0.0V 208.4599ms,0.0
+ 208.4600ms,3.3V 208.4683ms,3.3
+ 208.4684ms,0.0V 208.4799ms,0.0
+ 208.4800ms,3.3V 208.4883ms,3.3
+ 208.4884ms,0.0V 208.4999ms,0.0
+ 208.5000ms,3.3V 208.5083ms,3.3
+ 208.5084ms,0.0V 208.5199ms,0.0
+ 208.5200ms,3.3V 208.5283ms,3.3
+ 208.5284ms,0.0V 208.5399ms,0.0
+ 208.5400ms,3.3V 208.5483ms,3.3
+ 208.5484ms,0.0V 208.5599ms,0.0
+ 208.5600ms,3.3V 208.5683ms,3.3
+ 208.5684ms,0.0V 208.5799ms,0.0
+ 208.5800ms,3.3V 208.5883ms,3.3
+ 208.5884ms,0.0V 208.5999ms,0.0
+ 208.6000ms,3.3V 208.6083ms,3.3
+ 208.6084ms,0.0V 208.6199ms,0.0
+ 208.6200ms,3.3V 208.6283ms,3.3
+ 208.6284ms,0.0V 208.6399ms,0.0
+ 208.6400ms,3.3V 208.6483ms,3.3
+ 208.6484ms,0.0V 208.6599ms,0.0
+ 208.6600ms,3.3V 208.6683ms,3.3
+ 208.6684ms,0.0V 208.6799ms,0.0
+ 208.6800ms,3.3V 208.6883ms,3.3
+ 208.6884ms,0.0V 208.6999ms,0.0
+ 208.7000ms,3.3V 208.7083ms,3.3
+ 208.7084ms,0.0V 208.7199ms,0.0
+ 208.7200ms,3.3V 208.7283ms,3.3
+ 208.7284ms,0.0V 208.7399ms,0.0
+ 208.7400ms,3.3V 208.7483ms,3.3
+ 208.7484ms,0.0V 208.7599ms,0.0
+ 208.7600ms,3.3V 208.7683ms,3.3
+ 208.7684ms,0.0V 208.7799ms,0.0
+ 208.7800ms,3.3V 208.7883ms,3.3
+ 208.7884ms,0.0V 208.7999ms,0.0
+ 208.8000ms,3.3V 208.8083ms,3.3
+ 208.8084ms,0.0V 208.8199ms,0.0
+ 208.8200ms,3.3V 208.8283ms,3.3
+ 208.8284ms,0.0V 208.8399ms,0.0
+ 208.8400ms,3.3V 208.8483ms,3.3
+ 208.8484ms,0.0V 208.8599ms,0.0
+ 208.8600ms,3.3V 208.8683ms,3.3
+ 208.8684ms,0.0V 208.8799ms,0.0
+ 208.8800ms,3.3V 208.8883ms,3.3
+ 208.8884ms,0.0V 208.8999ms,0.0
+ 208.9000ms,3.3V 208.9083ms,3.3
+ 208.9084ms,0.0V 208.9199ms,0.0
+ 208.9200ms,3.3V 208.9283ms,3.3
+ 208.9284ms,0.0V 208.9399ms,0.0
+ 208.9400ms,3.3V 208.9483ms,3.3
+ 208.9484ms,0.0V 208.9599ms,0.0
+ 208.9600ms,3.3V 208.9683ms,3.3
+ 208.9684ms,0.0V 208.9799ms,0.0
+ 208.9800ms,3.3V 208.9883ms,3.3
+ 208.9884ms,0.0V 208.9999ms,0.0
+ 209.0000ms,3.3V 209.0083ms,3.3
+ 209.0084ms,0.0V 209.0199ms,0.0
+ 209.0200ms,3.3V 209.0283ms,3.3
+ 209.0284ms,0.0V 209.0399ms,0.0
+ 209.0400ms,3.3V 209.0483ms,3.3
+ 209.0484ms,0.0V 209.0599ms,0.0
+ 209.0600ms,3.3V 209.0683ms,3.3
+ 209.0684ms,0.0V 209.0799ms,0.0
+ 209.0800ms,3.3V 209.0883ms,3.3
+ 209.0884ms,0.0V 209.0999ms,0.0
+ 209.1000ms,3.3V 209.1083ms,3.3
+ 209.1084ms,0.0V 209.1199ms,0.0
+ 209.1200ms,3.3V 209.1283ms,3.3
+ 209.1284ms,0.0V 209.1399ms,0.0
+ 209.1400ms,3.3V 209.1483ms,3.3
+ 209.1484ms,0.0V 209.1599ms,0.0
+ 209.1600ms,3.3V 209.1683ms,3.3
+ 209.1684ms,0.0V 209.1799ms,0.0
+ 209.1800ms,3.3V 209.1883ms,3.3
+ 209.1884ms,0.0V 209.1999ms,0.0
+ 209.2000ms,3.3V 209.2083ms,3.3
+ 209.2084ms,0.0V 209.2199ms,0.0
+ 209.2200ms,3.3V 209.2283ms,3.3
+ 209.2284ms,0.0V 209.2399ms,0.0
+ 209.2400ms,3.3V 209.2483ms,3.3
+ 209.2484ms,0.0V 209.2599ms,0.0
+ 209.2600ms,3.3V 209.2683ms,3.3
+ 209.2684ms,0.0V 209.2799ms,0.0
+ 209.2800ms,3.3V 209.2883ms,3.3
+ 209.2884ms,0.0V 209.2999ms,0.0
+ 209.3000ms,3.3V 209.3083ms,3.3
+ 209.3084ms,0.0V 209.3199ms,0.0
+ 209.3200ms,3.3V 209.3283ms,3.3
+ 209.3284ms,0.0V 209.3399ms,0.0
+ 209.3400ms,3.3V 209.3483ms,3.3
+ 209.3484ms,0.0V 209.3599ms,0.0
+ 209.3600ms,3.3V 209.3683ms,3.3
+ 209.3684ms,0.0V 209.3799ms,0.0
+ 209.3800ms,3.3V 209.3883ms,3.3
+ 209.3884ms,0.0V 209.3999ms,0.0
+ 209.4000ms,3.3V 209.4083ms,3.3
+ 209.4084ms,0.0V 209.4199ms,0.0
+ 209.4200ms,3.3V 209.4283ms,3.3
+ 209.4284ms,0.0V 209.4399ms,0.0
+ 209.4400ms,3.3V 209.4483ms,3.3
+ 209.4484ms,0.0V 209.4599ms,0.0
+ 209.4600ms,3.3V 209.4683ms,3.3
+ 209.4684ms,0.0V 209.4799ms,0.0
+ 209.4800ms,3.3V 209.4883ms,3.3
+ 209.4884ms,0.0V 209.4999ms,0.0
+ 209.5000ms,3.3V 209.5083ms,3.3
+ 209.5084ms,0.0V 209.5199ms,0.0
+ 209.5200ms,3.3V 209.5283ms,3.3
+ 209.5284ms,0.0V 209.5399ms,0.0
+ 209.5400ms,3.3V 209.5483ms,3.3
+ 209.5484ms,0.0V 209.5599ms,0.0
+ 209.5600ms,3.3V 209.5683ms,3.3
+ 209.5684ms,0.0V 209.5799ms,0.0
+ 209.5800ms,3.3V 209.5883ms,3.3
+ 209.5884ms,0.0V 209.5999ms,0.0
+ 209.6000ms,3.3V 209.6083ms,3.3
+ 209.6084ms,0.0V 209.6199ms,0.0
+ 209.6200ms,3.3V 209.6283ms,3.3
+ 209.6284ms,0.0V 209.6399ms,0.0
+ 209.6400ms,3.3V 209.6483ms,3.3
+ 209.6484ms,0.0V 209.6599ms,0.0
+ 209.6600ms,3.3V 209.6683ms,3.3
+ 209.6684ms,0.0V 209.6799ms,0.0
+ 209.6800ms,3.3V 209.6883ms,3.3
+ 209.6884ms,0.0V 209.6999ms,0.0
+ 209.7000ms,3.3V 209.7083ms,3.3
+ 209.7084ms,0.0V 209.7199ms,0.0
+ 209.7200ms,3.3V 209.7283ms,3.3
+ 209.7284ms,0.0V 209.7399ms,0.0
+ 209.7400ms,3.3V 209.7483ms,3.3
+ 209.7484ms,0.0V 209.7599ms,0.0
+ 209.7600ms,3.3V 209.7683ms,3.3
+ 209.7684ms,0.0V 209.7799ms,0.0
+ 209.7800ms,3.3V 209.7883ms,3.3
+ 209.7884ms,0.0V 209.7999ms,0.0
+ 209.8000ms,3.3V 209.8083ms,3.3
+ 209.8084ms,0.0V 209.8199ms,0.0
+ 209.8200ms,3.3V 209.8283ms,3.3
+ 209.8284ms,0.0V 209.8399ms,0.0
+ 209.8400ms,3.3V 209.8483ms,3.3
+ 209.8484ms,0.0V 209.8599ms,0.0
+ 209.8600ms,3.3V 209.8683ms,3.3
+ 209.8684ms,0.0V 209.8799ms,0.0
+ 209.8800ms,3.3V 209.8883ms,3.3
+ 209.8884ms,0.0V 209.8999ms,0.0
+ 209.9000ms,3.3V 209.9083ms,3.3
+ 209.9084ms,0.0V 209.9199ms,0.0
+ 209.9200ms,3.3V 209.9283ms,3.3
+ 209.9284ms,0.0V 209.9399ms,0.0
+ 209.9400ms,3.3V 209.9483ms,3.3
+ 209.9484ms,0.0V 209.9599ms,0.0
+ 209.9600ms,3.3V 209.9683ms,3.3
+ 209.9684ms,0.0V 209.9799ms,0.0
+ 209.9800ms,3.3V 209.9883ms,3.3
+ 209.9884ms,0.0V 209.9999ms,0.0
+ 210.0000ms,3.3V 210.0083ms,3.3
+ 210.0084ms,0.0V 210.0199ms,0.0
+ 210.0200ms,3.3V 210.0283ms,3.3
+ 210.0284ms,0.0V 210.0399ms,0.0
+ 210.0400ms,3.3V 210.0483ms,3.3
+ 210.0484ms,0.0V 210.0599ms,0.0
+ 210.0600ms,3.3V 210.0683ms,3.3
+ 210.0684ms,0.0V 210.0799ms,0.0
+ 210.0800ms,3.3V 210.0883ms,3.3
+ 210.0884ms,0.0V 210.0999ms,0.0
+ 210.1000ms,3.3V 210.1083ms,3.3
+ 210.1084ms,0.0V 210.1199ms,0.0
+ 210.1200ms,3.3V 210.1283ms,3.3
+ 210.1284ms,0.0V 210.1399ms,0.0
+ 210.1400ms,3.3V 210.1483ms,3.3
+ 210.1484ms,0.0V 210.1599ms,0.0
+ 210.1600ms,3.3V 210.1683ms,3.3
+ 210.1684ms,0.0V 210.1799ms,0.0
+ 210.1800ms,3.3V 210.1883ms,3.3
+ 210.1884ms,0.0V 210.1999ms,0.0
+ 210.2000ms,3.3V 210.2083ms,3.3
+ 210.2084ms,0.0V 210.2199ms,0.0
+ 210.2200ms,3.3V 210.2283ms,3.3
+ 210.2284ms,0.0V 210.2399ms,0.0
+ 210.2400ms,3.3V 210.2483ms,3.3
+ 210.2484ms,0.0V 210.2599ms,0.0
+ 210.2600ms,3.3V 210.2683ms,3.3
+ 210.2684ms,0.0V 210.2799ms,0.0
+ 210.2800ms,3.3V 210.2883ms,3.3
+ 210.2884ms,0.0V 210.2999ms,0.0
+ 210.3000ms,3.3V 210.3083ms,3.3
+ 210.3084ms,0.0V 210.3199ms,0.0
+ 210.3200ms,3.3V 210.3283ms,3.3
+ 210.3284ms,0.0V 210.3399ms,0.0
+ 210.3400ms,3.3V 210.3483ms,3.3
+ 210.3484ms,0.0V 210.3599ms,0.0
+ 210.3600ms,3.3V 210.3685ms,3.3
+ 210.3686ms,0.0V 210.3799ms,0.0
+ 210.3800ms,3.3V 210.3885ms,3.3
+ 210.3886ms,0.0V 210.3999ms,0.0
+ 210.4000ms,3.3V 210.4085ms,3.3
+ 210.4086ms,0.0V 210.4199ms,0.0
+ 210.4200ms,3.3V 210.4285ms,3.3
+ 210.4286ms,0.0V 210.4399ms,0.0
+ 210.4400ms,3.3V 210.4485ms,3.3
+ 210.4486ms,0.0V 210.4599ms,0.0
+ 210.4600ms,3.3V 210.4685ms,3.3
+ 210.4686ms,0.0V 210.4799ms,0.0
+ 210.4800ms,3.3V 210.4885ms,3.3
+ 210.4886ms,0.0V 210.4999ms,0.0
+ 210.5000ms,3.3V 210.5085ms,3.3
+ 210.5086ms,0.0V 210.5199ms,0.0
+ 210.5200ms,3.3V 210.5285ms,3.3
+ 210.5286ms,0.0V 210.5399ms,0.0
+ 210.5400ms,3.3V 210.5485ms,3.3
+ 210.5486ms,0.0V 210.5599ms,0.0
+ 210.5600ms,3.3V 210.5685ms,3.3
+ 210.5686ms,0.0V 210.5799ms,0.0
+ 210.5800ms,3.3V 210.5885ms,3.3
+ 210.5886ms,0.0V 210.5999ms,0.0
+ 210.6000ms,3.3V 210.6085ms,3.3
+ 210.6086ms,0.0V 210.6199ms,0.0
+ 210.6200ms,3.3V 210.6285ms,3.3
+ 210.6286ms,0.0V 210.6399ms,0.0
+ 210.6400ms,3.3V 210.6485ms,3.3
+ 210.6486ms,0.0V 210.6599ms,0.0
+ 210.6600ms,3.3V 210.6685ms,3.3
+ 210.6686ms,0.0V 210.6799ms,0.0
+ 210.6800ms,3.3V 210.6885ms,3.3
+ 210.6886ms,0.0V 210.6999ms,0.0
+ 210.7000ms,3.3V 210.7085ms,3.3
+ 210.7086ms,0.0V 210.7199ms,0.0
+ 210.7200ms,3.3V 210.7285ms,3.3
+ 210.7286ms,0.0V 210.7399ms,0.0
+ 210.7400ms,3.3V 210.7485ms,3.3
+ 210.7486ms,0.0V 210.7599ms,0.0
+ 210.7600ms,3.3V 210.7685ms,3.3
+ 210.7686ms,0.0V 210.7799ms,0.0
+ 210.7800ms,3.3V 210.7885ms,3.3
+ 210.7886ms,0.0V 210.7999ms,0.0
+ 210.8000ms,3.3V 210.8085ms,3.3
+ 210.8086ms,0.0V 210.8199ms,0.0
+ 210.8200ms,3.3V 210.8285ms,3.3
+ 210.8286ms,0.0V 210.8399ms,0.0
+ 210.8400ms,3.3V 210.8485ms,3.3
+ 210.8486ms,0.0V 210.8599ms,0.0
+ 210.8600ms,3.3V 210.8685ms,3.3
+ 210.8686ms,0.0V 210.8799ms,0.0
+ 210.8800ms,3.3V 210.8885ms,3.3
+ 210.8886ms,0.0V 210.8999ms,0.0
+ 210.9000ms,3.3V 210.9085ms,3.3
+ 210.9086ms,0.0V 210.9199ms,0.0
+ 210.9200ms,3.3V 210.9285ms,3.3
+ 210.9286ms,0.0V 210.9399ms,0.0
+ 210.9400ms,3.3V 210.9485ms,3.3
+ 210.9486ms,0.0V 210.9599ms,0.0
+ 210.9600ms,3.3V 210.9685ms,3.3
+ 210.9686ms,0.0V 210.9799ms,0.0
+ 210.9800ms,3.3V 210.9885ms,3.3
+ 210.9886ms,0.0V 210.9999ms,0.0
+ 211.0000ms,3.3V 211.0085ms,3.3
+ 211.0086ms,0.0V 211.0199ms,0.0
+ 211.0200ms,3.3V 211.0285ms,3.3
+ 211.0286ms,0.0V 211.0399ms,0.0
+ 211.0400ms,3.3V 211.0485ms,3.3
+ 211.0486ms,0.0V 211.0599ms,0.0
+ 211.0600ms,3.3V 211.0685ms,3.3
+ 211.0686ms,0.0V 211.0799ms,0.0
+ 211.0800ms,3.3V 211.0885ms,3.3
+ 211.0886ms,0.0V 211.0999ms,0.0
+ 211.1000ms,3.3V 211.1085ms,3.3
+ 211.1086ms,0.0V 211.1199ms,0.0
+ 211.1200ms,3.3V 211.1285ms,3.3
+ 211.1286ms,0.0V 211.1399ms,0.0
+ 211.1400ms,3.3V 211.1485ms,3.3
+ 211.1486ms,0.0V 211.1599ms,0.0
+ 211.1600ms,3.3V 211.1685ms,3.3
+ 211.1686ms,0.0V 211.1799ms,0.0
+ 211.1800ms,3.3V 211.1885ms,3.3
+ 211.1886ms,0.0V 211.1999ms,0.0
+ 211.2000ms,3.3V 211.2085ms,3.3
+ 211.2086ms,0.0V 211.2199ms,0.0
+ 211.2200ms,3.3V 211.2285ms,3.3
+ 211.2286ms,0.0V 211.2399ms,0.0
+ 211.2400ms,3.3V 211.2485ms,3.3
+ 211.2486ms,0.0V 211.2599ms,0.0
+ 211.2600ms,3.3V 211.2685ms,3.3
+ 211.2686ms,0.0V 211.2799ms,0.0
+ 211.2800ms,3.3V 211.2885ms,3.3
+ 211.2886ms,0.0V 211.2999ms,0.0
+ 211.3000ms,3.3V 211.3085ms,3.3
+ 211.3086ms,0.0V 211.3199ms,0.0
+ 211.3200ms,3.3V 211.3285ms,3.3
+ 211.3286ms,0.0V 211.3399ms,0.0
+ 211.3400ms,3.3V 211.3485ms,3.3
+ 211.3486ms,0.0V 211.3599ms,0.0
+ 211.3600ms,3.3V 211.3685ms,3.3
+ 211.3686ms,0.0V 211.3799ms,0.0
+ 211.3800ms,3.3V 211.3885ms,3.3
+ 211.3886ms,0.0V 211.3999ms,0.0
+ 211.4000ms,3.3V 211.4085ms,3.3
+ 211.4086ms,0.0V 211.4199ms,0.0
+ 211.4200ms,3.3V 211.4285ms,3.3
+ 211.4286ms,0.0V 211.4399ms,0.0
+ 211.4400ms,3.3V 211.4485ms,3.3
+ 211.4486ms,0.0V 211.4599ms,0.0
+ 211.4600ms,3.3V 211.4685ms,3.3
+ 211.4686ms,0.0V 211.4799ms,0.0
+ 211.4800ms,3.3V 211.4885ms,3.3
+ 211.4886ms,0.0V 211.4999ms,0.0
+ 211.5000ms,3.3V 211.5085ms,3.3
+ 211.5086ms,0.0V 211.5199ms,0.0
+ 211.5200ms,3.3V 211.5285ms,3.3
+ 211.5286ms,0.0V 211.5399ms,0.0
+ 211.5400ms,3.3V 211.5485ms,3.3
+ 211.5486ms,0.0V 211.5599ms,0.0
+ 211.5600ms,3.3V 211.5685ms,3.3
+ 211.5686ms,0.0V 211.5799ms,0.0
+ 211.5800ms,3.3V 211.5885ms,3.3
+ 211.5886ms,0.0V 211.5999ms,0.0
+ 211.6000ms,3.3V 211.6085ms,3.3
+ 211.6086ms,0.0V 211.6199ms,0.0
+ 211.6200ms,3.3V 211.6285ms,3.3
+ 211.6286ms,0.0V 211.6399ms,0.0
+ 211.6400ms,3.3V 211.6485ms,3.3
+ 211.6486ms,0.0V 211.6599ms,0.0
+ 211.6600ms,3.3V 211.6685ms,3.3
+ 211.6686ms,0.0V 211.6799ms,0.0
+ 211.6800ms,3.3V 211.6885ms,3.3
+ 211.6886ms,0.0V 211.6999ms,0.0
+ 211.7000ms,3.3V 211.7085ms,3.3
+ 211.7086ms,0.0V 211.7199ms,0.0
+ 211.7200ms,3.3V 211.7285ms,3.3
+ 211.7286ms,0.0V 211.7399ms,0.0
+ 211.7400ms,3.3V 211.7485ms,3.3
+ 211.7486ms,0.0V 211.7599ms,0.0
+ 211.7600ms,3.3V 211.7685ms,3.3
+ 211.7686ms,0.0V 211.7799ms,0.0
+ 211.7800ms,3.3V 211.7885ms,3.3
+ 211.7886ms,0.0V 211.7999ms,0.0
+ 211.8000ms,3.3V 211.8085ms,3.3
+ 211.8086ms,0.0V 211.8199ms,0.0
+ 211.8200ms,3.3V 211.8285ms,3.3
+ 211.8286ms,0.0V 211.8399ms,0.0
+ 211.8400ms,3.3V 211.8485ms,3.3
+ 211.8486ms,0.0V 211.8599ms,0.0
+ 211.8600ms,3.3V 211.8685ms,3.3
+ 211.8686ms,0.0V 211.8799ms,0.0
+ 211.8800ms,3.3V 211.8885ms,3.3
+ 211.8886ms,0.0V 211.8999ms,0.0
+ 211.9000ms,3.3V 211.9085ms,3.3
+ 211.9086ms,0.0V 211.9199ms,0.0
+ 211.9200ms,3.3V 211.9285ms,3.3
+ 211.9286ms,0.0V 211.9399ms,0.0
+ 211.9400ms,3.3V 211.9485ms,3.3
+ 211.9486ms,0.0V 211.9599ms,0.0
+ 211.9600ms,3.3V 211.9685ms,3.3
+ 211.9686ms,0.0V 211.9799ms,0.0
+ 211.9800ms,3.3V 211.9885ms,3.3
+ 211.9886ms,0.0V 211.9999ms,0.0
+ 212.0000ms,3.3V 212.0085ms,3.3
+ 212.0086ms,0.0V 212.0199ms,0.0
+ 212.0200ms,3.3V 212.0285ms,3.3
+ 212.0286ms,0.0V 212.0399ms,0.0
+ 212.0400ms,3.3V 212.0485ms,3.3
+ 212.0486ms,0.0V 212.0599ms,0.0
+ 212.0600ms,3.3V 212.0685ms,3.3
+ 212.0686ms,0.0V 212.0799ms,0.0
+ 212.0800ms,3.3V 212.0885ms,3.3
+ 212.0886ms,0.0V 212.0999ms,0.0
+ 212.1000ms,3.3V 212.1085ms,3.3
+ 212.1086ms,0.0V 212.1199ms,0.0
+ 212.1200ms,3.3V 212.1285ms,3.3
+ 212.1286ms,0.0V 212.1399ms,0.0
+ 212.1400ms,3.3V 212.1485ms,3.3
+ 212.1486ms,0.0V 212.1599ms,0.0
+ 212.1600ms,3.3V 212.1685ms,3.3
+ 212.1686ms,0.0V 212.1799ms,0.0
+ 212.1800ms,3.3V 212.1885ms,3.3
+ 212.1886ms,0.0V 212.1999ms,0.0
+ 212.2000ms,3.3V 212.2085ms,3.3
+ 212.2086ms,0.0V 212.2199ms,0.0
+ 212.2200ms,3.3V 212.2285ms,3.3
+ 212.2286ms,0.0V 212.2399ms,0.0
+ 212.2400ms,3.3V 212.2485ms,3.3
+ 212.2486ms,0.0V 212.2599ms,0.0
+ 212.2600ms,3.3V 212.2685ms,3.3
+ 212.2686ms,0.0V 212.2799ms,0.0
+ 212.2800ms,3.3V 212.2885ms,3.3
+ 212.2886ms,0.0V 212.2999ms,0.0
+ 212.3000ms,3.3V 212.3085ms,3.3
+ 212.3086ms,0.0V 212.3199ms,0.0
+ 212.3200ms,3.3V 212.3285ms,3.3
+ 212.3286ms,0.0V 212.3399ms,0.0
+ 212.3400ms,3.3V 212.3485ms,3.3
+ 212.3486ms,0.0V 212.3599ms,0.0
+ 212.3600ms,3.3V 212.3685ms,3.3
+ 212.3686ms,0.0V 212.3799ms,0.0
+ 212.3800ms,3.3V 212.3885ms,3.3
+ 212.3886ms,0.0V 212.3999ms,0.0
+ 212.4000ms,3.3V 212.4085ms,3.3
+ 212.4086ms,0.0V 212.4199ms,0.0
+ 212.4200ms,3.3V 212.4285ms,3.3
+ 212.4286ms,0.0V 212.4399ms,0.0
+ 212.4400ms,3.3V 212.4485ms,3.3
+ 212.4486ms,0.0V 212.4599ms,0.0
+ 212.4600ms,3.3V 212.4685ms,3.3
+ 212.4686ms,0.0V 212.4799ms,0.0
+ 212.4800ms,3.3V 212.4885ms,3.3
+ 212.4886ms,0.0V 212.4999ms,0.0
+ 212.5000ms,3.3V 212.5085ms,3.3
+ 212.5086ms,0.0V 212.5199ms,0.0
+ 212.5200ms,3.3V 212.5285ms,3.3
+ 212.5286ms,0.0V 212.5399ms,0.0
+ 212.5400ms,3.3V 212.5485ms,3.3
+ 212.5486ms,0.0V 212.5599ms,0.0
+ 212.5600ms,3.3V 212.5685ms,3.3
+ 212.5686ms,0.0V 212.5799ms,0.0
+ 212.5800ms,3.3V 212.5885ms,3.3
+ 212.5886ms,0.0V 212.5999ms,0.0
+ 212.6000ms,3.3V 212.6085ms,3.3
+ 212.6086ms,0.0V 212.6199ms,0.0
+ 212.6200ms,3.3V 212.6285ms,3.3
+ 212.6286ms,0.0V 212.6399ms,0.0
+ 212.6400ms,3.3V 212.6485ms,3.3
+ 212.6486ms,0.0V 212.6599ms,0.0
+ 212.6600ms,3.3V 212.6685ms,3.3
+ 212.6686ms,0.0V 212.6799ms,0.0
+ 212.6800ms,3.3V 212.6885ms,3.3
+ 212.6886ms,0.0V 212.6999ms,0.0
+ 212.7000ms,3.3V 212.7085ms,3.3
+ 212.7086ms,0.0V 212.7199ms,0.0
+ 212.7200ms,3.3V 212.7285ms,3.3
+ 212.7286ms,0.0V 212.7399ms,0.0
+ 212.7400ms,3.3V 212.7485ms,3.3
+ 212.7486ms,0.0V 212.7599ms,0.0
+ 212.7600ms,3.3V 212.7685ms,3.3
+ 212.7686ms,0.0V 212.7799ms,0.0
+ 212.7800ms,3.3V 212.7885ms,3.3
+ 212.7886ms,0.0V 212.7999ms,0.0
+ 212.8000ms,3.3V 212.8085ms,3.3
+ 212.8086ms,0.0V 212.8199ms,0.0
+ 212.8200ms,3.3V 212.8285ms,3.3
+ 212.8286ms,0.0V 212.8399ms,0.0
+ 212.8400ms,3.3V 212.8485ms,3.3
+ 212.8486ms,0.0V 212.8599ms,0.0
+ 212.8600ms,3.3V 212.8685ms,3.3
+ 212.8686ms,0.0V 212.8799ms,0.0
+ 212.8800ms,3.3V 212.8885ms,3.3
+ 212.8886ms,0.0V 212.8999ms,0.0
+ 212.9000ms,3.3V 212.9085ms,3.3
+ 212.9086ms,0.0V 212.9199ms,0.0
+ 212.9200ms,3.3V 212.9285ms,3.3
+ 212.9286ms,0.0V 212.9399ms,0.0
+ 212.9400ms,3.3V 212.9485ms,3.3
+ 212.9486ms,0.0V 212.9599ms,0.0
+ 212.9600ms,3.3V 212.9685ms,3.3
+ 212.9686ms,0.0V 212.9799ms,0.0
+ 212.9800ms,3.3V 212.9885ms,3.3
+ 212.9886ms,0.0V 212.9999ms,0.0
+ 213.0000ms,3.3V 213.0085ms,3.3
+ 213.0086ms,0.0V 213.0199ms,0.0
+ 213.0200ms,3.3V 213.0285ms,3.3
+ 213.0286ms,0.0V 213.0399ms,0.0
+ 213.0400ms,3.3V 213.0485ms,3.3
+ 213.0486ms,0.0V 213.0599ms,0.0
+ 213.0600ms,3.3V 213.0685ms,3.3
+ 213.0686ms,0.0V 213.0799ms,0.0
+ 213.0800ms,3.3V 213.0885ms,3.3
+ 213.0886ms,0.0V 213.0999ms,0.0
+ 213.1000ms,3.3V 213.1085ms,3.3
+ 213.1086ms,0.0V 213.1199ms,0.0
+ 213.1200ms,3.3V 213.1285ms,3.3
+ 213.1286ms,0.0V 213.1399ms,0.0
+ 213.1400ms,3.3V 213.1485ms,3.3
+ 213.1486ms,0.0V 213.1599ms,0.0
+ 213.1600ms,3.3V 213.1685ms,3.3
+ 213.1686ms,0.0V 213.1799ms,0.0
+ 213.1800ms,3.3V 213.1885ms,3.3
+ 213.1886ms,0.0V 213.1999ms,0.0
+ 213.2000ms,3.3V 213.2085ms,3.3
+ 213.2086ms,0.0V 213.2199ms,0.0
+ 213.2200ms,3.3V 213.2285ms,3.3
+ 213.2286ms,0.0V 213.2399ms,0.0
+ 213.2400ms,3.3V 213.2485ms,3.3
+ 213.2486ms,0.0V 213.2599ms,0.0
+ 213.2600ms,3.3V 213.2685ms,3.3
+ 213.2686ms,0.0V 213.2799ms,0.0
+ 213.2800ms,3.3V 213.2885ms,3.3
+ 213.2886ms,0.0V 213.2999ms,0.0
+ 213.3000ms,3.3V 213.3085ms,3.3
+ 213.3086ms,0.0V 213.3199ms,0.0
+ 213.3200ms,3.3V 213.3285ms,3.3
+ 213.3286ms,0.0V 213.3399ms,0.0
+ 213.3400ms,3.3V 213.3485ms,3.3
+ 213.3486ms,0.0V 213.3599ms,0.0
+ 213.3600ms,3.3V 213.3685ms,3.3
+ 213.3686ms,0.0V 213.3799ms,0.0
+ 213.3800ms,3.3V 213.3885ms,3.3
+ 213.3886ms,0.0V 213.3999ms,0.0
+ 213.4000ms,3.3V 213.4085ms,3.3
+ 213.4086ms,0.0V 213.4199ms,0.0
+ 213.4200ms,3.3V 213.4285ms,3.3
+ 213.4286ms,0.0V 213.4399ms,0.0
+ 213.4400ms,3.3V 213.4485ms,3.3
+ 213.4486ms,0.0V 213.4599ms,0.0
+ 213.4600ms,3.3V 213.4685ms,3.3
+ 213.4686ms,0.0V 213.4799ms,0.0
+ 213.4800ms,3.3V 213.4885ms,3.3
+ 213.4886ms,0.0V 213.4999ms,0.0
+ 213.5000ms,3.3V 213.5085ms,3.3
+ 213.5086ms,0.0V 213.5199ms,0.0
+ 213.5200ms,3.3V 213.5285ms,3.3
+ 213.5286ms,0.0V 213.5399ms,0.0
+ 213.5400ms,3.3V 213.5485ms,3.3
+ 213.5486ms,0.0V 213.5599ms,0.0
+ 213.5600ms,3.3V 213.5685ms,3.3
+ 213.5686ms,0.0V 213.5799ms,0.0
+ 213.5800ms,3.3V 213.5885ms,3.3
+ 213.5886ms,0.0V 213.5999ms,0.0
+ 213.6000ms,3.3V 213.6085ms,3.3
+ 213.6086ms,0.0V 213.6199ms,0.0
+ 213.6200ms,3.3V 213.6285ms,3.3
+ 213.6286ms,0.0V 213.6399ms,0.0
+ 213.6400ms,3.3V 213.6485ms,3.3
+ 213.6486ms,0.0V 213.6599ms,0.0
+ 213.6600ms,3.3V 213.6685ms,3.3
+ 213.6686ms,0.0V 213.6799ms,0.0
+ 213.6800ms,3.3V 213.6885ms,3.3
+ 213.6886ms,0.0V 213.6999ms,0.0
+ 213.7000ms,3.3V 213.7085ms,3.3
+ 213.7086ms,0.0V 213.7199ms,0.0
+ 213.7200ms,3.3V 213.7285ms,3.3
+ 213.7286ms,0.0V 213.7399ms,0.0
+ 213.7400ms,3.3V 213.7485ms,3.3
+ 213.7486ms,0.0V 213.7599ms,0.0
+ 213.7600ms,3.3V 213.7685ms,3.3
+ 213.7686ms,0.0V 213.7799ms,0.0
+ 213.7800ms,3.3V 213.7885ms,3.3
+ 213.7886ms,0.0V 213.7999ms,0.0
+ 213.8000ms,3.3V 213.8085ms,3.3
+ 213.8086ms,0.0V 213.8199ms,0.0
+ 213.8200ms,3.3V 213.8285ms,3.3
+ 213.8286ms,0.0V 213.8399ms,0.0
+ 213.8400ms,3.3V 213.8485ms,3.3
+ 213.8486ms,0.0V 213.8599ms,0.0
+ 213.8600ms,3.3V 213.8685ms,3.3
+ 213.8686ms,0.0V 213.8799ms,0.0
+ 213.8800ms,3.3V 213.8885ms,3.3
+ 213.8886ms,0.0V 213.8999ms,0.0
+ 213.9000ms,3.3V 213.9085ms,3.3
+ 213.9086ms,0.0V 213.9199ms,0.0
+ 213.9200ms,3.3V 213.9285ms,3.3
+ 213.9286ms,0.0V 213.9399ms,0.0
+ 213.9400ms,3.3V 213.9485ms,3.3
+ 213.9486ms,0.0V 213.9599ms,0.0
+ 213.9600ms,3.3V 213.9685ms,3.3
+ 213.9686ms,0.0V 213.9799ms,0.0
+ 213.9800ms,3.3V 213.9885ms,3.3
+ 213.9886ms,0.0V 213.9999ms,0.0
+ 214.0000ms,3.3V 214.0085ms,3.3
+ 214.0086ms,0.0V 214.0199ms,0.0
+ 214.0200ms,3.3V 214.0285ms,3.3
+ 214.0286ms,0.0V 214.0399ms,0.0
+ 214.0400ms,3.3V 214.0485ms,3.3
+ 214.0486ms,0.0V 214.0599ms,0.0
+ 214.0600ms,3.3V 214.0685ms,3.3
+ 214.0686ms,0.0V 214.0799ms,0.0
+ 214.0800ms,3.3V 214.0885ms,3.3
+ 214.0886ms,0.0V 214.0999ms,0.0
+ 214.1000ms,3.3V 214.1085ms,3.3
+ 214.1086ms,0.0V 214.1199ms,0.0
+ 214.1200ms,3.3V 214.1285ms,3.3
+ 214.1286ms,0.0V 214.1399ms,0.0
+ 214.1400ms,3.3V 214.1485ms,3.3
+ 214.1486ms,0.0V 214.1599ms,0.0
+ 214.1600ms,3.3V 214.1685ms,3.3
+ 214.1686ms,0.0V 214.1799ms,0.0
+ 214.1800ms,3.3V 214.1885ms,3.3
+ 214.1886ms,0.0V 214.1999ms,0.0
+ 214.2000ms,3.3V 214.2085ms,3.3
+ 214.2086ms,0.0V 214.2199ms,0.0
+ 214.2200ms,3.3V 214.2285ms,3.3
+ 214.2286ms,0.0V 214.2399ms,0.0
+ 214.2400ms,3.3V 214.2485ms,3.3
+ 214.2486ms,0.0V 214.2599ms,0.0
+ 214.2600ms,3.3V 214.2685ms,3.3
+ 214.2686ms,0.0V 214.2799ms,0.0
+ 214.2800ms,3.3V 214.2885ms,3.3
+ 214.2886ms,0.0V 214.2999ms,0.0
+ 214.3000ms,3.3V 214.3085ms,3.3
+ 214.3086ms,0.0V 214.3199ms,0.0
+ 214.3200ms,3.3V 214.3285ms,3.3
+ 214.3286ms,0.0V 214.3399ms,0.0
+ 214.3400ms,3.3V 214.3485ms,3.3
+ 214.3486ms,0.0V 214.3599ms,0.0
+ 214.3600ms,3.3V 214.3685ms,3.3
+ 214.3686ms,0.0V 214.3799ms,0.0
+ 214.3800ms,3.3V 214.3885ms,3.3
+ 214.3886ms,0.0V 214.3999ms,0.0
+ 214.4000ms,3.3V 214.4085ms,3.3
+ 214.4086ms,0.0V 214.4199ms,0.0
+ 214.4200ms,3.3V 214.4285ms,3.3
+ 214.4286ms,0.0V 214.4399ms,0.0
+ 214.4400ms,3.3V 214.4485ms,3.3
+ 214.4486ms,0.0V 214.4599ms,0.0
+ 214.4600ms,3.3V 214.4685ms,3.3
+ 214.4686ms,0.0V 214.4799ms,0.0
+ 214.4800ms,3.3V 214.4885ms,3.3
+ 214.4886ms,0.0V 214.4999ms,0.0
+ 214.5000ms,3.3V 214.5085ms,3.3
+ 214.5086ms,0.0V 214.5199ms,0.0
+ 214.5200ms,3.3V 214.5285ms,3.3
+ 214.5286ms,0.0V 214.5399ms,0.0
+ 214.5400ms,3.3V 214.5485ms,3.3
+ 214.5486ms,0.0V 214.5599ms,0.0
+ 214.5600ms,3.3V 214.5685ms,3.3
+ 214.5686ms,0.0V 214.5799ms,0.0
+ 214.5800ms,3.3V 214.5885ms,3.3
+ 214.5886ms,0.0V 214.5999ms,0.0
+ 214.6000ms,3.3V 214.6085ms,3.3
+ 214.6086ms,0.0V 214.6199ms,0.0
+ 214.6200ms,3.3V 214.6285ms,3.3
+ 214.6286ms,0.0V 214.6399ms,0.0
+ 214.6400ms,3.3V 214.6485ms,3.3
+ 214.6486ms,0.0V 214.6599ms,0.0
+ 214.6600ms,3.3V 214.6685ms,3.3
+ 214.6686ms,0.0V 214.6799ms,0.0
+ 214.6800ms,3.3V 214.6885ms,3.3
+ 214.6886ms,0.0V 214.6999ms,0.0
+ 214.7000ms,3.3V 214.7085ms,3.3
+ 214.7086ms,0.0V 214.7199ms,0.0
+ 214.7200ms,3.3V 214.7285ms,3.3
+ 214.7286ms,0.0V 214.7399ms,0.0
+ 214.7400ms,3.3V 214.7485ms,3.3
+ 214.7486ms,0.0V 214.7599ms,0.0
+ 214.7600ms,3.3V 214.7685ms,3.3
+ 214.7686ms,0.0V 214.7799ms,0.0
+ 214.7800ms,3.3V 214.7885ms,3.3
+ 214.7886ms,0.0V 214.7999ms,0.0
+ 214.8000ms,3.3V 214.8085ms,3.3
+ 214.8086ms,0.0V 214.8199ms,0.0
+ 214.8200ms,3.3V 214.8285ms,3.3
+ 214.8286ms,0.0V 214.8399ms,0.0
+ 214.8400ms,3.3V 214.8485ms,3.3
+ 214.8486ms,0.0V 214.8599ms,0.0
+ 214.8600ms,3.3V 214.8685ms,3.3
+ 214.8686ms,0.0V 214.8799ms,0.0
+ 214.8800ms,3.3V 214.8885ms,3.3
+ 214.8886ms,0.0V 214.8999ms,0.0
+ 214.9000ms,3.3V 214.9085ms,3.3
+ 214.9086ms,0.0V 214.9199ms,0.0
+ 214.9200ms,3.3V 214.9285ms,3.3
+ 214.9286ms,0.0V 214.9399ms,0.0
+ 214.9400ms,3.3V 214.9485ms,3.3
+ 214.9486ms,0.0V 214.9599ms,0.0
+ 214.9600ms,3.3V 214.9685ms,3.3
+ 214.9686ms,0.0V 214.9799ms,0.0
+ 214.9800ms,3.3V 214.9885ms,3.3
+ 214.9886ms,0.0V 214.9999ms,0.0
+ 215.0000ms,3.3V 215.0085ms,3.3
+ 215.0086ms,0.0V 215.0199ms,0.0
+ 215.0200ms,3.3V 215.0285ms,3.3
+ 215.0286ms,0.0V 215.0399ms,0.0
+ 215.0400ms,3.3V 215.0485ms,3.3
+ 215.0486ms,0.0V 215.0599ms,0.0
+ 215.0600ms,3.3V 215.0685ms,3.3
+ 215.0686ms,0.0V 215.0799ms,0.0
+ 215.0800ms,3.3V 215.0885ms,3.3
+ 215.0886ms,0.0V 215.0999ms,0.0
+ 215.1000ms,3.3V 215.1085ms,3.3
+ 215.1086ms,0.0V 215.1199ms,0.0
+ 215.1200ms,3.3V 215.1285ms,3.3
+ 215.1286ms,0.0V 215.1399ms,0.0
+ 215.1400ms,3.3V 215.1485ms,3.3
+ 215.1486ms,0.0V 215.1599ms,0.0
+ 215.1600ms,3.3V 215.1685ms,3.3
+ 215.1686ms,0.0V 215.1799ms,0.0
+ 215.1800ms,3.3V 215.1885ms,3.3
+ 215.1886ms,0.0V 215.1999ms,0.0
+ 215.2000ms,3.3V 215.2085ms,3.3
+ 215.2086ms,0.0V 215.2199ms,0.0
+ 215.2200ms,3.3V 215.2285ms,3.3
+ 215.2286ms,0.0V 215.2399ms,0.0
+ 215.2400ms,3.3V 215.2485ms,3.3
+ 215.2486ms,0.0V 215.2599ms,0.0
+ 215.2600ms,3.3V 215.2685ms,3.3
+ 215.2686ms,0.0V 215.2799ms,0.0
+ 215.2800ms,3.3V 215.2885ms,3.3
+ 215.2886ms,0.0V 215.2999ms,0.0
+ 215.3000ms,3.3V 215.3085ms,3.3
+ 215.3086ms,0.0V 215.3199ms,0.0
+ 215.3200ms,3.3V 215.3285ms,3.3
+ 215.3286ms,0.0V 215.3399ms,0.0
+ 215.3400ms,3.3V 215.3485ms,3.3
+ 215.3486ms,0.0V 215.3599ms,0.0
+ 215.3600ms,3.3V 215.3687ms,3.3
+ 215.3688ms,0.0V 215.3799ms,0.0
+ 215.3800ms,3.3V 215.3887ms,3.3
+ 215.3888ms,0.0V 215.3999ms,0.0
+ 215.4000ms,3.3V 215.4087ms,3.3
+ 215.4088ms,0.0V 215.4199ms,0.0
+ 215.4200ms,3.3V 215.4287ms,3.3
+ 215.4288ms,0.0V 215.4399ms,0.0
+ 215.4400ms,3.3V 215.4487ms,3.3
+ 215.4488ms,0.0V 215.4599ms,0.0
+ 215.4600ms,3.3V 215.4687ms,3.3
+ 215.4688ms,0.0V 215.4799ms,0.0
+ 215.4800ms,3.3V 215.4887ms,3.3
+ 215.4888ms,0.0V 215.4999ms,0.0
+ 215.5000ms,3.3V 215.5087ms,3.3
+ 215.5088ms,0.0V 215.5199ms,0.0
+ 215.5200ms,3.3V 215.5287ms,3.3
+ 215.5288ms,0.0V 215.5399ms,0.0
+ 215.5400ms,3.3V 215.5487ms,3.3
+ 215.5488ms,0.0V 215.5599ms,0.0
+ 215.5600ms,3.3V 215.5687ms,3.3
+ 215.5688ms,0.0V 215.5799ms,0.0
+ 215.5800ms,3.3V 215.5887ms,3.3
+ 215.5888ms,0.0V 215.5999ms,0.0
+ 215.6000ms,3.3V 215.6087ms,3.3
+ 215.6088ms,0.0V 215.6199ms,0.0
+ 215.6200ms,3.3V 215.6287ms,3.3
+ 215.6288ms,0.0V 215.6399ms,0.0
+ 215.6400ms,3.3V 215.6487ms,3.3
+ 215.6488ms,0.0V 215.6599ms,0.0
+ 215.6600ms,3.3V 215.6687ms,3.3
+ 215.6688ms,0.0V 215.6799ms,0.0
+ 215.6800ms,3.3V 215.6887ms,3.3
+ 215.6888ms,0.0V 215.6999ms,0.0
+ 215.7000ms,3.3V 215.7087ms,3.3
+ 215.7088ms,0.0V 215.7199ms,0.0
+ 215.7200ms,3.3V 215.7287ms,3.3
+ 215.7288ms,0.0V 215.7399ms,0.0
+ 215.7400ms,3.3V 215.7487ms,3.3
+ 215.7488ms,0.0V 215.7599ms,0.0
+ 215.7600ms,3.3V 215.7687ms,3.3
+ 215.7688ms,0.0V 215.7799ms,0.0
+ 215.7800ms,3.3V 215.7887ms,3.3
+ 215.7888ms,0.0V 215.7999ms,0.0
+ 215.8000ms,3.3V 215.8087ms,3.3
+ 215.8088ms,0.0V 215.8199ms,0.0
+ 215.8200ms,3.3V 215.8287ms,3.3
+ 215.8288ms,0.0V 215.8399ms,0.0
+ 215.8400ms,3.3V 215.8487ms,3.3
+ 215.8488ms,0.0V 215.8599ms,0.0
+ 215.8600ms,3.3V 215.8687ms,3.3
+ 215.8688ms,0.0V 215.8799ms,0.0
+ 215.8800ms,3.3V 215.8887ms,3.3
+ 215.8888ms,0.0V 215.8999ms,0.0
+ 215.9000ms,3.3V 215.9087ms,3.3
+ 215.9088ms,0.0V 215.9199ms,0.0
+ 215.9200ms,3.3V 215.9287ms,3.3
+ 215.9288ms,0.0V 215.9399ms,0.0
+ 215.9400ms,3.3V 215.9487ms,3.3
+ 215.9488ms,0.0V 215.9599ms,0.0
+ 215.9600ms,3.3V 215.9687ms,3.3
+ 215.9688ms,0.0V 215.9799ms,0.0
+ 215.9800ms,3.3V 215.9887ms,3.3
+ 215.9888ms,0.0V 215.9999ms,0.0
+ 216.0000ms,3.3V 216.0087ms,3.3
+ 216.0088ms,0.0V 216.0199ms,0.0
+ 216.0200ms,3.3V 216.0287ms,3.3
+ 216.0288ms,0.0V 216.0399ms,0.0
+ 216.0400ms,3.3V 216.0487ms,3.3
+ 216.0488ms,0.0V 216.0599ms,0.0
+ 216.0600ms,3.3V 216.0687ms,3.3
+ 216.0688ms,0.0V 216.0799ms,0.0
+ 216.0800ms,3.3V 216.0887ms,3.3
+ 216.0888ms,0.0V 216.0999ms,0.0
+ 216.1000ms,3.3V 216.1087ms,3.3
+ 216.1088ms,0.0V 216.1199ms,0.0
+ 216.1200ms,3.3V 216.1287ms,3.3
+ 216.1288ms,0.0V 216.1399ms,0.0
+ 216.1400ms,3.3V 216.1487ms,3.3
+ 216.1488ms,0.0V 216.1599ms,0.0
+ 216.1600ms,3.3V 216.1687ms,3.3
+ 216.1688ms,0.0V 216.1799ms,0.0
+ 216.1800ms,3.3V 216.1887ms,3.3
+ 216.1888ms,0.0V 216.1999ms,0.0
+ 216.2000ms,3.3V 216.2087ms,3.3
+ 216.2088ms,0.0V 216.2199ms,0.0
+ 216.2200ms,3.3V 216.2287ms,3.3
+ 216.2288ms,0.0V 216.2399ms,0.0
+ 216.2400ms,3.3V 216.2487ms,3.3
+ 216.2488ms,0.0V 216.2599ms,0.0
+ 216.2600ms,3.3V 216.2687ms,3.3
+ 216.2688ms,0.0V 216.2799ms,0.0
+ 216.2800ms,3.3V 216.2887ms,3.3
+ 216.2888ms,0.0V 216.2999ms,0.0
+ 216.3000ms,3.3V 216.3087ms,3.3
+ 216.3088ms,0.0V 216.3199ms,0.0
+ 216.3200ms,3.3V 216.3287ms,3.3
+ 216.3288ms,0.0V 216.3399ms,0.0
+ 216.3400ms,3.3V 216.3487ms,3.3
+ 216.3488ms,0.0V 216.3599ms,0.0
+ 216.3600ms,3.3V 216.3687ms,3.3
+ 216.3688ms,0.0V 216.3799ms,0.0
+ 216.3800ms,3.3V 216.3887ms,3.3
+ 216.3888ms,0.0V 216.3999ms,0.0
+ 216.4000ms,3.3V 216.4087ms,3.3
+ 216.4088ms,0.0V 216.4199ms,0.0
+ 216.4200ms,3.3V 216.4287ms,3.3
+ 216.4288ms,0.0V 216.4399ms,0.0
+ 216.4400ms,3.3V 216.4487ms,3.3
+ 216.4488ms,0.0V 216.4599ms,0.0
+ 216.4600ms,3.3V 216.4687ms,3.3
+ 216.4688ms,0.0V 216.4799ms,0.0
+ 216.4800ms,3.3V 216.4887ms,3.3
+ 216.4888ms,0.0V 216.4999ms,0.0
+ 216.5000ms,3.3V 216.5087ms,3.3
+ 216.5088ms,0.0V 216.5199ms,0.0
+ 216.5200ms,3.3V 216.5287ms,3.3
+ 216.5288ms,0.0V 216.5399ms,0.0
+ 216.5400ms,3.3V 216.5487ms,3.3
+ 216.5488ms,0.0V 216.5599ms,0.0
+ 216.5600ms,3.3V 216.5687ms,3.3
+ 216.5688ms,0.0V 216.5799ms,0.0
+ 216.5800ms,3.3V 216.5887ms,3.3
+ 216.5888ms,0.0V 216.5999ms,0.0
+ 216.6000ms,3.3V 216.6087ms,3.3
+ 216.6088ms,0.0V 216.6199ms,0.0
+ 216.6200ms,3.3V 216.6287ms,3.3
+ 216.6288ms,0.0V 216.6399ms,0.0
+ 216.6400ms,3.3V 216.6487ms,3.3
+ 216.6488ms,0.0V 216.6599ms,0.0
+ 216.6600ms,3.3V 216.6687ms,3.3
+ 216.6688ms,0.0V 216.6799ms,0.0
+ 216.6800ms,3.3V 216.6887ms,3.3
+ 216.6888ms,0.0V 216.6999ms,0.0
+ 216.7000ms,3.3V 216.7087ms,3.3
+ 216.7088ms,0.0V 216.7199ms,0.0
+ 216.7200ms,3.3V 216.7287ms,3.3
+ 216.7288ms,0.0V 216.7399ms,0.0
+ 216.7400ms,3.3V 216.7487ms,3.3
+ 216.7488ms,0.0V 216.7599ms,0.0
+ 216.7600ms,3.3V 216.7687ms,3.3
+ 216.7688ms,0.0V 216.7799ms,0.0
+ 216.7800ms,3.3V 216.7887ms,3.3
+ 216.7888ms,0.0V 216.7999ms,0.0
+ 216.8000ms,3.3V 216.8087ms,3.3
+ 216.8088ms,0.0V 216.8199ms,0.0
+ 216.8200ms,3.3V 216.8287ms,3.3
+ 216.8288ms,0.0V 216.8399ms,0.0
+ 216.8400ms,3.3V 216.8487ms,3.3
+ 216.8488ms,0.0V 216.8599ms,0.0
+ 216.8600ms,3.3V 216.8687ms,3.3
+ 216.8688ms,0.0V 216.8799ms,0.0
+ 216.8800ms,3.3V 216.8887ms,3.3
+ 216.8888ms,0.0V 216.8999ms,0.0
+ 216.9000ms,3.3V 216.9087ms,3.3
+ 216.9088ms,0.0V 216.9199ms,0.0
+ 216.9200ms,3.3V 216.9287ms,3.3
+ 216.9288ms,0.0V 216.9399ms,0.0
+ 216.9400ms,3.3V 216.9487ms,3.3
+ 216.9488ms,0.0V 216.9599ms,0.0
+ 216.9600ms,3.3V 216.9687ms,3.3
+ 216.9688ms,0.0V 216.9799ms,0.0
+ 216.9800ms,3.3V 216.9887ms,3.3
+ 216.9888ms,0.0V 216.9999ms,0.0
+ 217.0000ms,3.3V 217.0087ms,3.3
+ 217.0088ms,0.0V 217.0199ms,0.0
+ 217.0200ms,3.3V 217.0287ms,3.3
+ 217.0288ms,0.0V 217.0399ms,0.0
+ 217.0400ms,3.3V 217.0487ms,3.3
+ 217.0488ms,0.0V 217.0599ms,0.0
+ 217.0600ms,3.3V 217.0687ms,3.3
+ 217.0688ms,0.0V 217.0799ms,0.0
+ 217.0800ms,3.3V 217.0887ms,3.3
+ 217.0888ms,0.0V 217.0999ms,0.0
+ 217.1000ms,3.3V 217.1087ms,3.3
+ 217.1088ms,0.0V 217.1199ms,0.0
+ 217.1200ms,3.3V 217.1287ms,3.3
+ 217.1288ms,0.0V 217.1399ms,0.0
+ 217.1400ms,3.3V 217.1487ms,3.3
+ 217.1488ms,0.0V 217.1599ms,0.0
+ 217.1600ms,3.3V 217.1687ms,3.3
+ 217.1688ms,0.0V 217.1799ms,0.0
+ 217.1800ms,3.3V 217.1887ms,3.3
+ 217.1888ms,0.0V 217.1999ms,0.0
+ 217.2000ms,3.3V 217.2087ms,3.3
+ 217.2088ms,0.0V 217.2199ms,0.0
+ 217.2200ms,3.3V 217.2287ms,3.3
+ 217.2288ms,0.0V 217.2399ms,0.0
+ 217.2400ms,3.3V 217.2487ms,3.3
+ 217.2488ms,0.0V 217.2599ms,0.0
+ 217.2600ms,3.3V 217.2687ms,3.3
+ 217.2688ms,0.0V 217.2799ms,0.0
+ 217.2800ms,3.3V 217.2887ms,3.3
+ 217.2888ms,0.0V 217.2999ms,0.0
+ 217.3000ms,3.3V 217.3087ms,3.3
+ 217.3088ms,0.0V 217.3199ms,0.0
+ 217.3200ms,3.3V 217.3287ms,3.3
+ 217.3288ms,0.0V 217.3399ms,0.0
+ 217.3400ms,3.3V 217.3487ms,3.3
+ 217.3488ms,0.0V 217.3599ms,0.0
+ 217.3600ms,3.3V 217.3687ms,3.3
+ 217.3688ms,0.0V 217.3799ms,0.0
+ 217.3800ms,3.3V 217.3887ms,3.3
+ 217.3888ms,0.0V 217.3999ms,0.0
+ 217.4000ms,3.3V 217.4087ms,3.3
+ 217.4088ms,0.0V 217.4199ms,0.0
+ 217.4200ms,3.3V 217.4287ms,3.3
+ 217.4288ms,0.0V 217.4399ms,0.0
+ 217.4400ms,3.3V 217.4487ms,3.3
+ 217.4488ms,0.0V 217.4599ms,0.0
+ 217.4600ms,3.3V 217.4687ms,3.3
+ 217.4688ms,0.0V 217.4799ms,0.0
+ 217.4800ms,3.3V 217.4887ms,3.3
+ 217.4888ms,0.0V 217.4999ms,0.0
+ 217.5000ms,3.3V 217.5087ms,3.3
+ 217.5088ms,0.0V 217.5199ms,0.0
+ 217.5200ms,3.3V 217.5287ms,3.3
+ 217.5288ms,0.0V 217.5399ms,0.0
+ 217.5400ms,3.3V 217.5487ms,3.3
+ 217.5488ms,0.0V 217.5599ms,0.0
+ 217.5600ms,3.3V 217.5687ms,3.3
+ 217.5688ms,0.0V 217.5799ms,0.0
+ 217.5800ms,3.3V 217.5887ms,3.3
+ 217.5888ms,0.0V 217.5999ms,0.0
+ 217.6000ms,3.3V 217.6087ms,3.3
+ 217.6088ms,0.0V 217.6199ms,0.0
+ 217.6200ms,3.3V 217.6287ms,3.3
+ 217.6288ms,0.0V 217.6399ms,0.0
+ 217.6400ms,3.3V 217.6487ms,3.3
+ 217.6488ms,0.0V 217.6599ms,0.0
+ 217.6600ms,3.3V 217.6687ms,3.3
+ 217.6688ms,0.0V 217.6799ms,0.0
+ 217.6800ms,3.3V 217.6887ms,3.3
+ 217.6888ms,0.0V 217.6999ms,0.0
+ 217.7000ms,3.3V 217.7087ms,3.3
+ 217.7088ms,0.0V 217.7199ms,0.0
+ 217.7200ms,3.3V 217.7287ms,3.3
+ 217.7288ms,0.0V 217.7399ms,0.0
+ 217.7400ms,3.3V 217.7487ms,3.3
+ 217.7488ms,0.0V 217.7599ms,0.0
+ 217.7600ms,3.3V 217.7687ms,3.3
+ 217.7688ms,0.0V 217.7799ms,0.0
+ 217.7800ms,3.3V 217.7887ms,3.3
+ 217.7888ms,0.0V 217.7999ms,0.0
+ 217.8000ms,3.3V 217.8087ms,3.3
+ 217.8088ms,0.0V 217.8199ms,0.0
+ 217.8200ms,3.3V 217.8287ms,3.3
+ 217.8288ms,0.0V 217.8399ms,0.0
+ 217.8400ms,3.3V 217.8487ms,3.3
+ 217.8488ms,0.0V 217.8599ms,0.0
+ 217.8600ms,3.3V 217.8687ms,3.3
+ 217.8688ms,0.0V 217.8799ms,0.0
+ 217.8800ms,3.3V 217.8887ms,3.3
+ 217.8888ms,0.0V 217.8999ms,0.0
+ 217.9000ms,3.3V 217.9087ms,3.3
+ 217.9088ms,0.0V 217.9199ms,0.0
+ 217.9200ms,3.3V 217.9287ms,3.3
+ 217.9288ms,0.0V 217.9399ms,0.0
+ 217.9400ms,3.3V 217.9487ms,3.3
+ 217.9488ms,0.0V 217.9599ms,0.0
+ 217.9600ms,3.3V 217.9687ms,3.3
+ 217.9688ms,0.0V 217.9799ms,0.0
+ 217.9800ms,3.3V 217.9887ms,3.3
+ 217.9888ms,0.0V 217.9999ms,0.0
+ 218.0000ms,3.3V 218.0087ms,3.3
+ 218.0088ms,0.0V 218.0199ms,0.0
+ 218.0200ms,3.3V 218.0287ms,3.3
+ 218.0288ms,0.0V 218.0399ms,0.0
+ 218.0400ms,3.3V 218.0487ms,3.3
+ 218.0488ms,0.0V 218.0599ms,0.0
+ 218.0600ms,3.3V 218.0687ms,3.3
+ 218.0688ms,0.0V 218.0799ms,0.0
+ 218.0800ms,3.3V 218.0887ms,3.3
+ 218.0888ms,0.0V 218.0999ms,0.0
+ 218.1000ms,3.3V 218.1087ms,3.3
+ 218.1088ms,0.0V 218.1199ms,0.0
+ 218.1200ms,3.3V 218.1287ms,3.3
+ 218.1288ms,0.0V 218.1399ms,0.0
+ 218.1400ms,3.3V 218.1487ms,3.3
+ 218.1488ms,0.0V 218.1599ms,0.0
+ 218.1600ms,3.3V 218.1687ms,3.3
+ 218.1688ms,0.0V 218.1799ms,0.0
+ 218.1800ms,3.3V 218.1887ms,3.3
+ 218.1888ms,0.0V 218.1999ms,0.0
+ 218.2000ms,3.3V 218.2087ms,3.3
+ 218.2088ms,0.0V 218.2199ms,0.0
+ 218.2200ms,3.3V 218.2287ms,3.3
+ 218.2288ms,0.0V 218.2399ms,0.0
+ 218.2400ms,3.3V 218.2487ms,3.3
+ 218.2488ms,0.0V 218.2599ms,0.0
+ 218.2600ms,3.3V 218.2687ms,3.3
+ 218.2688ms,0.0V 218.2799ms,0.0
+ 218.2800ms,3.3V 218.2887ms,3.3
+ 218.2888ms,0.0V 218.2999ms,0.0
+ 218.3000ms,3.3V 218.3087ms,3.3
+ 218.3088ms,0.0V 218.3199ms,0.0
+ 218.3200ms,3.3V 218.3287ms,3.3
+ 218.3288ms,0.0V 218.3399ms,0.0
+ 218.3400ms,3.3V 218.3487ms,3.3
+ 218.3488ms,0.0V 218.3599ms,0.0
+ 218.3600ms,3.3V 218.3687ms,3.3
+ 218.3688ms,0.0V 218.3799ms,0.0
+ 218.3800ms,3.3V 218.3887ms,3.3
+ 218.3888ms,0.0V 218.3999ms,0.0
+ 218.4000ms,3.3V 218.4087ms,3.3
+ 218.4088ms,0.0V 218.4199ms,0.0
+ 218.4200ms,3.3V 218.4287ms,3.3
+ 218.4288ms,0.0V 218.4399ms,0.0
+ 218.4400ms,3.3V 218.4487ms,3.3
+ 218.4488ms,0.0V 218.4599ms,0.0
+ 218.4600ms,3.3V 218.4687ms,3.3
+ 218.4688ms,0.0V 218.4799ms,0.0
+ 218.4800ms,3.3V 218.4887ms,3.3
+ 218.4888ms,0.0V 218.4999ms,0.0
+ 218.5000ms,3.3V 218.5087ms,3.3
+ 218.5088ms,0.0V 218.5199ms,0.0
+ 218.5200ms,3.3V 218.5287ms,3.3
+ 218.5288ms,0.0V 218.5399ms,0.0
+ 218.5400ms,3.3V 218.5487ms,3.3
+ 218.5488ms,0.0V 218.5599ms,0.0
+ 218.5600ms,3.3V 218.5687ms,3.3
+ 218.5688ms,0.0V 218.5799ms,0.0
+ 218.5800ms,3.3V 218.5887ms,3.3
+ 218.5888ms,0.0V 218.5999ms,0.0
+ 218.6000ms,3.3V 218.6087ms,3.3
+ 218.6088ms,0.0V 218.6199ms,0.0
+ 218.6200ms,3.3V 218.6287ms,3.3
+ 218.6288ms,0.0V 218.6399ms,0.0
+ 218.6400ms,3.3V 218.6487ms,3.3
+ 218.6488ms,0.0V 218.6599ms,0.0
+ 218.6600ms,3.3V 218.6687ms,3.3
+ 218.6688ms,0.0V 218.6799ms,0.0
+ 218.6800ms,3.3V 218.6887ms,3.3
+ 218.6888ms,0.0V 218.6999ms,0.0
+ 218.7000ms,3.3V 218.7087ms,3.3
+ 218.7088ms,0.0V 218.7199ms,0.0
+ 218.7200ms,3.3V 218.7287ms,3.3
+ 218.7288ms,0.0V 218.7399ms,0.0
+ 218.7400ms,3.3V 218.7487ms,3.3
+ 218.7488ms,0.0V 218.7599ms,0.0
+ 218.7600ms,3.3V 218.7687ms,3.3
+ 218.7688ms,0.0V 218.7799ms,0.0
+ 218.7800ms,3.3V 218.7887ms,3.3
+ 218.7888ms,0.0V 218.7999ms,0.0
+ 218.8000ms,3.3V 218.8087ms,3.3
+ 218.8088ms,0.0V 218.8199ms,0.0
+ 218.8200ms,3.3V 218.8287ms,3.3
+ 218.8288ms,0.0V 218.8399ms,0.0
+ 218.8400ms,3.3V 218.8487ms,3.3
+ 218.8488ms,0.0V 218.8599ms,0.0
+ 218.8600ms,3.3V 218.8687ms,3.3
+ 218.8688ms,0.0V 218.8799ms,0.0
+ 218.8800ms,3.3V 218.8887ms,3.3
+ 218.8888ms,0.0V 218.8999ms,0.0
+ 218.9000ms,3.3V 218.9087ms,3.3
+ 218.9088ms,0.0V 218.9199ms,0.0
+ 218.9200ms,3.3V 218.9287ms,3.3
+ 218.9288ms,0.0V 218.9399ms,0.0
+ 218.9400ms,3.3V 218.9487ms,3.3
+ 218.9488ms,0.0V 218.9599ms,0.0
+ 218.9600ms,3.3V 218.9687ms,3.3
+ 218.9688ms,0.0V 218.9799ms,0.0
+ 218.9800ms,3.3V 218.9887ms,3.3
+ 218.9888ms,0.0V 218.9999ms,0.0
+ 219.0000ms,3.3V 219.0087ms,3.3
+ 219.0088ms,0.0V 219.0199ms,0.0
+ 219.0200ms,3.3V 219.0287ms,3.3
+ 219.0288ms,0.0V 219.0399ms,0.0
+ 219.0400ms,3.3V 219.0487ms,3.3
+ 219.0488ms,0.0V 219.0599ms,0.0
+ 219.0600ms,3.3V 219.0687ms,3.3
+ 219.0688ms,0.0V 219.0799ms,0.0
+ 219.0800ms,3.3V 219.0887ms,3.3
+ 219.0888ms,0.0V 219.0999ms,0.0
+ 219.1000ms,3.3V 219.1087ms,3.3
+ 219.1088ms,0.0V 219.1199ms,0.0
+ 219.1200ms,3.3V 219.1287ms,3.3
+ 219.1288ms,0.0V 219.1399ms,0.0
+ 219.1400ms,3.3V 219.1487ms,3.3
+ 219.1488ms,0.0V 219.1599ms,0.0
+ 219.1600ms,3.3V 219.1687ms,3.3
+ 219.1688ms,0.0V 219.1799ms,0.0
+ 219.1800ms,3.3V 219.1887ms,3.3
+ 219.1888ms,0.0V 219.1999ms,0.0
+ 219.2000ms,3.3V 219.2087ms,3.3
+ 219.2088ms,0.0V 219.2199ms,0.0
+ 219.2200ms,3.3V 219.2287ms,3.3
+ 219.2288ms,0.0V 219.2399ms,0.0
+ 219.2400ms,3.3V 219.2487ms,3.3
+ 219.2488ms,0.0V 219.2599ms,0.0
+ 219.2600ms,3.3V 219.2687ms,3.3
+ 219.2688ms,0.0V 219.2799ms,0.0
+ 219.2800ms,3.3V 219.2887ms,3.3
+ 219.2888ms,0.0V 219.2999ms,0.0
+ 219.3000ms,3.3V 219.3087ms,3.3
+ 219.3088ms,0.0V 219.3199ms,0.0
+ 219.3200ms,3.3V 219.3287ms,3.3
+ 219.3288ms,0.0V 219.3399ms,0.0
+ 219.3400ms,3.3V 219.3487ms,3.3
+ 219.3488ms,0.0V 219.3599ms,0.0
+ 219.3600ms,3.3V 219.3687ms,3.3
+ 219.3688ms,0.0V 219.3799ms,0.0
+ 219.3800ms,3.3V 219.3887ms,3.3
+ 219.3888ms,0.0V 219.3999ms,0.0
+ 219.4000ms,3.3V 219.4087ms,3.3
+ 219.4088ms,0.0V 219.4199ms,0.0
+ 219.4200ms,3.3V 219.4287ms,3.3
+ 219.4288ms,0.0V 219.4399ms,0.0
+ 219.4400ms,3.3V 219.4487ms,3.3
+ 219.4488ms,0.0V 219.4599ms,0.0
+ 219.4600ms,3.3V 219.4687ms,3.3
+ 219.4688ms,0.0V 219.4799ms,0.0
+ 219.4800ms,3.3V 219.4887ms,3.3
+ 219.4888ms,0.0V 219.4999ms,0.0
+ 219.5000ms,3.3V 219.5087ms,3.3
+ 219.5088ms,0.0V 219.5199ms,0.0
+ 219.5200ms,3.3V 219.5287ms,3.3
+ 219.5288ms,0.0V 219.5399ms,0.0
+ 219.5400ms,3.3V 219.5487ms,3.3
+ 219.5488ms,0.0V 219.5599ms,0.0
+ 219.5600ms,3.3V 219.5687ms,3.3
+ 219.5688ms,0.0V 219.5799ms,0.0
+ 219.5800ms,3.3V 219.5887ms,3.3
+ 219.5888ms,0.0V 219.5999ms,0.0
+ 219.6000ms,3.3V 219.6087ms,3.3
+ 219.6088ms,0.0V 219.6199ms,0.0
+ 219.6200ms,3.3V 219.6287ms,3.3
+ 219.6288ms,0.0V 219.6399ms,0.0
+ 219.6400ms,3.3V 219.6487ms,3.3
+ 219.6488ms,0.0V 219.6599ms,0.0
+ 219.6600ms,3.3V 219.6687ms,3.3
+ 219.6688ms,0.0V 219.6799ms,0.0
+ 219.6800ms,3.3V 219.6887ms,3.3
+ 219.6888ms,0.0V 219.6999ms,0.0
+ 219.7000ms,3.3V 219.7087ms,3.3
+ 219.7088ms,0.0V 219.7199ms,0.0
+ 219.7200ms,3.3V 219.7287ms,3.3
+ 219.7288ms,0.0V 219.7399ms,0.0
+ 219.7400ms,3.3V 219.7487ms,3.3
+ 219.7488ms,0.0V 219.7599ms,0.0
+ 219.7600ms,3.3V 219.7687ms,3.3
+ 219.7688ms,0.0V 219.7799ms,0.0
+ 219.7800ms,3.3V 219.7887ms,3.3
+ 219.7888ms,0.0V 219.7999ms,0.0
+ 219.8000ms,3.3V 219.8087ms,3.3
+ 219.8088ms,0.0V 219.8199ms,0.0
+ 219.8200ms,3.3V 219.8287ms,3.3
+ 219.8288ms,0.0V 219.8399ms,0.0
+ 219.8400ms,3.3V 219.8487ms,3.3
+ 219.8488ms,0.0V 219.8599ms,0.0
+ 219.8600ms,3.3V 219.8687ms,3.3
+ 219.8688ms,0.0V 219.8799ms,0.0
+ 219.8800ms,3.3V 219.8887ms,3.3
+ 219.8888ms,0.0V 219.8999ms,0.0
+ 219.9000ms,3.3V 219.9087ms,3.3
+ 219.9088ms,0.0V 219.9199ms,0.0
+ 219.9200ms,3.3V 219.9287ms,3.3
+ 219.9288ms,0.0V 219.9399ms,0.0
+ 219.9400ms,3.3V 219.9487ms,3.3
+ 219.9488ms,0.0V 219.9599ms,0.0
+ 219.9600ms,3.3V 219.9687ms,3.3
+ 219.9688ms,0.0V 219.9799ms,0.0
+ 219.9800ms,3.3V 219.9887ms,3.3
+ 219.9888ms,0.0V 219.9999ms,0.0
+ 220.0000ms,3.3V 220.0087ms,3.3
+ 220.0088ms,0.0V 220.0199ms,0.0
+ 220.0200ms,3.3V 220.0287ms,3.3
+ 220.0288ms,0.0V 220.0399ms,0.0
+ 220.0400ms,3.3V 220.0487ms,3.3
+ 220.0488ms,0.0V 220.0599ms,0.0
+ 220.0600ms,3.3V 220.0687ms,3.3
+ 220.0688ms,0.0V 220.0799ms,0.0
+ 220.0800ms,3.3V 220.0887ms,3.3
+ 220.0888ms,0.0V 220.0999ms,0.0
+ 220.1000ms,3.3V 220.1087ms,3.3
+ 220.1088ms,0.0V 220.1199ms,0.0
+ 220.1200ms,3.3V 220.1287ms,3.3
+ 220.1288ms,0.0V 220.1399ms,0.0
+ 220.1400ms,3.3V 220.1487ms,3.3
+ 220.1488ms,0.0V 220.1599ms,0.0
+ 220.1600ms,3.3V 220.1687ms,3.3
+ 220.1688ms,0.0V 220.1799ms,0.0
+ 220.1800ms,3.3V 220.1887ms,3.3
+ 220.1888ms,0.0V 220.1999ms,0.0
+ 220.2000ms,3.3V 220.2087ms,3.3
+ 220.2088ms,0.0V 220.2199ms,0.0
+ 220.2200ms,3.3V 220.2287ms,3.3
+ 220.2288ms,0.0V 220.2399ms,0.0
+ 220.2400ms,3.3V 220.2487ms,3.3
+ 220.2488ms,0.0V 220.2599ms,0.0
+ 220.2600ms,3.3V 220.2687ms,3.3
+ 220.2688ms,0.0V 220.2799ms,0.0
+ 220.2800ms,3.3V 220.2887ms,3.3
+ 220.2888ms,0.0V 220.2999ms,0.0
+ 220.3000ms,3.3V 220.3087ms,3.3
+ 220.3088ms,0.0V 220.3199ms,0.0
+ 220.3200ms,3.3V 220.3287ms,3.3
+ 220.3288ms,0.0V 220.3399ms,0.0
+ 220.3400ms,3.3V 220.3487ms,3.3
+ 220.3488ms,0.0V 220.3599ms,0.0
+ 220.3600ms,3.3V 220.3689ms,3.3
+ 220.3690ms,0.0V 220.3799ms,0.0
+ 220.3800ms,3.3V 220.3889ms,3.3
+ 220.3890ms,0.0V 220.3999ms,0.0
+ 220.4000ms,3.3V 220.4089ms,3.3
+ 220.4090ms,0.0V 220.4199ms,0.0
+ 220.4200ms,3.3V 220.4289ms,3.3
+ 220.4290ms,0.0V 220.4399ms,0.0
+ 220.4400ms,3.3V 220.4489ms,3.3
+ 220.4490ms,0.0V 220.4599ms,0.0
+ 220.4600ms,3.3V 220.4689ms,3.3
+ 220.4690ms,0.0V 220.4799ms,0.0
+ 220.4800ms,3.3V 220.4889ms,3.3
+ 220.4890ms,0.0V 220.4999ms,0.0
+ 220.5000ms,3.3V 220.5089ms,3.3
+ 220.5090ms,0.0V 220.5199ms,0.0
+ 220.5200ms,3.3V 220.5289ms,3.3
+ 220.5290ms,0.0V 220.5399ms,0.0
+ 220.5400ms,3.3V 220.5489ms,3.3
+ 220.5490ms,0.0V 220.5599ms,0.0
+ 220.5600ms,3.3V 220.5689ms,3.3
+ 220.5690ms,0.0V 220.5799ms,0.0
+ 220.5800ms,3.3V 220.5889ms,3.3
+ 220.5890ms,0.0V 220.5999ms,0.0
+ 220.6000ms,3.3V 220.6089ms,3.3
+ 220.6090ms,0.0V 220.6199ms,0.0
+ 220.6200ms,3.3V 220.6289ms,3.3
+ 220.6290ms,0.0V 220.6399ms,0.0
+ 220.6400ms,3.3V 220.6489ms,3.3
+ 220.6490ms,0.0V 220.6599ms,0.0
+ 220.6600ms,3.3V 220.6689ms,3.3
+ 220.6690ms,0.0V 220.6799ms,0.0
+ 220.6800ms,3.3V 220.6889ms,3.3
+ 220.6890ms,0.0V 220.6999ms,0.0
+ 220.7000ms,3.3V 220.7089ms,3.3
+ 220.7090ms,0.0V 220.7199ms,0.0
+ 220.7200ms,3.3V 220.7289ms,3.3
+ 220.7290ms,0.0V 220.7399ms,0.0
+ 220.7400ms,3.3V 220.7489ms,3.3
+ 220.7490ms,0.0V 220.7599ms,0.0
+ 220.7600ms,3.3V 220.7689ms,3.3
+ 220.7690ms,0.0V 220.7799ms,0.0
+ 220.7800ms,3.3V 220.7889ms,3.3
+ 220.7890ms,0.0V 220.7999ms,0.0
+ 220.8000ms,3.3V 220.8089ms,3.3
+ 220.8090ms,0.0V 220.8199ms,0.0
+ 220.8200ms,3.3V 220.8289ms,3.3
+ 220.8290ms,0.0V 220.8399ms,0.0
+ 220.8400ms,3.3V 220.8489ms,3.3
+ 220.8490ms,0.0V 220.8599ms,0.0
+ 220.8600ms,3.3V 220.8689ms,3.3
+ 220.8690ms,0.0V 220.8799ms,0.0
+ 220.8800ms,3.3V 220.8889ms,3.3
+ 220.8890ms,0.0V 220.8999ms,0.0
+ 220.9000ms,3.3V 220.9089ms,3.3
+ 220.9090ms,0.0V 220.9199ms,0.0
+ 220.9200ms,3.3V 220.9289ms,3.3
+ 220.9290ms,0.0V 220.9399ms,0.0
+ 220.9400ms,3.3V 220.9489ms,3.3
+ 220.9490ms,0.0V 220.9599ms,0.0
+ 220.9600ms,3.3V 220.9689ms,3.3
+ 220.9690ms,0.0V 220.9799ms,0.0
+ 220.9800ms,3.3V 220.9889ms,3.3
+ 220.9890ms,0.0V 220.9999ms,0.0
+ 221.0000ms,3.3V 221.0089ms,3.3
+ 221.0090ms,0.0V 221.0199ms,0.0
+ 221.0200ms,3.3V 221.0289ms,3.3
+ 221.0290ms,0.0V 221.0399ms,0.0
+ 221.0400ms,3.3V 221.0489ms,3.3
+ 221.0490ms,0.0V 221.0599ms,0.0
+ 221.0600ms,3.3V 221.0689ms,3.3
+ 221.0690ms,0.0V 221.0799ms,0.0
+ 221.0800ms,3.3V 221.0889ms,3.3
+ 221.0890ms,0.0V 221.0999ms,0.0
+ 221.1000ms,3.3V 221.1089ms,3.3
+ 221.1090ms,0.0V 221.1199ms,0.0
+ 221.1200ms,3.3V 221.1289ms,3.3
+ 221.1290ms,0.0V 221.1399ms,0.0
+ 221.1400ms,3.3V 221.1489ms,3.3
+ 221.1490ms,0.0V 221.1599ms,0.0
+ 221.1600ms,3.3V 221.1689ms,3.3
+ 221.1690ms,0.0V 221.1799ms,0.0
+ 221.1800ms,3.3V 221.1889ms,3.3
+ 221.1890ms,0.0V 221.1999ms,0.0
+ 221.2000ms,3.3V 221.2089ms,3.3
+ 221.2090ms,0.0V 221.2199ms,0.0
+ 221.2200ms,3.3V 221.2289ms,3.3
+ 221.2290ms,0.0V 221.2399ms,0.0
+ 221.2400ms,3.3V 221.2489ms,3.3
+ 221.2490ms,0.0V 221.2599ms,0.0
+ 221.2600ms,3.3V 221.2689ms,3.3
+ 221.2690ms,0.0V 221.2799ms,0.0
+ 221.2800ms,3.3V 221.2889ms,3.3
+ 221.2890ms,0.0V 221.2999ms,0.0
+ 221.3000ms,3.3V 221.3089ms,3.3
+ 221.3090ms,0.0V 221.3199ms,0.0
+ 221.3200ms,3.3V 221.3289ms,3.3
+ 221.3290ms,0.0V 221.3399ms,0.0
+ 221.3400ms,3.3V 221.3489ms,3.3
+ 221.3490ms,0.0V 221.3599ms,0.0
+ 221.3600ms,3.3V 221.3689ms,3.3
+ 221.3690ms,0.0V 221.3799ms,0.0
+ 221.3800ms,3.3V 221.3889ms,3.3
+ 221.3890ms,0.0V 221.3999ms,0.0
+ 221.4000ms,3.3V 221.4089ms,3.3
+ 221.4090ms,0.0V 221.4199ms,0.0
+ 221.4200ms,3.3V 221.4289ms,3.3
+ 221.4290ms,0.0V 221.4399ms,0.0
+ 221.4400ms,3.3V 221.4489ms,3.3
+ 221.4490ms,0.0V 221.4599ms,0.0
+ 221.4600ms,3.3V 221.4689ms,3.3
+ 221.4690ms,0.0V 221.4799ms,0.0
+ 221.4800ms,3.3V 221.4889ms,3.3
+ 221.4890ms,0.0V 221.4999ms,0.0
+ 221.5000ms,3.3V 221.5089ms,3.3
+ 221.5090ms,0.0V 221.5199ms,0.0
+ 221.5200ms,3.3V 221.5289ms,3.3
+ 221.5290ms,0.0V 221.5399ms,0.0
+ 221.5400ms,3.3V 221.5489ms,3.3
+ 221.5490ms,0.0V 221.5599ms,0.0
+ 221.5600ms,3.3V 221.5689ms,3.3
+ 221.5690ms,0.0V 221.5799ms,0.0
+ 221.5800ms,3.3V 221.5889ms,3.3
+ 221.5890ms,0.0V 221.5999ms,0.0
+ 221.6000ms,3.3V 221.6089ms,3.3
+ 221.6090ms,0.0V 221.6199ms,0.0
+ 221.6200ms,3.3V 221.6289ms,3.3
+ 221.6290ms,0.0V 221.6399ms,0.0
+ 221.6400ms,3.3V 221.6489ms,3.3
+ 221.6490ms,0.0V 221.6599ms,0.0
+ 221.6600ms,3.3V 221.6689ms,3.3
+ 221.6690ms,0.0V 221.6799ms,0.0
+ 221.6800ms,3.3V 221.6889ms,3.3
+ 221.6890ms,0.0V 221.6999ms,0.0
+ 221.7000ms,3.3V 221.7089ms,3.3
+ 221.7090ms,0.0V 221.7199ms,0.0
+ 221.7200ms,3.3V 221.7289ms,3.3
+ 221.7290ms,0.0V 221.7399ms,0.0
+ 221.7400ms,3.3V 221.7489ms,3.3
+ 221.7490ms,0.0V 221.7599ms,0.0
+ 221.7600ms,3.3V 221.7689ms,3.3
+ 221.7690ms,0.0V 221.7799ms,0.0
+ 221.7800ms,3.3V 221.7889ms,3.3
+ 221.7890ms,0.0V 221.7999ms,0.0
+ 221.8000ms,3.3V 221.8089ms,3.3
+ 221.8090ms,0.0V 221.8199ms,0.0
+ 221.8200ms,3.3V 221.8289ms,3.3
+ 221.8290ms,0.0V 221.8399ms,0.0
+ 221.8400ms,3.3V 221.8489ms,3.3
+ 221.8490ms,0.0V 221.8599ms,0.0
+ 221.8600ms,3.3V 221.8689ms,3.3
+ 221.8690ms,0.0V 221.8799ms,0.0
+ 221.8800ms,3.3V 221.8889ms,3.3
+ 221.8890ms,0.0V 221.8999ms,0.0
+ 221.9000ms,3.3V 221.9089ms,3.3
+ 221.9090ms,0.0V 221.9199ms,0.0
+ 221.9200ms,3.3V 221.9289ms,3.3
+ 221.9290ms,0.0V 221.9399ms,0.0
+ 221.9400ms,3.3V 221.9489ms,3.3
+ 221.9490ms,0.0V 221.9599ms,0.0
+ 221.9600ms,3.3V 221.9689ms,3.3
+ 221.9690ms,0.0V 221.9799ms,0.0
+ 221.9800ms,3.3V 221.9889ms,3.3
+ 221.9890ms,0.0V 221.9999ms,0.0
+ 222.0000ms,3.3V 222.0089ms,3.3
+ 222.0090ms,0.0V 222.0199ms,0.0
+ 222.0200ms,3.3V 222.0289ms,3.3
+ 222.0290ms,0.0V 222.0399ms,0.0
+ 222.0400ms,3.3V 222.0489ms,3.3
+ 222.0490ms,0.0V 222.0599ms,0.0
+ 222.0600ms,3.3V 222.0689ms,3.3
+ 222.0690ms,0.0V 222.0799ms,0.0
+ 222.0800ms,3.3V 222.0889ms,3.3
+ 222.0890ms,0.0V 222.0999ms,0.0
+ 222.1000ms,3.3V 222.1089ms,3.3
+ 222.1090ms,0.0V 222.1199ms,0.0
+ 222.1200ms,3.3V 222.1289ms,3.3
+ 222.1290ms,0.0V 222.1399ms,0.0
+ 222.1400ms,3.3V 222.1489ms,3.3
+ 222.1490ms,0.0V 222.1599ms,0.0
+ 222.1600ms,3.3V 222.1689ms,3.3
+ 222.1690ms,0.0V 222.1799ms,0.0
+ 222.1800ms,3.3V 222.1889ms,3.3
+ 222.1890ms,0.0V 222.1999ms,0.0
+ 222.2000ms,3.3V 222.2089ms,3.3
+ 222.2090ms,0.0V 222.2199ms,0.0
+ 222.2200ms,3.3V 222.2289ms,3.3
+ 222.2290ms,0.0V 222.2399ms,0.0
+ 222.2400ms,3.3V 222.2489ms,3.3
+ 222.2490ms,0.0V 222.2599ms,0.0
+ 222.2600ms,3.3V 222.2689ms,3.3
+ 222.2690ms,0.0V 222.2799ms,0.0
+ 222.2800ms,3.3V 222.2889ms,3.3
+ 222.2890ms,0.0V 222.2999ms,0.0
+ 222.3000ms,3.3V 222.3089ms,3.3
+ 222.3090ms,0.0V 222.3199ms,0.0
+ 222.3200ms,3.3V 222.3289ms,3.3
+ 222.3290ms,0.0V 222.3399ms,0.0
+ 222.3400ms,3.3V 222.3489ms,3.3
+ 222.3490ms,0.0V 222.3599ms,0.0
+ 222.3600ms,3.3V 222.3689ms,3.3
+ 222.3690ms,0.0V 222.3799ms,0.0
+ 222.3800ms,3.3V 222.3889ms,3.3
+ 222.3890ms,0.0V 222.3999ms,0.0
+ 222.4000ms,3.3V 222.4089ms,3.3
+ 222.4090ms,0.0V 222.4199ms,0.0
+ 222.4200ms,3.3V 222.4289ms,3.3
+ 222.4290ms,0.0V 222.4399ms,0.0
+ 222.4400ms,3.3V 222.4489ms,3.3
+ 222.4490ms,0.0V 222.4599ms,0.0
+ 222.4600ms,3.3V 222.4689ms,3.3
+ 222.4690ms,0.0V 222.4799ms,0.0
+ 222.4800ms,3.3V 222.4889ms,3.3
+ 222.4890ms,0.0V 222.4999ms,0.0
+ 222.5000ms,3.3V 222.5089ms,3.3
+ 222.5090ms,0.0V 222.5199ms,0.0
+ 222.5200ms,3.3V 222.5289ms,3.3
+ 222.5290ms,0.0V 222.5399ms,0.0
+ 222.5400ms,3.3V 222.5489ms,3.3
+ 222.5490ms,0.0V 222.5599ms,0.0
+ 222.5600ms,3.3V 222.5689ms,3.3
+ 222.5690ms,0.0V 222.5799ms,0.0
+ 222.5800ms,3.3V 222.5889ms,3.3
+ 222.5890ms,0.0V 222.5999ms,0.0
+ 222.6000ms,3.3V 222.6089ms,3.3
+ 222.6090ms,0.0V 222.6199ms,0.0
+ 222.6200ms,3.3V 222.6289ms,3.3
+ 222.6290ms,0.0V 222.6399ms,0.0
+ 222.6400ms,3.3V 222.6489ms,3.3
+ 222.6490ms,0.0V 222.6599ms,0.0
+ 222.6600ms,3.3V 222.6689ms,3.3
+ 222.6690ms,0.0V 222.6799ms,0.0
+ 222.6800ms,3.3V 222.6889ms,3.3
+ 222.6890ms,0.0V 222.6999ms,0.0
+ 222.7000ms,3.3V 222.7089ms,3.3
+ 222.7090ms,0.0V 222.7199ms,0.0
+ 222.7200ms,3.3V 222.7289ms,3.3
+ 222.7290ms,0.0V 222.7399ms,0.0
+ 222.7400ms,3.3V 222.7489ms,3.3
+ 222.7490ms,0.0V 222.7599ms,0.0
+ 222.7600ms,3.3V 222.7689ms,3.3
+ 222.7690ms,0.0V 222.7799ms,0.0
+ 222.7800ms,3.3V 222.7889ms,3.3
+ 222.7890ms,0.0V 222.7999ms,0.0
+ 222.8000ms,3.3V 222.8089ms,3.3
+ 222.8090ms,0.0V 222.8199ms,0.0
+ 222.8200ms,3.3V 222.8289ms,3.3
+ 222.8290ms,0.0V 222.8399ms,0.0
+ 222.8400ms,3.3V 222.8489ms,3.3
+ 222.8490ms,0.0V 222.8599ms,0.0
+ 222.8600ms,3.3V 222.8689ms,3.3
+ 222.8690ms,0.0V 222.8799ms,0.0
+ 222.8800ms,3.3V 222.8889ms,3.3
+ 222.8890ms,0.0V 222.8999ms,0.0
+ 222.9000ms,3.3V 222.9089ms,3.3
+ 222.9090ms,0.0V 222.9199ms,0.0
+ 222.9200ms,3.3V 222.9289ms,3.3
+ 222.9290ms,0.0V 222.9399ms,0.0
+ 222.9400ms,3.3V 222.9489ms,3.3
+ 222.9490ms,0.0V 222.9599ms,0.0
+ 222.9600ms,3.3V 222.9689ms,3.3
+ 222.9690ms,0.0V 222.9799ms,0.0
+ 222.9800ms,3.3V 222.9889ms,3.3
+ 222.9890ms,0.0V 222.9999ms,0.0
+ 223.0000ms,3.3V 223.0089ms,3.3
+ 223.0090ms,0.0V 223.0199ms,0.0
+ 223.0200ms,3.3V 223.0289ms,3.3
+ 223.0290ms,0.0V 223.0399ms,0.0
+ 223.0400ms,3.3V 223.0489ms,3.3
+ 223.0490ms,0.0V 223.0599ms,0.0
+ 223.0600ms,3.3V 223.0689ms,3.3
+ 223.0690ms,0.0V 223.0799ms,0.0
+ 223.0800ms,3.3V 223.0889ms,3.3
+ 223.0890ms,0.0V 223.0999ms,0.0
+ 223.1000ms,3.3V 223.1089ms,3.3
+ 223.1090ms,0.0V 223.1199ms,0.0
+ 223.1200ms,3.3V 223.1289ms,3.3
+ 223.1290ms,0.0V 223.1399ms,0.0
+ 223.1400ms,3.3V 223.1489ms,3.3
+ 223.1490ms,0.0V 223.1599ms,0.0
+ 223.1600ms,3.3V 223.1689ms,3.3
+ 223.1690ms,0.0V 223.1799ms,0.0
+ 223.1800ms,3.3V 223.1889ms,3.3
+ 223.1890ms,0.0V 223.1999ms,0.0
+ 223.2000ms,3.3V 223.2089ms,3.3
+ 223.2090ms,0.0V 223.2199ms,0.0
+ 223.2200ms,3.3V 223.2289ms,3.3
+ 223.2290ms,0.0V 223.2399ms,0.0
+ 223.2400ms,3.3V 223.2489ms,3.3
+ 223.2490ms,0.0V 223.2599ms,0.0
+ 223.2600ms,3.3V 223.2689ms,3.3
+ 223.2690ms,0.0V 223.2799ms,0.0
+ 223.2800ms,3.3V 223.2889ms,3.3
+ 223.2890ms,0.0V 223.2999ms,0.0
+ 223.3000ms,3.3V 223.3089ms,3.3
+ 223.3090ms,0.0V 223.3199ms,0.0
+ 223.3200ms,3.3V 223.3289ms,3.3
+ 223.3290ms,0.0V 223.3399ms,0.0
+ 223.3400ms,3.3V 223.3489ms,3.3
+ 223.3490ms,0.0V 223.3599ms,0.0
+ 223.3600ms,3.3V 223.3689ms,3.3
+ 223.3690ms,0.0V 223.3799ms,0.0
+ 223.3800ms,3.3V 223.3889ms,3.3
+ 223.3890ms,0.0V 223.3999ms,0.0
+ 223.4000ms,3.3V 223.4089ms,3.3
+ 223.4090ms,0.0V 223.4199ms,0.0
+ 223.4200ms,3.3V 223.4289ms,3.3
+ 223.4290ms,0.0V 223.4399ms,0.0
+ 223.4400ms,3.3V 223.4489ms,3.3
+ 223.4490ms,0.0V 223.4599ms,0.0
+ 223.4600ms,3.3V 223.4689ms,3.3
+ 223.4690ms,0.0V 223.4799ms,0.0
+ 223.4800ms,3.3V 223.4889ms,3.3
+ 223.4890ms,0.0V 223.4999ms,0.0
+ 223.5000ms,3.3V 223.5089ms,3.3
+ 223.5090ms,0.0V 223.5199ms,0.0
+ 223.5200ms,3.3V 223.5289ms,3.3
+ 223.5290ms,0.0V 223.5399ms,0.0
+ 223.5400ms,3.3V 223.5489ms,3.3
+ 223.5490ms,0.0V 223.5599ms,0.0
+ 223.5600ms,3.3V 223.5689ms,3.3
+ 223.5690ms,0.0V 223.5799ms,0.0
+ 223.5800ms,3.3V 223.5889ms,3.3
+ 223.5890ms,0.0V 223.5999ms,0.0
+ 223.6000ms,3.3V 223.6089ms,3.3
+ 223.6090ms,0.0V 223.6199ms,0.0
+ 223.6200ms,3.3V 223.6289ms,3.3
+ 223.6290ms,0.0V 223.6399ms,0.0
+ 223.6400ms,3.3V 223.6489ms,3.3
+ 223.6490ms,0.0V 223.6599ms,0.0
+ 223.6600ms,3.3V 223.6689ms,3.3
+ 223.6690ms,0.0V 223.6799ms,0.0
+ 223.6800ms,3.3V 223.6889ms,3.3
+ 223.6890ms,0.0V 223.6999ms,0.0
+ 223.7000ms,3.3V 223.7089ms,3.3
+ 223.7090ms,0.0V 223.7199ms,0.0
+ 223.7200ms,3.3V 223.7289ms,3.3
+ 223.7290ms,0.0V 223.7399ms,0.0
+ 223.7400ms,3.3V 223.7489ms,3.3
+ 223.7490ms,0.0V 223.7599ms,0.0
+ 223.7600ms,3.3V 223.7689ms,3.3
+ 223.7690ms,0.0V 223.7799ms,0.0
+ 223.7800ms,3.3V 223.7889ms,3.3
+ 223.7890ms,0.0V 223.7999ms,0.0
+ 223.8000ms,3.3V 223.8089ms,3.3
+ 223.8090ms,0.0V 223.8199ms,0.0
+ 223.8200ms,3.3V 223.8289ms,3.3
+ 223.8290ms,0.0V 223.8399ms,0.0
+ 223.8400ms,3.3V 223.8489ms,3.3
+ 223.8490ms,0.0V 223.8599ms,0.0
+ 223.8600ms,3.3V 223.8689ms,3.3
+ 223.8690ms,0.0V 223.8799ms,0.0
+ 223.8800ms,3.3V 223.8889ms,3.3
+ 223.8890ms,0.0V 223.8999ms,0.0
+ 223.9000ms,3.3V 223.9089ms,3.3
+ 223.9090ms,0.0V 223.9199ms,0.0
+ 223.9200ms,3.3V 223.9289ms,3.3
+ 223.9290ms,0.0V 223.9399ms,0.0
+ 223.9400ms,3.3V 223.9489ms,3.3
+ 223.9490ms,0.0V 223.9599ms,0.0
+ 223.9600ms,3.3V 223.9689ms,3.3
+ 223.9690ms,0.0V 223.9799ms,0.0
+ 223.9800ms,3.3V 223.9889ms,3.3
+ 223.9890ms,0.0V 223.9999ms,0.0
+ 224.0000ms,3.3V 224.0089ms,3.3
+ 224.0090ms,0.0V 224.0199ms,0.0
+ 224.0200ms,3.3V 224.0289ms,3.3
+ 224.0290ms,0.0V 224.0399ms,0.0
+ 224.0400ms,3.3V 224.0489ms,3.3
+ 224.0490ms,0.0V 224.0599ms,0.0
+ 224.0600ms,3.3V 224.0689ms,3.3
+ 224.0690ms,0.0V 224.0799ms,0.0
+ 224.0800ms,3.3V 224.0889ms,3.3
+ 224.0890ms,0.0V 224.0999ms,0.0
+ 224.1000ms,3.3V 224.1089ms,3.3
+ 224.1090ms,0.0V 224.1199ms,0.0
+ 224.1200ms,3.3V 224.1289ms,3.3
+ 224.1290ms,0.0V 224.1399ms,0.0
+ 224.1400ms,3.3V 224.1489ms,3.3
+ 224.1490ms,0.0V 224.1599ms,0.0
+ 224.1600ms,3.3V 224.1689ms,3.3
+ 224.1690ms,0.0V 224.1799ms,0.0
+ 224.1800ms,3.3V 224.1889ms,3.3
+ 224.1890ms,0.0V 224.1999ms,0.0
+ 224.2000ms,3.3V 224.2089ms,3.3
+ 224.2090ms,0.0V 224.2199ms,0.0
+ 224.2200ms,3.3V 224.2289ms,3.3
+ 224.2290ms,0.0V 224.2399ms,0.0
+ 224.2400ms,3.3V 224.2489ms,3.3
+ 224.2490ms,0.0V 224.2599ms,0.0
+ 224.2600ms,3.3V 224.2689ms,3.3
+ 224.2690ms,0.0V 224.2799ms,0.0
+ 224.2800ms,3.3V 224.2889ms,3.3
+ 224.2890ms,0.0V 224.2999ms,0.0
+ 224.3000ms,3.3V 224.3089ms,3.3
+ 224.3090ms,0.0V 224.3199ms,0.0
+ 224.3200ms,3.3V 224.3289ms,3.3
+ 224.3290ms,0.0V 224.3399ms,0.0
+ 224.3400ms,3.3V 224.3489ms,3.3
+ 224.3490ms,0.0V 224.3599ms,0.0
+ 224.3600ms,3.3V 224.3689ms,3.3
+ 224.3690ms,0.0V 224.3799ms,0.0
+ 224.3800ms,3.3V 224.3889ms,3.3
+ 224.3890ms,0.0V 224.3999ms,0.0
+ 224.4000ms,3.3V 224.4089ms,3.3
+ 224.4090ms,0.0V 224.4199ms,0.0
+ 224.4200ms,3.3V 224.4289ms,3.3
+ 224.4290ms,0.0V 224.4399ms,0.0
+ 224.4400ms,3.3V 224.4489ms,3.3
+ 224.4490ms,0.0V 224.4599ms,0.0
+ 224.4600ms,3.3V 224.4689ms,3.3
+ 224.4690ms,0.0V 224.4799ms,0.0
+ 224.4800ms,3.3V 224.4889ms,3.3
+ 224.4890ms,0.0V 224.4999ms,0.0
+ 224.5000ms,3.3V 224.5089ms,3.3
+ 224.5090ms,0.0V 224.5199ms,0.0
+ 224.5200ms,3.3V 224.5289ms,3.3
+ 224.5290ms,0.0V 224.5399ms,0.0
+ 224.5400ms,3.3V 224.5489ms,3.3
+ 224.5490ms,0.0V 224.5599ms,0.0
+ 224.5600ms,3.3V 224.5689ms,3.3
+ 224.5690ms,0.0V 224.5799ms,0.0
+ 224.5800ms,3.3V 224.5889ms,3.3
+ 224.5890ms,0.0V 224.5999ms,0.0
+ 224.6000ms,3.3V 224.6089ms,3.3
+ 224.6090ms,0.0V 224.6199ms,0.0
+ 224.6200ms,3.3V 224.6289ms,3.3
+ 224.6290ms,0.0V 224.6399ms,0.0
+ 224.6400ms,3.3V 224.6489ms,3.3
+ 224.6490ms,0.0V 224.6599ms,0.0
+ 224.6600ms,3.3V 224.6689ms,3.3
+ 224.6690ms,0.0V 224.6799ms,0.0
+ 224.6800ms,3.3V 224.6889ms,3.3
+ 224.6890ms,0.0V 224.6999ms,0.0
+ 224.7000ms,3.3V 224.7089ms,3.3
+ 224.7090ms,0.0V 224.7199ms,0.0
+ 224.7200ms,3.3V 224.7289ms,3.3
+ 224.7290ms,0.0V 224.7399ms,0.0
+ 224.7400ms,3.3V 224.7489ms,3.3
+ 224.7490ms,0.0V 224.7599ms,0.0
+ 224.7600ms,3.3V 224.7689ms,3.3
+ 224.7690ms,0.0V 224.7799ms,0.0
+ 224.7800ms,3.3V 224.7889ms,3.3
+ 224.7890ms,0.0V 224.7999ms,0.0
+ 224.8000ms,3.3V 224.8089ms,3.3
+ 224.8090ms,0.0V 224.8199ms,0.0
+ 224.8200ms,3.3V 224.8289ms,3.3
+ 224.8290ms,0.0V 224.8399ms,0.0
+ 224.8400ms,3.3V 224.8489ms,3.3
+ 224.8490ms,0.0V 224.8599ms,0.0
+ 224.8600ms,3.3V 224.8689ms,3.3
+ 224.8690ms,0.0V 224.8799ms,0.0
+ 224.8800ms,3.3V 224.8889ms,3.3
+ 224.8890ms,0.0V 224.8999ms,0.0
+ 224.9000ms,3.3V 224.9089ms,3.3
+ 224.9090ms,0.0V 224.9199ms,0.0
+ 224.9200ms,3.3V 224.9289ms,3.3
+ 224.9290ms,0.0V 224.9399ms,0.0
+ 224.9400ms,3.3V 224.9489ms,3.3
+ 224.9490ms,0.0V 224.9599ms,0.0
+ 224.9600ms,3.3V 224.9689ms,3.3
+ 224.9690ms,0.0V 224.9799ms,0.0
+ 224.9800ms,3.3V 224.9889ms,3.3
+ 224.9890ms,0.0V 224.9999ms,0.0
+ 225.0000ms,3.3V 225.0089ms,3.3
+ 225.0090ms,0.0V 225.0199ms,0.0
+ 225.0200ms,3.3V 225.0289ms,3.3
+ 225.0290ms,0.0V 225.0399ms,0.0
+ 225.0400ms,3.3V 225.0489ms,3.3
+ 225.0490ms,0.0V 225.0599ms,0.0
+ 225.0600ms,3.3V 225.0689ms,3.3
+ 225.0690ms,0.0V 225.0799ms,0.0
+ 225.0800ms,3.3V 225.0889ms,3.3
+ 225.0890ms,0.0V 225.0999ms,0.0
+ 225.1000ms,3.3V 225.1089ms,3.3
+ 225.1090ms,0.0V 225.1199ms,0.0
+ 225.1200ms,3.3V 225.1289ms,3.3
+ 225.1290ms,0.0V 225.1399ms,0.0
+ 225.1400ms,3.3V 225.1489ms,3.3
+ 225.1490ms,0.0V 225.1599ms,0.0
+ 225.1600ms,3.3V 225.1689ms,3.3
+ 225.1690ms,0.0V 225.1799ms,0.0
+ 225.1800ms,3.3V 225.1889ms,3.3
+ 225.1890ms,0.0V 225.1999ms,0.0
+ 225.2000ms,3.3V 225.2089ms,3.3
+ 225.2090ms,0.0V 225.2199ms,0.0
+ 225.2200ms,3.3V 225.2289ms,3.3
+ 225.2290ms,0.0V 225.2399ms,0.0
+ 225.2400ms,3.3V 225.2489ms,3.3
+ 225.2490ms,0.0V 225.2599ms,0.0
+ 225.2600ms,3.3V 225.2689ms,3.3
+ 225.2690ms,0.0V 225.2799ms,0.0
+ 225.2800ms,3.3V 225.2889ms,3.3
+ 225.2890ms,0.0V 225.2999ms,0.0
+ 225.3000ms,3.3V 225.3089ms,3.3
+ 225.3090ms,0.0V 225.3199ms,0.0
+ 225.3200ms,3.3V 225.3289ms,3.3
+ 225.3290ms,0.0V 225.3399ms,0.0
+ 225.3400ms,3.3V 225.3489ms,3.3
+ 225.3490ms,0.0V 225.3599ms,0.0
+ 225.3600ms,3.3V 225.3691ms,3.3
+ 225.3692ms,0.0V 225.3799ms,0.0
+ 225.3800ms,3.3V 225.3891ms,3.3
+ 225.3892ms,0.0V 225.3999ms,0.0
+ 225.4000ms,3.3V 225.4091ms,3.3
+ 225.4092ms,0.0V 225.4199ms,0.0
+ 225.4200ms,3.3V 225.4291ms,3.3
+ 225.4292ms,0.0V 225.4399ms,0.0
+ 225.4400ms,3.3V 225.4491ms,3.3
+ 225.4492ms,0.0V 225.4599ms,0.0
+ 225.4600ms,3.3V 225.4691ms,3.3
+ 225.4692ms,0.0V 225.4799ms,0.0
+ 225.4800ms,3.3V 225.4891ms,3.3
+ 225.4892ms,0.0V 225.4999ms,0.0
+ 225.5000ms,3.3V 225.5091ms,3.3
+ 225.5092ms,0.0V 225.5199ms,0.0
+ 225.5200ms,3.3V 225.5291ms,3.3
+ 225.5292ms,0.0V 225.5399ms,0.0
+ 225.5400ms,3.3V 225.5491ms,3.3
+ 225.5492ms,0.0V 225.5599ms,0.0
+ 225.5600ms,3.3V 225.5691ms,3.3
+ 225.5692ms,0.0V 225.5799ms,0.0
+ 225.5800ms,3.3V 225.5891ms,3.3
+ 225.5892ms,0.0V 225.5999ms,0.0
+ 225.6000ms,3.3V 225.6091ms,3.3
+ 225.6092ms,0.0V 225.6199ms,0.0
+ 225.6200ms,3.3V 225.6291ms,3.3
+ 225.6292ms,0.0V 225.6399ms,0.0
+ 225.6400ms,3.3V 225.6491ms,3.3
+ 225.6492ms,0.0V 225.6599ms,0.0
+ 225.6600ms,3.3V 225.6691ms,3.3
+ 225.6692ms,0.0V 225.6799ms,0.0
+ 225.6800ms,3.3V 225.6891ms,3.3
+ 225.6892ms,0.0V 225.6999ms,0.0
+ 225.7000ms,3.3V 225.7091ms,3.3
+ 225.7092ms,0.0V 225.7199ms,0.0
+ 225.7200ms,3.3V 225.7291ms,3.3
+ 225.7292ms,0.0V 225.7399ms,0.0
+ 225.7400ms,3.3V 225.7491ms,3.3
+ 225.7492ms,0.0V 225.7599ms,0.0
+ 225.7600ms,3.3V 225.7691ms,3.3
+ 225.7692ms,0.0V 225.7799ms,0.0
+ 225.7800ms,3.3V 225.7891ms,3.3
+ 225.7892ms,0.0V 225.7999ms,0.0
+ 225.8000ms,3.3V 225.8091ms,3.3
+ 225.8092ms,0.0V 225.8199ms,0.0
+ 225.8200ms,3.3V 225.8291ms,3.3
+ 225.8292ms,0.0V 225.8399ms,0.0
+ 225.8400ms,3.3V 225.8491ms,3.3
+ 225.8492ms,0.0V 225.8599ms,0.0
+ 225.8600ms,3.3V 225.8691ms,3.3
+ 225.8692ms,0.0V 225.8799ms,0.0
+ 225.8800ms,3.3V 225.8891ms,3.3
+ 225.8892ms,0.0V 225.8999ms,0.0
+ 225.9000ms,3.3V 225.9091ms,3.3
+ 225.9092ms,0.0V 225.9199ms,0.0
+ 225.9200ms,3.3V 225.9291ms,3.3
+ 225.9292ms,0.0V 225.9399ms,0.0
+ 225.9400ms,3.3V 225.9491ms,3.3
+ 225.9492ms,0.0V 225.9599ms,0.0
+ 225.9600ms,3.3V 225.9691ms,3.3
+ 225.9692ms,0.0V 225.9799ms,0.0
+ 225.9800ms,3.3V 225.9891ms,3.3
+ 225.9892ms,0.0V 225.9999ms,0.0
+ 226.0000ms,3.3V 226.0091ms,3.3
+ 226.0092ms,0.0V 226.0199ms,0.0
+ 226.0200ms,3.3V 226.0291ms,3.3
+ 226.0292ms,0.0V 226.0399ms,0.0
+ 226.0400ms,3.3V 226.0491ms,3.3
+ 226.0492ms,0.0V 226.0599ms,0.0
+ 226.0600ms,3.3V 226.0691ms,3.3
+ 226.0692ms,0.0V 226.0799ms,0.0
+ 226.0800ms,3.3V 226.0891ms,3.3
+ 226.0892ms,0.0V 226.0999ms,0.0
+ 226.1000ms,3.3V 226.1091ms,3.3
+ 226.1092ms,0.0V 226.1199ms,0.0
+ 226.1200ms,3.3V 226.1291ms,3.3
+ 226.1292ms,0.0V 226.1399ms,0.0
+ 226.1400ms,3.3V 226.1491ms,3.3
+ 226.1492ms,0.0V 226.1599ms,0.0
+ 226.1600ms,3.3V 226.1691ms,3.3
+ 226.1692ms,0.0V 226.1799ms,0.0
+ 226.1800ms,3.3V 226.1891ms,3.3
+ 226.1892ms,0.0V 226.1999ms,0.0
+ 226.2000ms,3.3V 226.2091ms,3.3
+ 226.2092ms,0.0V 226.2199ms,0.0
+ 226.2200ms,3.3V 226.2291ms,3.3
+ 226.2292ms,0.0V 226.2399ms,0.0
+ 226.2400ms,3.3V 226.2491ms,3.3
+ 226.2492ms,0.0V 226.2599ms,0.0
+ 226.2600ms,3.3V 226.2691ms,3.3
+ 226.2692ms,0.0V 226.2799ms,0.0
+ 226.2800ms,3.3V 226.2891ms,3.3
+ 226.2892ms,0.0V 226.2999ms,0.0
+ 226.3000ms,3.3V 226.3091ms,3.3
+ 226.3092ms,0.0V 226.3199ms,0.0
+ 226.3200ms,3.3V 226.3291ms,3.3
+ 226.3292ms,0.0V 226.3399ms,0.0
+ 226.3400ms,3.3V 226.3491ms,3.3
+ 226.3492ms,0.0V 226.3599ms,0.0
+ 226.3600ms,3.3V 226.3691ms,3.3
+ 226.3692ms,0.0V 226.3799ms,0.0
+ 226.3800ms,3.3V 226.3891ms,3.3
+ 226.3892ms,0.0V 226.3999ms,0.0
+ 226.4000ms,3.3V 226.4091ms,3.3
+ 226.4092ms,0.0V 226.4199ms,0.0
+ 226.4200ms,3.3V 226.4291ms,3.3
+ 226.4292ms,0.0V 226.4399ms,0.0
+ 226.4400ms,3.3V 226.4491ms,3.3
+ 226.4492ms,0.0V 226.4599ms,0.0
+ 226.4600ms,3.3V 226.4691ms,3.3
+ 226.4692ms,0.0V 226.4799ms,0.0
+ 226.4800ms,3.3V 226.4891ms,3.3
+ 226.4892ms,0.0V 226.4999ms,0.0
+ 226.5000ms,3.3V 226.5091ms,3.3
+ 226.5092ms,0.0V 226.5199ms,0.0
+ 226.5200ms,3.3V 226.5291ms,3.3
+ 226.5292ms,0.0V 226.5399ms,0.0
+ 226.5400ms,3.3V 226.5491ms,3.3
+ 226.5492ms,0.0V 226.5599ms,0.0
+ 226.5600ms,3.3V 226.5691ms,3.3
+ 226.5692ms,0.0V 226.5799ms,0.0
+ 226.5800ms,3.3V 226.5891ms,3.3
+ 226.5892ms,0.0V 226.5999ms,0.0
+ 226.6000ms,3.3V 226.6091ms,3.3
+ 226.6092ms,0.0V 226.6199ms,0.0
+ 226.6200ms,3.3V 226.6291ms,3.3
+ 226.6292ms,0.0V 226.6399ms,0.0
+ 226.6400ms,3.3V 226.6491ms,3.3
+ 226.6492ms,0.0V 226.6599ms,0.0
+ 226.6600ms,3.3V 226.6691ms,3.3
+ 226.6692ms,0.0V 226.6799ms,0.0
+ 226.6800ms,3.3V 226.6891ms,3.3
+ 226.6892ms,0.0V 226.6999ms,0.0
+ 226.7000ms,3.3V 226.7091ms,3.3
+ 226.7092ms,0.0V 226.7199ms,0.0
+ 226.7200ms,3.3V 226.7291ms,3.3
+ 226.7292ms,0.0V 226.7399ms,0.0
+ 226.7400ms,3.3V 226.7491ms,3.3
+ 226.7492ms,0.0V 226.7599ms,0.0
+ 226.7600ms,3.3V 226.7691ms,3.3
+ 226.7692ms,0.0V 226.7799ms,0.0
+ 226.7800ms,3.3V 226.7891ms,3.3
+ 226.7892ms,0.0V 226.7999ms,0.0
+ 226.8000ms,3.3V 226.8091ms,3.3
+ 226.8092ms,0.0V 226.8199ms,0.0
+ 226.8200ms,3.3V 226.8291ms,3.3
+ 226.8292ms,0.0V 226.8399ms,0.0
+ 226.8400ms,3.3V 226.8491ms,3.3
+ 226.8492ms,0.0V 226.8599ms,0.0
+ 226.8600ms,3.3V 226.8691ms,3.3
+ 226.8692ms,0.0V 226.8799ms,0.0
+ 226.8800ms,3.3V 226.8891ms,3.3
+ 226.8892ms,0.0V 226.8999ms,0.0
+ 226.9000ms,3.3V 226.9091ms,3.3
+ 226.9092ms,0.0V 226.9199ms,0.0
+ 226.9200ms,3.3V 226.9291ms,3.3
+ 226.9292ms,0.0V 226.9399ms,0.0
+ 226.9400ms,3.3V 226.9491ms,3.3
+ 226.9492ms,0.0V 226.9599ms,0.0
+ 226.9600ms,3.3V 226.9691ms,3.3
+ 226.9692ms,0.0V 226.9799ms,0.0
+ 226.9800ms,3.3V 226.9891ms,3.3
+ 226.9892ms,0.0V 226.9999ms,0.0
+ 227.0000ms,3.3V 227.0091ms,3.3
+ 227.0092ms,0.0V 227.0199ms,0.0
+ 227.0200ms,3.3V 227.0291ms,3.3
+ 227.0292ms,0.0V 227.0399ms,0.0
+ 227.0400ms,3.3V 227.0491ms,3.3
+ 227.0492ms,0.0V 227.0599ms,0.0
+ 227.0600ms,3.3V 227.0691ms,3.3
+ 227.0692ms,0.0V 227.0799ms,0.0
+ 227.0800ms,3.3V 227.0891ms,3.3
+ 227.0892ms,0.0V 227.0999ms,0.0
+ 227.1000ms,3.3V 227.1091ms,3.3
+ 227.1092ms,0.0V 227.1199ms,0.0
+ 227.1200ms,3.3V 227.1291ms,3.3
+ 227.1292ms,0.0V 227.1399ms,0.0
+ 227.1400ms,3.3V 227.1491ms,3.3
+ 227.1492ms,0.0V 227.1599ms,0.0
+ 227.1600ms,3.3V 227.1691ms,3.3
+ 227.1692ms,0.0V 227.1799ms,0.0
+ 227.1800ms,3.3V 227.1891ms,3.3
+ 227.1892ms,0.0V 227.1999ms,0.0
+ 227.2000ms,3.3V 227.2091ms,3.3
+ 227.2092ms,0.0V 227.2199ms,0.0
+ 227.2200ms,3.3V 227.2291ms,3.3
+ 227.2292ms,0.0V 227.2399ms,0.0
+ 227.2400ms,3.3V 227.2491ms,3.3
+ 227.2492ms,0.0V 227.2599ms,0.0
+ 227.2600ms,3.3V 227.2691ms,3.3
+ 227.2692ms,0.0V 227.2799ms,0.0
+ 227.2800ms,3.3V 227.2891ms,3.3
+ 227.2892ms,0.0V 227.2999ms,0.0
+ 227.3000ms,3.3V 227.3091ms,3.3
+ 227.3092ms,0.0V 227.3199ms,0.0
+ 227.3200ms,3.3V 227.3291ms,3.3
+ 227.3292ms,0.0V 227.3399ms,0.0
+ 227.3400ms,3.3V 227.3491ms,3.3
+ 227.3492ms,0.0V 227.3599ms,0.0
+ 227.3600ms,3.3V 227.3691ms,3.3
+ 227.3692ms,0.0V 227.3799ms,0.0
+ 227.3800ms,3.3V 227.3891ms,3.3
+ 227.3892ms,0.0V 227.3999ms,0.0
+ 227.4000ms,3.3V 227.4091ms,3.3
+ 227.4092ms,0.0V 227.4199ms,0.0
+ 227.4200ms,3.3V 227.4291ms,3.3
+ 227.4292ms,0.0V 227.4399ms,0.0
+ 227.4400ms,3.3V 227.4491ms,3.3
+ 227.4492ms,0.0V 227.4599ms,0.0
+ 227.4600ms,3.3V 227.4691ms,3.3
+ 227.4692ms,0.0V 227.4799ms,0.0
+ 227.4800ms,3.3V 227.4891ms,3.3
+ 227.4892ms,0.0V 227.4999ms,0.0
+ 227.5000ms,3.3V 227.5091ms,3.3
+ 227.5092ms,0.0V 227.5199ms,0.0
+ 227.5200ms,3.3V 227.5291ms,3.3
+ 227.5292ms,0.0V 227.5399ms,0.0
+ 227.5400ms,3.3V 227.5491ms,3.3
+ 227.5492ms,0.0V 227.5599ms,0.0
+ 227.5600ms,3.3V 227.5691ms,3.3
+ 227.5692ms,0.0V 227.5799ms,0.0
+ 227.5800ms,3.3V 227.5891ms,3.3
+ 227.5892ms,0.0V 227.5999ms,0.0
+ 227.6000ms,3.3V 227.6091ms,3.3
+ 227.6092ms,0.0V 227.6199ms,0.0
+ 227.6200ms,3.3V 227.6291ms,3.3
+ 227.6292ms,0.0V 227.6399ms,0.0
+ 227.6400ms,3.3V 227.6491ms,3.3
+ 227.6492ms,0.0V 227.6599ms,0.0
+ 227.6600ms,3.3V 227.6691ms,3.3
+ 227.6692ms,0.0V 227.6799ms,0.0
+ 227.6800ms,3.3V 227.6891ms,3.3
+ 227.6892ms,0.0V 227.6999ms,0.0
+ 227.7000ms,3.3V 227.7091ms,3.3
+ 227.7092ms,0.0V 227.7199ms,0.0
+ 227.7200ms,3.3V 227.7291ms,3.3
+ 227.7292ms,0.0V 227.7399ms,0.0
+ 227.7400ms,3.3V 227.7491ms,3.3
+ 227.7492ms,0.0V 227.7599ms,0.0
+ 227.7600ms,3.3V 227.7691ms,3.3
+ 227.7692ms,0.0V 227.7799ms,0.0
+ 227.7800ms,3.3V 227.7891ms,3.3
+ 227.7892ms,0.0V 227.7999ms,0.0
+ 227.8000ms,3.3V 227.8091ms,3.3
+ 227.8092ms,0.0V 227.8199ms,0.0
+ 227.8200ms,3.3V 227.8291ms,3.3
+ 227.8292ms,0.0V 227.8399ms,0.0
+ 227.8400ms,3.3V 227.8491ms,3.3
+ 227.8492ms,0.0V 227.8599ms,0.0
+ 227.8600ms,3.3V 227.8691ms,3.3
+ 227.8692ms,0.0V 227.8799ms,0.0
+ 227.8800ms,3.3V 227.8891ms,3.3
+ 227.8892ms,0.0V 227.8999ms,0.0
+ 227.9000ms,3.3V 227.9091ms,3.3
+ 227.9092ms,0.0V 227.9199ms,0.0
+ 227.9200ms,3.3V 227.9291ms,3.3
+ 227.9292ms,0.0V 227.9399ms,0.0
+ 227.9400ms,3.3V 227.9491ms,3.3
+ 227.9492ms,0.0V 227.9599ms,0.0
+ 227.9600ms,3.3V 227.9691ms,3.3
+ 227.9692ms,0.0V 227.9799ms,0.0
+ 227.9800ms,3.3V 227.9891ms,3.3
+ 227.9892ms,0.0V 227.9999ms,0.0
+ 228.0000ms,3.3V 228.0091ms,3.3
+ 228.0092ms,0.0V 228.0199ms,0.0
+ 228.0200ms,3.3V 228.0291ms,3.3
+ 228.0292ms,0.0V 228.0399ms,0.0
+ 228.0400ms,3.3V 228.0491ms,3.3
+ 228.0492ms,0.0V 228.0599ms,0.0
+ 228.0600ms,3.3V 228.0691ms,3.3
+ 228.0692ms,0.0V 228.0799ms,0.0
+ 228.0800ms,3.3V 228.0891ms,3.3
+ 228.0892ms,0.0V 228.0999ms,0.0
+ 228.1000ms,3.3V 228.1091ms,3.3
+ 228.1092ms,0.0V 228.1199ms,0.0
+ 228.1200ms,3.3V 228.1291ms,3.3
+ 228.1292ms,0.0V 228.1399ms,0.0
+ 228.1400ms,3.3V 228.1491ms,3.3
+ 228.1492ms,0.0V 228.1599ms,0.0
+ 228.1600ms,3.3V 228.1691ms,3.3
+ 228.1692ms,0.0V 228.1799ms,0.0
+ 228.1800ms,3.3V 228.1891ms,3.3
+ 228.1892ms,0.0V 228.1999ms,0.0
+ 228.2000ms,3.3V 228.2091ms,3.3
+ 228.2092ms,0.0V 228.2199ms,0.0
+ 228.2200ms,3.3V 228.2291ms,3.3
+ 228.2292ms,0.0V 228.2399ms,0.0
+ 228.2400ms,3.3V 228.2491ms,3.3
+ 228.2492ms,0.0V 228.2599ms,0.0
+ 228.2600ms,3.3V 228.2691ms,3.3
+ 228.2692ms,0.0V 228.2799ms,0.0
+ 228.2800ms,3.3V 228.2891ms,3.3
+ 228.2892ms,0.0V 228.2999ms,0.0
+ 228.3000ms,3.3V 228.3091ms,3.3
+ 228.3092ms,0.0V 228.3199ms,0.0
+ 228.3200ms,3.3V 228.3291ms,3.3
+ 228.3292ms,0.0V 228.3399ms,0.0
+ 228.3400ms,3.3V 228.3491ms,3.3
+ 228.3492ms,0.0V 228.3599ms,0.0
+ 228.3600ms,3.3V 228.3691ms,3.3
+ 228.3692ms,0.0V 228.3799ms,0.0
+ 228.3800ms,3.3V 228.3891ms,3.3
+ 228.3892ms,0.0V 228.3999ms,0.0
+ 228.4000ms,3.3V 228.4091ms,3.3
+ 228.4092ms,0.0V 228.4199ms,0.0
+ 228.4200ms,3.3V 228.4291ms,3.3
+ 228.4292ms,0.0V 228.4399ms,0.0
+ 228.4400ms,3.3V 228.4491ms,3.3
+ 228.4492ms,0.0V 228.4599ms,0.0
+ 228.4600ms,3.3V 228.4691ms,3.3
+ 228.4692ms,0.0V 228.4799ms,0.0
+ 228.4800ms,3.3V 228.4891ms,3.3
+ 228.4892ms,0.0V 228.4999ms,0.0
+ 228.5000ms,3.3V 228.5091ms,3.3
+ 228.5092ms,0.0V 228.5199ms,0.0
+ 228.5200ms,3.3V 228.5291ms,3.3
+ 228.5292ms,0.0V 228.5399ms,0.0
+ 228.5400ms,3.3V 228.5491ms,3.3
+ 228.5492ms,0.0V 228.5599ms,0.0
+ 228.5600ms,3.3V 228.5691ms,3.3
+ 228.5692ms,0.0V 228.5799ms,0.0
+ 228.5800ms,3.3V 228.5891ms,3.3
+ 228.5892ms,0.0V 228.5999ms,0.0
+ 228.6000ms,3.3V 228.6091ms,3.3
+ 228.6092ms,0.0V 228.6199ms,0.0
+ 228.6200ms,3.3V 228.6291ms,3.3
+ 228.6292ms,0.0V 228.6399ms,0.0
+ 228.6400ms,3.3V 228.6491ms,3.3
+ 228.6492ms,0.0V 228.6599ms,0.0
+ 228.6600ms,3.3V 228.6691ms,3.3
+ 228.6692ms,0.0V 228.6799ms,0.0
+ 228.6800ms,3.3V 228.6891ms,3.3
+ 228.6892ms,0.0V 228.6999ms,0.0
+ 228.7000ms,3.3V 228.7091ms,3.3
+ 228.7092ms,0.0V 228.7199ms,0.0
+ 228.7200ms,3.3V 228.7291ms,3.3
+ 228.7292ms,0.0V 228.7399ms,0.0
+ 228.7400ms,3.3V 228.7491ms,3.3
+ 228.7492ms,0.0V 228.7599ms,0.0
+ 228.7600ms,3.3V 228.7691ms,3.3
+ 228.7692ms,0.0V 228.7799ms,0.0
+ 228.7800ms,3.3V 228.7891ms,3.3
+ 228.7892ms,0.0V 228.7999ms,0.0
+ 228.8000ms,3.3V 228.8091ms,3.3
+ 228.8092ms,0.0V 228.8199ms,0.0
+ 228.8200ms,3.3V 228.8291ms,3.3
+ 228.8292ms,0.0V 228.8399ms,0.0
+ 228.8400ms,3.3V 228.8491ms,3.3
+ 228.8492ms,0.0V 228.8599ms,0.0
+ 228.8600ms,3.3V 228.8691ms,3.3
+ 228.8692ms,0.0V 228.8799ms,0.0
+ 228.8800ms,3.3V 228.8891ms,3.3
+ 228.8892ms,0.0V 228.8999ms,0.0
+ 228.9000ms,3.3V 228.9091ms,3.3
+ 228.9092ms,0.0V 228.9199ms,0.0
+ 228.9200ms,3.3V 228.9291ms,3.3
+ 228.9292ms,0.0V 228.9399ms,0.0
+ 228.9400ms,3.3V 228.9491ms,3.3
+ 228.9492ms,0.0V 228.9599ms,0.0
+ 228.9600ms,3.3V 228.9691ms,3.3
+ 228.9692ms,0.0V 228.9799ms,0.0
+ 228.9800ms,3.3V 228.9891ms,3.3
+ 228.9892ms,0.0V 228.9999ms,0.0
+ 229.0000ms,3.3V 229.0091ms,3.3
+ 229.0092ms,0.0V 229.0199ms,0.0
+ 229.0200ms,3.3V 229.0291ms,3.3
+ 229.0292ms,0.0V 229.0399ms,0.0
+ 229.0400ms,3.3V 229.0491ms,3.3
+ 229.0492ms,0.0V 229.0599ms,0.0
+ 229.0600ms,3.3V 229.0691ms,3.3
+ 229.0692ms,0.0V 229.0799ms,0.0
+ 229.0800ms,3.3V 229.0891ms,3.3
+ 229.0892ms,0.0V 229.0999ms,0.0
+ 229.1000ms,3.3V 229.1091ms,3.3
+ 229.1092ms,0.0V 229.1199ms,0.0
+ 229.1200ms,3.3V 229.1291ms,3.3
+ 229.1292ms,0.0V 229.1399ms,0.0
+ 229.1400ms,3.3V 229.1491ms,3.3
+ 229.1492ms,0.0V 229.1599ms,0.0
+ 229.1600ms,3.3V 229.1691ms,3.3
+ 229.1692ms,0.0V 229.1799ms,0.0
+ 229.1800ms,3.3V 229.1891ms,3.3
+ 229.1892ms,0.0V 229.1999ms,0.0
+ 229.2000ms,3.3V 229.2091ms,3.3
+ 229.2092ms,0.0V 229.2199ms,0.0
+ 229.2200ms,3.3V 229.2291ms,3.3
+ 229.2292ms,0.0V 229.2399ms,0.0
+ 229.2400ms,3.3V 229.2491ms,3.3
+ 229.2492ms,0.0V 229.2599ms,0.0
+ 229.2600ms,3.3V 229.2691ms,3.3
+ 229.2692ms,0.0V 229.2799ms,0.0
+ 229.2800ms,3.3V 229.2891ms,3.3
+ 229.2892ms,0.0V 229.2999ms,0.0
+ 229.3000ms,3.3V 229.3091ms,3.3
+ 229.3092ms,0.0V 229.3199ms,0.0
+ 229.3200ms,3.3V 229.3291ms,3.3
+ 229.3292ms,0.0V 229.3399ms,0.0
+ 229.3400ms,3.3V 229.3491ms,3.3
+ 229.3492ms,0.0V 229.3599ms,0.0
+ 229.3600ms,3.3V 229.3691ms,3.3
+ 229.3692ms,0.0V 229.3799ms,0.0
+ 229.3800ms,3.3V 229.3891ms,3.3
+ 229.3892ms,0.0V 229.3999ms,0.0
+ 229.4000ms,3.3V 229.4091ms,3.3
+ 229.4092ms,0.0V 229.4199ms,0.0
+ 229.4200ms,3.3V 229.4291ms,3.3
+ 229.4292ms,0.0V 229.4399ms,0.0
+ 229.4400ms,3.3V 229.4491ms,3.3
+ 229.4492ms,0.0V 229.4599ms,0.0
+ 229.4600ms,3.3V 229.4691ms,3.3
+ 229.4692ms,0.0V 229.4799ms,0.0
+ 229.4800ms,3.3V 229.4891ms,3.3
+ 229.4892ms,0.0V 229.4999ms,0.0
+ 229.5000ms,3.3V 229.5091ms,3.3
+ 229.5092ms,0.0V 229.5199ms,0.0
+ 229.5200ms,3.3V 229.5291ms,3.3
+ 229.5292ms,0.0V 229.5399ms,0.0
+ 229.5400ms,3.3V 229.5491ms,3.3
+ 229.5492ms,0.0V 229.5599ms,0.0
+ 229.5600ms,3.3V 229.5691ms,3.3
+ 229.5692ms,0.0V 229.5799ms,0.0
+ 229.5800ms,3.3V 229.5891ms,3.3
+ 229.5892ms,0.0V 229.5999ms,0.0
+ 229.6000ms,3.3V 229.6091ms,3.3
+ 229.6092ms,0.0V 229.6199ms,0.0
+ 229.6200ms,3.3V 229.6291ms,3.3
+ 229.6292ms,0.0V 229.6399ms,0.0
+ 229.6400ms,3.3V 229.6491ms,3.3
+ 229.6492ms,0.0V 229.6599ms,0.0
+ 229.6600ms,3.3V 229.6691ms,3.3
+ 229.6692ms,0.0V 229.6799ms,0.0
+ 229.6800ms,3.3V 229.6891ms,3.3
+ 229.6892ms,0.0V 229.6999ms,0.0
+ 229.7000ms,3.3V 229.7091ms,3.3
+ 229.7092ms,0.0V 229.7199ms,0.0
+ 229.7200ms,3.3V 229.7291ms,3.3
+ 229.7292ms,0.0V 229.7399ms,0.0
+ 229.7400ms,3.3V 229.7491ms,3.3
+ 229.7492ms,0.0V 229.7599ms,0.0
+ 229.7600ms,3.3V 229.7691ms,3.3
+ 229.7692ms,0.0V 229.7799ms,0.0
+ 229.7800ms,3.3V 229.7891ms,3.3
+ 229.7892ms,0.0V 229.7999ms,0.0
+ 229.8000ms,3.3V 229.8091ms,3.3
+ 229.8092ms,0.0V 229.8199ms,0.0
+ 229.8200ms,3.3V 229.8291ms,3.3
+ 229.8292ms,0.0V 229.8399ms,0.0
+ 229.8400ms,3.3V 229.8491ms,3.3
+ 229.8492ms,0.0V 229.8599ms,0.0
+ 229.8600ms,3.3V 229.8691ms,3.3
+ 229.8692ms,0.0V 229.8799ms,0.0
+ 229.8800ms,3.3V 229.8891ms,3.3
+ 229.8892ms,0.0V 229.8999ms,0.0
+ 229.9000ms,3.3V 229.9091ms,3.3
+ 229.9092ms,0.0V 229.9199ms,0.0
+ 229.9200ms,3.3V 229.9291ms,3.3
+ 229.9292ms,0.0V 229.9399ms,0.0
+ 229.9400ms,3.3V 229.9491ms,3.3
+ 229.9492ms,0.0V 229.9599ms,0.0
+ 229.9600ms,3.3V 229.9691ms,3.3
+ 229.9692ms,0.0V 229.9799ms,0.0
+ 229.9800ms,3.3V 229.9891ms,3.3
+ 229.9892ms,0.0V 229.9999ms,0.0
+ 230.0000ms,3.3V 230.0091ms,3.3
+ 230.0092ms,0.0V 230.0199ms,0.0
+ 230.0200ms,3.3V 230.0291ms,3.3
+ 230.0292ms,0.0V 230.0399ms,0.0
+ 230.0400ms,3.3V 230.0491ms,3.3
+ 230.0492ms,0.0V 230.0599ms,0.0
+ 230.0600ms,3.3V 230.0691ms,3.3
+ 230.0692ms,0.0V 230.0799ms,0.0
+ 230.0800ms,3.3V 230.0891ms,3.3
+ 230.0892ms,0.0V 230.0999ms,0.0
+ 230.1000ms,3.3V 230.1091ms,3.3
+ 230.1092ms,0.0V 230.1199ms,0.0
+ 230.1200ms,3.3V 230.1291ms,3.3
+ 230.1292ms,0.0V 230.1399ms,0.0
+ 230.1400ms,3.3V 230.1491ms,3.3
+ 230.1492ms,0.0V 230.1599ms,0.0
+ 230.1600ms,3.3V 230.1691ms,3.3
+ 230.1692ms,0.0V 230.1799ms,0.0
+ 230.1800ms,3.3V 230.1891ms,3.3
+ 230.1892ms,0.0V 230.1999ms,0.0
+ 230.2000ms,3.3V 230.2091ms,3.3
+ 230.2092ms,0.0V 230.2199ms,0.0
+ 230.2200ms,3.3V 230.2291ms,3.3
+ 230.2292ms,0.0V 230.2399ms,0.0
+ 230.2400ms,3.3V 230.2491ms,3.3
+ 230.2492ms,0.0V 230.2599ms,0.0
+ 230.2600ms,3.3V 230.2691ms,3.3
+ 230.2692ms,0.0V 230.2799ms,0.0
+ 230.2800ms,3.3V 230.2891ms,3.3
+ 230.2892ms,0.0V 230.2999ms,0.0
+ 230.3000ms,3.3V 230.3091ms,3.3
+ 230.3092ms,0.0V 230.3199ms,0.0
+ 230.3200ms,3.3V 230.3291ms,3.3
+ 230.3292ms,0.0V 230.3399ms,0.0
+ 230.3400ms,3.3V 230.3491ms,3.3
+ 230.3492ms,0.0V 230.3599ms,0.0
+ 230.3600ms,3.3V 230.3693ms,3.3
+ 230.3694ms,0.0V 230.3799ms,0.0
+ 230.3800ms,3.3V 230.3893ms,3.3
+ 230.3894ms,0.0V 230.3999ms,0.0
+ 230.4000ms,3.3V 230.4093ms,3.3
+ 230.4094ms,0.0V 230.4199ms,0.0
+ 230.4200ms,3.3V 230.4293ms,3.3
+ 230.4294ms,0.0V 230.4399ms,0.0
+ 230.4400ms,3.3V 230.4493ms,3.3
+ 230.4494ms,0.0V 230.4599ms,0.0
+ 230.4600ms,3.3V 230.4693ms,3.3
+ 230.4694ms,0.0V 230.4799ms,0.0
+ 230.4800ms,3.3V 230.4893ms,3.3
+ 230.4894ms,0.0V 230.4999ms,0.0
+ 230.5000ms,3.3V 230.5093ms,3.3
+ 230.5094ms,0.0V 230.5199ms,0.0
+ 230.5200ms,3.3V 230.5293ms,3.3
+ 230.5294ms,0.0V 230.5399ms,0.0
+ 230.5400ms,3.3V 230.5493ms,3.3
+ 230.5494ms,0.0V 230.5599ms,0.0
+ 230.5600ms,3.3V 230.5693ms,3.3
+ 230.5694ms,0.0V 230.5799ms,0.0
+ 230.5800ms,3.3V 230.5893ms,3.3
+ 230.5894ms,0.0V 230.5999ms,0.0
+ 230.6000ms,3.3V 230.6093ms,3.3
+ 230.6094ms,0.0V 230.6199ms,0.0
+ 230.6200ms,3.3V 230.6293ms,3.3
+ 230.6294ms,0.0V 230.6399ms,0.0
+ 230.6400ms,3.3V 230.6493ms,3.3
+ 230.6494ms,0.0V 230.6599ms,0.0
+ 230.6600ms,3.3V 230.6693ms,3.3
+ 230.6694ms,0.0V 230.6799ms,0.0
+ 230.6800ms,3.3V 230.6893ms,3.3
+ 230.6894ms,0.0V 230.6999ms,0.0
+ 230.7000ms,3.3V 230.7093ms,3.3
+ 230.7094ms,0.0V 230.7199ms,0.0
+ 230.7200ms,3.3V 230.7293ms,3.3
+ 230.7294ms,0.0V 230.7399ms,0.0
+ 230.7400ms,3.3V 230.7493ms,3.3
+ 230.7494ms,0.0V 230.7599ms,0.0
+ 230.7600ms,3.3V 230.7693ms,3.3
+ 230.7694ms,0.0V 230.7799ms,0.0
+ 230.7800ms,3.3V 230.7893ms,3.3
+ 230.7894ms,0.0V 230.7999ms,0.0
+ 230.8000ms,3.3V 230.8093ms,3.3
+ 230.8094ms,0.0V 230.8199ms,0.0
+ 230.8200ms,3.3V 230.8293ms,3.3
+ 230.8294ms,0.0V 230.8399ms,0.0
+ 230.8400ms,3.3V 230.8493ms,3.3
+ 230.8494ms,0.0V 230.8599ms,0.0
+ 230.8600ms,3.3V 230.8693ms,3.3
+ 230.8694ms,0.0V 230.8799ms,0.0
+ 230.8800ms,3.3V 230.8893ms,3.3
+ 230.8894ms,0.0V 230.8999ms,0.0
+ 230.9000ms,3.3V 230.9093ms,3.3
+ 230.9094ms,0.0V 230.9199ms,0.0
+ 230.9200ms,3.3V 230.9293ms,3.3
+ 230.9294ms,0.0V 230.9399ms,0.0
+ 230.9400ms,3.3V 230.9493ms,3.3
+ 230.9494ms,0.0V 230.9599ms,0.0
+ 230.9600ms,3.3V 230.9693ms,3.3
+ 230.9694ms,0.0V 230.9799ms,0.0
+ 230.9800ms,3.3V 230.9893ms,3.3
+ 230.9894ms,0.0V 230.9999ms,0.0
+ 231.0000ms,3.3V 231.0093ms,3.3
+ 231.0094ms,0.0V 231.0199ms,0.0
+ 231.0200ms,3.3V 231.0293ms,3.3
+ 231.0294ms,0.0V 231.0399ms,0.0
+ 231.0400ms,3.3V 231.0493ms,3.3
+ 231.0494ms,0.0V 231.0599ms,0.0
+ 231.0600ms,3.3V 231.0693ms,3.3
+ 231.0694ms,0.0V 231.0799ms,0.0
+ 231.0800ms,3.3V 231.0893ms,3.3
+ 231.0894ms,0.0V 231.0999ms,0.0
+ 231.1000ms,3.3V 231.1093ms,3.3
+ 231.1094ms,0.0V 231.1199ms,0.0
+ 231.1200ms,3.3V 231.1293ms,3.3
+ 231.1294ms,0.0V 231.1399ms,0.0
+ 231.1400ms,3.3V 231.1493ms,3.3
+ 231.1494ms,0.0V 231.1599ms,0.0
+ 231.1600ms,3.3V 231.1693ms,3.3
+ 231.1694ms,0.0V 231.1799ms,0.0
+ 231.1800ms,3.3V 231.1893ms,3.3
+ 231.1894ms,0.0V 231.1999ms,0.0
+ 231.2000ms,3.3V 231.2093ms,3.3
+ 231.2094ms,0.0V 231.2199ms,0.0
+ 231.2200ms,3.3V 231.2293ms,3.3
+ 231.2294ms,0.0V 231.2399ms,0.0
+ 231.2400ms,3.3V 231.2493ms,3.3
+ 231.2494ms,0.0V 231.2599ms,0.0
+ 231.2600ms,3.3V 231.2693ms,3.3
+ 231.2694ms,0.0V 231.2799ms,0.0
+ 231.2800ms,3.3V 231.2893ms,3.3
+ 231.2894ms,0.0V 231.2999ms,0.0
+ 231.3000ms,3.3V 231.3093ms,3.3
+ 231.3094ms,0.0V 231.3199ms,0.0
+ 231.3200ms,3.3V 231.3293ms,3.3
+ 231.3294ms,0.0V 231.3399ms,0.0
+ 231.3400ms,3.3V 231.3493ms,3.3
+ 231.3494ms,0.0V 231.3599ms,0.0
+ 231.3600ms,3.3V 231.3693ms,3.3
+ 231.3694ms,0.0V 231.3799ms,0.0
+ 231.3800ms,3.3V 231.3893ms,3.3
+ 231.3894ms,0.0V 231.3999ms,0.0
+ 231.4000ms,3.3V 231.4093ms,3.3
+ 231.4094ms,0.0V 231.4199ms,0.0
+ 231.4200ms,3.3V 231.4293ms,3.3
+ 231.4294ms,0.0V 231.4399ms,0.0
+ 231.4400ms,3.3V 231.4493ms,3.3
+ 231.4494ms,0.0V 231.4599ms,0.0
+ 231.4600ms,3.3V 231.4693ms,3.3
+ 231.4694ms,0.0V 231.4799ms,0.0
+ 231.4800ms,3.3V 231.4893ms,3.3
+ 231.4894ms,0.0V 231.4999ms,0.0
+ 231.5000ms,3.3V 231.5093ms,3.3
+ 231.5094ms,0.0V 231.5199ms,0.0
+ 231.5200ms,3.3V 231.5293ms,3.3
+ 231.5294ms,0.0V 231.5399ms,0.0
+ 231.5400ms,3.3V 231.5493ms,3.3
+ 231.5494ms,0.0V 231.5599ms,0.0
+ 231.5600ms,3.3V 231.5693ms,3.3
+ 231.5694ms,0.0V 231.5799ms,0.0
+ 231.5800ms,3.3V 231.5893ms,3.3
+ 231.5894ms,0.0V 231.5999ms,0.0
+ 231.6000ms,3.3V 231.6093ms,3.3
+ 231.6094ms,0.0V 231.6199ms,0.0
+ 231.6200ms,3.3V 231.6293ms,3.3
+ 231.6294ms,0.0V 231.6399ms,0.0
+ 231.6400ms,3.3V 231.6493ms,3.3
+ 231.6494ms,0.0V 231.6599ms,0.0
+ 231.6600ms,3.3V 231.6693ms,3.3
+ 231.6694ms,0.0V 231.6799ms,0.0
+ 231.6800ms,3.3V 231.6893ms,3.3
+ 231.6894ms,0.0V 231.6999ms,0.0
+ 231.7000ms,3.3V 231.7093ms,3.3
+ 231.7094ms,0.0V 231.7199ms,0.0
+ 231.7200ms,3.3V 231.7293ms,3.3
+ 231.7294ms,0.0V 231.7399ms,0.0
+ 231.7400ms,3.3V 231.7493ms,3.3
+ 231.7494ms,0.0V 231.7599ms,0.0
+ 231.7600ms,3.3V 231.7693ms,3.3
+ 231.7694ms,0.0V 231.7799ms,0.0
+ 231.7800ms,3.3V 231.7893ms,3.3
+ 231.7894ms,0.0V 231.7999ms,0.0
+ 231.8000ms,3.3V 231.8093ms,3.3
+ 231.8094ms,0.0V 231.8199ms,0.0
+ 231.8200ms,3.3V 231.8293ms,3.3
+ 231.8294ms,0.0V 231.8399ms,0.0
+ 231.8400ms,3.3V 231.8493ms,3.3
+ 231.8494ms,0.0V 231.8599ms,0.0
+ 231.8600ms,3.3V 231.8693ms,3.3
+ 231.8694ms,0.0V 231.8799ms,0.0
+ 231.8800ms,3.3V 231.8893ms,3.3
+ 231.8894ms,0.0V 231.8999ms,0.0
+ 231.9000ms,3.3V 231.9093ms,3.3
+ 231.9094ms,0.0V 231.9199ms,0.0
+ 231.9200ms,3.3V 231.9293ms,3.3
+ 231.9294ms,0.0V 231.9399ms,0.0
+ 231.9400ms,3.3V 231.9493ms,3.3
+ 231.9494ms,0.0V 231.9599ms,0.0
+ 231.9600ms,3.3V 231.9693ms,3.3
+ 231.9694ms,0.0V 231.9799ms,0.0
+ 231.9800ms,3.3V 231.9893ms,3.3
+ 231.9894ms,0.0V 231.9999ms,0.0
+ 232.0000ms,3.3V 232.0093ms,3.3
+ 232.0094ms,0.0V 232.0199ms,0.0
+ 232.0200ms,3.3V 232.0293ms,3.3
+ 232.0294ms,0.0V 232.0399ms,0.0
+ 232.0400ms,3.3V 232.0493ms,3.3
+ 232.0494ms,0.0V 232.0599ms,0.0
+ 232.0600ms,3.3V 232.0693ms,3.3
+ 232.0694ms,0.0V 232.0799ms,0.0
+ 232.0800ms,3.3V 232.0893ms,3.3
+ 232.0894ms,0.0V 232.0999ms,0.0
+ 232.1000ms,3.3V 232.1093ms,3.3
+ 232.1094ms,0.0V 232.1199ms,0.0
+ 232.1200ms,3.3V 232.1293ms,3.3
+ 232.1294ms,0.0V 232.1399ms,0.0
+ 232.1400ms,3.3V 232.1493ms,3.3
+ 232.1494ms,0.0V 232.1599ms,0.0
+ 232.1600ms,3.3V 232.1693ms,3.3
+ 232.1694ms,0.0V 232.1799ms,0.0
+ 232.1800ms,3.3V 232.1893ms,3.3
+ 232.1894ms,0.0V 232.1999ms,0.0
+ 232.2000ms,3.3V 232.2093ms,3.3
+ 232.2094ms,0.0V 232.2199ms,0.0
+ 232.2200ms,3.3V 232.2293ms,3.3
+ 232.2294ms,0.0V 232.2399ms,0.0
+ 232.2400ms,3.3V 232.2493ms,3.3
+ 232.2494ms,0.0V 232.2599ms,0.0
+ 232.2600ms,3.3V 232.2693ms,3.3
+ 232.2694ms,0.0V 232.2799ms,0.0
+ 232.2800ms,3.3V 232.2893ms,3.3
+ 232.2894ms,0.0V 232.2999ms,0.0
+ 232.3000ms,3.3V 232.3093ms,3.3
+ 232.3094ms,0.0V 232.3199ms,0.0
+ 232.3200ms,3.3V 232.3293ms,3.3
+ 232.3294ms,0.0V 232.3399ms,0.0
+ 232.3400ms,3.3V 232.3493ms,3.3
+ 232.3494ms,0.0V 232.3599ms,0.0
+ 232.3600ms,3.3V 232.3693ms,3.3
+ 232.3694ms,0.0V 232.3799ms,0.0
+ 232.3800ms,3.3V 232.3893ms,3.3
+ 232.3894ms,0.0V 232.3999ms,0.0
+ 232.4000ms,3.3V 232.4093ms,3.3
+ 232.4094ms,0.0V 232.4199ms,0.0
+ 232.4200ms,3.3V 232.4293ms,3.3
+ 232.4294ms,0.0V 232.4399ms,0.0
+ 232.4400ms,3.3V 232.4493ms,3.3
+ 232.4494ms,0.0V 232.4599ms,0.0
+ 232.4600ms,3.3V 232.4693ms,3.3
+ 232.4694ms,0.0V 232.4799ms,0.0
+ 232.4800ms,3.3V 232.4893ms,3.3
+ 232.4894ms,0.0V 232.4999ms,0.0
+ 232.5000ms,3.3V 232.5093ms,3.3
+ 232.5094ms,0.0V 232.5199ms,0.0
+ 232.5200ms,3.3V 232.5293ms,3.3
+ 232.5294ms,0.0V 232.5399ms,0.0
+ 232.5400ms,3.3V 232.5493ms,3.3
+ 232.5494ms,0.0V 232.5599ms,0.0
+ 232.5600ms,3.3V 232.5693ms,3.3
+ 232.5694ms,0.0V 232.5799ms,0.0
+ 232.5800ms,3.3V 232.5893ms,3.3
+ 232.5894ms,0.0V 232.5999ms,0.0
+ 232.6000ms,3.3V 232.6093ms,3.3
+ 232.6094ms,0.0V 232.6199ms,0.0
+ 232.6200ms,3.3V 232.6293ms,3.3
+ 232.6294ms,0.0V 232.6399ms,0.0
+ 232.6400ms,3.3V 232.6493ms,3.3
+ 232.6494ms,0.0V 232.6599ms,0.0
+ 232.6600ms,3.3V 232.6693ms,3.3
+ 232.6694ms,0.0V 232.6799ms,0.0
+ 232.6800ms,3.3V 232.6893ms,3.3
+ 232.6894ms,0.0V 232.6999ms,0.0
+ 232.7000ms,3.3V 232.7093ms,3.3
+ 232.7094ms,0.0V 232.7199ms,0.0
+ 232.7200ms,3.3V 232.7293ms,3.3
+ 232.7294ms,0.0V 232.7399ms,0.0
+ 232.7400ms,3.3V 232.7493ms,3.3
+ 232.7494ms,0.0V 232.7599ms,0.0
+ 232.7600ms,3.3V 232.7693ms,3.3
+ 232.7694ms,0.0V 232.7799ms,0.0
+ 232.7800ms,3.3V 232.7893ms,3.3
+ 232.7894ms,0.0V 232.7999ms,0.0
+ 232.8000ms,3.3V 232.8093ms,3.3
+ 232.8094ms,0.0V 232.8199ms,0.0
+ 232.8200ms,3.3V 232.8293ms,3.3
+ 232.8294ms,0.0V 232.8399ms,0.0
+ 232.8400ms,3.3V 232.8493ms,3.3
+ 232.8494ms,0.0V 232.8599ms,0.0
+ 232.8600ms,3.3V 232.8693ms,3.3
+ 232.8694ms,0.0V 232.8799ms,0.0
+ 232.8800ms,3.3V 232.8893ms,3.3
+ 232.8894ms,0.0V 232.8999ms,0.0
+ 232.9000ms,3.3V 232.9093ms,3.3
+ 232.9094ms,0.0V 232.9199ms,0.0
+ 232.9200ms,3.3V 232.9293ms,3.3
+ 232.9294ms,0.0V 232.9399ms,0.0
+ 232.9400ms,3.3V 232.9493ms,3.3
+ 232.9494ms,0.0V 232.9599ms,0.0
+ 232.9600ms,3.3V 232.9693ms,3.3
+ 232.9694ms,0.0V 232.9799ms,0.0
+ 232.9800ms,3.3V 232.9893ms,3.3
+ 232.9894ms,0.0V 232.9999ms,0.0
+ 233.0000ms,3.3V 233.0093ms,3.3
+ 233.0094ms,0.0V 233.0199ms,0.0
+ 233.0200ms,3.3V 233.0293ms,3.3
+ 233.0294ms,0.0V 233.0399ms,0.0
+ 233.0400ms,3.3V 233.0493ms,3.3
+ 233.0494ms,0.0V 233.0599ms,0.0
+ 233.0600ms,3.3V 233.0693ms,3.3
+ 233.0694ms,0.0V 233.0799ms,0.0
+ 233.0800ms,3.3V 233.0893ms,3.3
+ 233.0894ms,0.0V 233.0999ms,0.0
+ 233.1000ms,3.3V 233.1093ms,3.3
+ 233.1094ms,0.0V 233.1199ms,0.0
+ 233.1200ms,3.3V 233.1293ms,3.3
+ 233.1294ms,0.0V 233.1399ms,0.0
+ 233.1400ms,3.3V 233.1493ms,3.3
+ 233.1494ms,0.0V 233.1599ms,0.0
+ 233.1600ms,3.3V 233.1693ms,3.3
+ 233.1694ms,0.0V 233.1799ms,0.0
+ 233.1800ms,3.3V 233.1893ms,3.3
+ 233.1894ms,0.0V 233.1999ms,0.0
+ 233.2000ms,3.3V 233.2093ms,3.3
+ 233.2094ms,0.0V 233.2199ms,0.0
+ 233.2200ms,3.3V 233.2293ms,3.3
+ 233.2294ms,0.0V 233.2399ms,0.0
+ 233.2400ms,3.3V 233.2493ms,3.3
+ 233.2494ms,0.0V 233.2599ms,0.0
+ 233.2600ms,3.3V 233.2693ms,3.3
+ 233.2694ms,0.0V 233.2799ms,0.0
+ 233.2800ms,3.3V 233.2893ms,3.3
+ 233.2894ms,0.0V 233.2999ms,0.0
+ 233.3000ms,3.3V 233.3093ms,3.3
+ 233.3094ms,0.0V 233.3199ms,0.0
+ 233.3200ms,3.3V 233.3293ms,3.3
+ 233.3294ms,0.0V 233.3399ms,0.0
+ 233.3400ms,3.3V 233.3493ms,3.3
+ 233.3494ms,0.0V 233.3599ms,0.0
+ 233.3600ms,3.3V 233.3693ms,3.3
+ 233.3694ms,0.0V 233.3799ms,0.0
+ 233.3800ms,3.3V 233.3893ms,3.3
+ 233.3894ms,0.0V 233.3999ms,0.0
+ 233.4000ms,3.3V 233.4093ms,3.3
+ 233.4094ms,0.0V 233.4199ms,0.0
+ 233.4200ms,3.3V 233.4293ms,3.3
+ 233.4294ms,0.0V 233.4399ms,0.0
+ 233.4400ms,3.3V 233.4493ms,3.3
+ 233.4494ms,0.0V 233.4599ms,0.0
+ 233.4600ms,3.3V 233.4693ms,3.3
+ 233.4694ms,0.0V 233.4799ms,0.0
+ 233.4800ms,3.3V 233.4893ms,3.3
+ 233.4894ms,0.0V 233.4999ms,0.0
+ 233.5000ms,3.3V 233.5093ms,3.3
+ 233.5094ms,0.0V 233.5199ms,0.0
+ 233.5200ms,3.3V 233.5293ms,3.3
+ 233.5294ms,0.0V 233.5399ms,0.0
+ 233.5400ms,3.3V 233.5493ms,3.3
+ 233.5494ms,0.0V 233.5599ms,0.0
+ 233.5600ms,3.3V 233.5693ms,3.3
+ 233.5694ms,0.0V 233.5799ms,0.0
+ 233.5800ms,3.3V 233.5893ms,3.3
+ 233.5894ms,0.0V 233.5999ms,0.0
+ 233.6000ms,3.3V 233.6093ms,3.3
+ 233.6094ms,0.0V 233.6199ms,0.0
+ 233.6200ms,3.3V 233.6293ms,3.3
+ 233.6294ms,0.0V 233.6399ms,0.0
+ 233.6400ms,3.3V 233.6493ms,3.3
+ 233.6494ms,0.0V 233.6599ms,0.0
+ 233.6600ms,3.3V 233.6693ms,3.3
+ 233.6694ms,0.0V 233.6799ms,0.0
+ 233.6800ms,3.3V 233.6893ms,3.3
+ 233.6894ms,0.0V 233.6999ms,0.0
+ 233.7000ms,3.3V 233.7093ms,3.3
+ 233.7094ms,0.0V 233.7199ms,0.0
+ 233.7200ms,3.3V 233.7293ms,3.3
+ 233.7294ms,0.0V 233.7399ms,0.0
+ 233.7400ms,3.3V 233.7493ms,3.3
+ 233.7494ms,0.0V 233.7599ms,0.0
+ 233.7600ms,3.3V 233.7693ms,3.3
+ 233.7694ms,0.0V 233.7799ms,0.0
+ 233.7800ms,3.3V 233.7893ms,3.3
+ 233.7894ms,0.0V 233.7999ms,0.0
+ 233.8000ms,3.3V 233.8093ms,3.3
+ 233.8094ms,0.0V 233.8199ms,0.0
+ 233.8200ms,3.3V 233.8293ms,3.3
+ 233.8294ms,0.0V 233.8399ms,0.0
+ 233.8400ms,3.3V 233.8493ms,3.3
+ 233.8494ms,0.0V 233.8599ms,0.0
+ 233.8600ms,3.3V 233.8693ms,3.3
+ 233.8694ms,0.0V 233.8799ms,0.0
+ 233.8800ms,3.3V 233.8893ms,3.3
+ 233.8894ms,0.0V 233.8999ms,0.0
+ 233.9000ms,3.3V 233.9093ms,3.3
+ 233.9094ms,0.0V 233.9199ms,0.0
+ 233.9200ms,3.3V 233.9293ms,3.3
+ 233.9294ms,0.0V 233.9399ms,0.0
+ 233.9400ms,3.3V 233.9493ms,3.3
+ 233.9494ms,0.0V 233.9599ms,0.0
+ 233.9600ms,3.3V 233.9693ms,3.3
+ 233.9694ms,0.0V 233.9799ms,0.0
+ 233.9800ms,3.3V 233.9893ms,3.3
+ 233.9894ms,0.0V 233.9999ms,0.0
+ 234.0000ms,3.3V 234.0093ms,3.3
+ 234.0094ms,0.0V 234.0199ms,0.0
+ 234.0200ms,3.3V 234.0293ms,3.3
+ 234.0294ms,0.0V 234.0399ms,0.0
+ 234.0400ms,3.3V 234.0493ms,3.3
+ 234.0494ms,0.0V 234.0599ms,0.0
+ 234.0600ms,3.3V 234.0693ms,3.3
+ 234.0694ms,0.0V 234.0799ms,0.0
+ 234.0800ms,3.3V 234.0893ms,3.3
+ 234.0894ms,0.0V 234.0999ms,0.0
+ 234.1000ms,3.3V 234.1093ms,3.3
+ 234.1094ms,0.0V 234.1199ms,0.0
+ 234.1200ms,3.3V 234.1293ms,3.3
+ 234.1294ms,0.0V 234.1399ms,0.0
+ 234.1400ms,3.3V 234.1493ms,3.3
+ 234.1494ms,0.0V 234.1599ms,0.0
+ 234.1600ms,3.3V 234.1693ms,3.3
+ 234.1694ms,0.0V 234.1799ms,0.0
+ 234.1800ms,3.3V 234.1893ms,3.3
+ 234.1894ms,0.0V 234.1999ms,0.0
+ 234.2000ms,3.3V 234.2093ms,3.3
+ 234.2094ms,0.0V 234.2199ms,0.0
+ 234.2200ms,3.3V 234.2293ms,3.3
+ 234.2294ms,0.0V 234.2399ms,0.0
+ 234.2400ms,3.3V 234.2493ms,3.3
+ 234.2494ms,0.0V 234.2599ms,0.0
+ 234.2600ms,3.3V 234.2693ms,3.3
+ 234.2694ms,0.0V 234.2799ms,0.0
+ 234.2800ms,3.3V 234.2893ms,3.3
+ 234.2894ms,0.0V 234.2999ms,0.0
+ 234.3000ms,3.3V 234.3093ms,3.3
+ 234.3094ms,0.0V 234.3199ms,0.0
+ 234.3200ms,3.3V 234.3293ms,3.3
+ 234.3294ms,0.0V 234.3399ms,0.0
+ 234.3400ms,3.3V 234.3493ms,3.3
+ 234.3494ms,0.0V 234.3599ms,0.0
+ 234.3600ms,3.3V 234.3693ms,3.3
+ 234.3694ms,0.0V 234.3799ms,0.0
+ 234.3800ms,3.3V 234.3893ms,3.3
+ 234.3894ms,0.0V 234.3999ms,0.0
+ 234.4000ms,3.3V 234.4093ms,3.3
+ 234.4094ms,0.0V 234.4199ms,0.0
+ 234.4200ms,3.3V 234.4293ms,3.3
+ 234.4294ms,0.0V 234.4399ms,0.0
+ 234.4400ms,3.3V 234.4493ms,3.3
+ 234.4494ms,0.0V 234.4599ms,0.0
+ 234.4600ms,3.3V 234.4693ms,3.3
+ 234.4694ms,0.0V 234.4799ms,0.0
+ 234.4800ms,3.3V 234.4893ms,3.3
+ 234.4894ms,0.0V 234.4999ms,0.0
+ 234.5000ms,3.3V 234.5093ms,3.3
+ 234.5094ms,0.0V 234.5199ms,0.0
+ 234.5200ms,3.3V 234.5293ms,3.3
+ 234.5294ms,0.0V 234.5399ms,0.0
+ 234.5400ms,3.3V 234.5493ms,3.3
+ 234.5494ms,0.0V 234.5599ms,0.0
+ 234.5600ms,3.3V 234.5693ms,3.3
+ 234.5694ms,0.0V 234.5799ms,0.0
+ 234.5800ms,3.3V 234.5893ms,3.3
+ 234.5894ms,0.0V 234.5999ms,0.0
+ 234.6000ms,3.3V 234.6093ms,3.3
+ 234.6094ms,0.0V 234.6199ms,0.0
+ 234.6200ms,3.3V 234.6293ms,3.3
+ 234.6294ms,0.0V 234.6399ms,0.0
+ 234.6400ms,3.3V 234.6493ms,3.3
+ 234.6494ms,0.0V 234.6599ms,0.0
+ 234.6600ms,3.3V 234.6693ms,3.3
+ 234.6694ms,0.0V 234.6799ms,0.0
+ 234.6800ms,3.3V 234.6893ms,3.3
+ 234.6894ms,0.0V 234.6999ms,0.0
+ 234.7000ms,3.3V 234.7093ms,3.3
+ 234.7094ms,0.0V 234.7199ms,0.0
+ 234.7200ms,3.3V 234.7293ms,3.3
+ 234.7294ms,0.0V 234.7399ms,0.0
+ 234.7400ms,3.3V 234.7493ms,3.3
+ 234.7494ms,0.0V 234.7599ms,0.0
+ 234.7600ms,3.3V 234.7693ms,3.3
+ 234.7694ms,0.0V 234.7799ms,0.0
+ 234.7800ms,3.3V 234.7893ms,3.3
+ 234.7894ms,0.0V 234.7999ms,0.0
+ 234.8000ms,3.3V 234.8093ms,3.3
+ 234.8094ms,0.0V 234.8199ms,0.0
+ 234.8200ms,3.3V 234.8293ms,3.3
+ 234.8294ms,0.0V 234.8399ms,0.0
+ 234.8400ms,3.3V 234.8493ms,3.3
+ 234.8494ms,0.0V 234.8599ms,0.0
+ 234.8600ms,3.3V 234.8693ms,3.3
+ 234.8694ms,0.0V 234.8799ms,0.0
+ 234.8800ms,3.3V 234.8893ms,3.3
+ 234.8894ms,0.0V 234.8999ms,0.0
+ 234.9000ms,3.3V 234.9093ms,3.3
+ 234.9094ms,0.0V 234.9199ms,0.0
+ 234.9200ms,3.3V 234.9293ms,3.3
+ 234.9294ms,0.0V 234.9399ms,0.0
+ 234.9400ms,3.3V 234.9493ms,3.3
+ 234.9494ms,0.0V 234.9599ms,0.0
+ 234.9600ms,3.3V 234.9693ms,3.3
+ 234.9694ms,0.0V 234.9799ms,0.0
+ 234.9800ms,3.3V 234.9893ms,3.3
+ 234.9894ms,0.0V 234.9999ms,0.0
+ 235.0000ms,3.3V 235.0093ms,3.3
+ 235.0094ms,0.0V 235.0199ms,0.0
+ 235.0200ms,3.3V 235.0293ms,3.3
+ 235.0294ms,0.0V 235.0399ms,0.0
+ 235.0400ms,3.3V 235.0493ms,3.3
+ 235.0494ms,0.0V 235.0599ms,0.0
+ 235.0600ms,3.3V 235.0693ms,3.3
+ 235.0694ms,0.0V 235.0799ms,0.0
+ 235.0800ms,3.3V 235.0893ms,3.3
+ 235.0894ms,0.0V 235.0999ms,0.0
+ 235.1000ms,3.3V 235.1093ms,3.3
+ 235.1094ms,0.0V 235.1199ms,0.0
+ 235.1200ms,3.3V 235.1293ms,3.3
+ 235.1294ms,0.0V 235.1399ms,0.0
+ 235.1400ms,3.3V 235.1493ms,3.3
+ 235.1494ms,0.0V 235.1599ms,0.0
+ 235.1600ms,3.3V 235.1693ms,3.3
+ 235.1694ms,0.0V 235.1799ms,0.0
+ 235.1800ms,3.3V 235.1893ms,3.3
+ 235.1894ms,0.0V 235.1999ms,0.0
+ 235.2000ms,3.3V 235.2093ms,3.3
+ 235.2094ms,0.0V 235.2199ms,0.0
+ 235.2200ms,3.3V 235.2293ms,3.3
+ 235.2294ms,0.0V 235.2399ms,0.0
+ 235.2400ms,3.3V 235.2493ms,3.3
+ 235.2494ms,0.0V 235.2599ms,0.0
+ 235.2600ms,3.3V 235.2693ms,3.3
+ 235.2694ms,0.0V 235.2799ms,0.0
+ 235.2800ms,3.3V 235.2893ms,3.3
+ 235.2894ms,0.0V 235.2999ms,0.0
+ 235.3000ms,3.3V 235.3093ms,3.3
+ 235.3094ms,0.0V 235.3199ms,0.0
+ 235.3200ms,3.3V 235.3293ms,3.3
+ 235.3294ms,0.0V 235.3399ms,0.0
+ 235.3400ms,3.3V 235.3493ms,3.3
+ 235.3494ms,0.0V 235.3599ms,0.0
+ 235.3600ms,3.3V 235.3695ms,3.3
+ 235.3696ms,0.0V 235.3799ms,0.0
+ 235.3800ms,3.3V 235.3895ms,3.3
+ 235.3896ms,0.0V 235.3999ms,0.0
+ 235.4000ms,3.3V 235.4095ms,3.3
+ 235.4096ms,0.0V 235.4199ms,0.0
+ 235.4200ms,3.3V 235.4295ms,3.3
+ 235.4296ms,0.0V 235.4399ms,0.0
+ 235.4400ms,3.3V 235.4495ms,3.3
+ 235.4496ms,0.0V 235.4599ms,0.0
+ 235.4600ms,3.3V 235.4695ms,3.3
+ 235.4696ms,0.0V 235.4799ms,0.0
+ 235.4800ms,3.3V 235.4895ms,3.3
+ 235.4896ms,0.0V 235.4999ms,0.0
+ 235.5000ms,3.3V 235.5095ms,3.3
+ 235.5096ms,0.0V 235.5199ms,0.0
+ 235.5200ms,3.3V 235.5295ms,3.3
+ 235.5296ms,0.0V 235.5399ms,0.0
+ 235.5400ms,3.3V 235.5495ms,3.3
+ 235.5496ms,0.0V 235.5599ms,0.0
+ 235.5600ms,3.3V 235.5695ms,3.3
+ 235.5696ms,0.0V 235.5799ms,0.0
+ 235.5800ms,3.3V 235.5895ms,3.3
+ 235.5896ms,0.0V 235.5999ms,0.0
+ 235.6000ms,3.3V 235.6095ms,3.3
+ 235.6096ms,0.0V 235.6199ms,0.0
+ 235.6200ms,3.3V 235.6295ms,3.3
+ 235.6296ms,0.0V 235.6399ms,0.0
+ 235.6400ms,3.3V 235.6495ms,3.3
+ 235.6496ms,0.0V 235.6599ms,0.0
+ 235.6600ms,3.3V 235.6695ms,3.3
+ 235.6696ms,0.0V 235.6799ms,0.0
+ 235.6800ms,3.3V 235.6895ms,3.3
+ 235.6896ms,0.0V 235.6999ms,0.0
+ 235.7000ms,3.3V 235.7095ms,3.3
+ 235.7096ms,0.0V 235.7199ms,0.0
+ 235.7200ms,3.3V 235.7295ms,3.3
+ 235.7296ms,0.0V 235.7399ms,0.0
+ 235.7400ms,3.3V 235.7495ms,3.3
+ 235.7496ms,0.0V 235.7599ms,0.0
+ 235.7600ms,3.3V 235.7695ms,3.3
+ 235.7696ms,0.0V 235.7799ms,0.0
+ 235.7800ms,3.3V 235.7895ms,3.3
+ 235.7896ms,0.0V 235.7999ms,0.0
+ 235.8000ms,3.3V 235.8095ms,3.3
+ 235.8096ms,0.0V 235.8199ms,0.0
+ 235.8200ms,3.3V 235.8295ms,3.3
+ 235.8296ms,0.0V 235.8399ms,0.0
+ 235.8400ms,3.3V 235.8495ms,3.3
+ 235.8496ms,0.0V 235.8599ms,0.0
+ 235.8600ms,3.3V 235.8695ms,3.3
+ 235.8696ms,0.0V 235.8799ms,0.0
+ 235.8800ms,3.3V 235.8895ms,3.3
+ 235.8896ms,0.0V 235.8999ms,0.0
+ 235.9000ms,3.3V 235.9095ms,3.3
+ 235.9096ms,0.0V 235.9199ms,0.0
+ 235.9200ms,3.3V 235.9295ms,3.3
+ 235.9296ms,0.0V 235.9399ms,0.0
+ 235.9400ms,3.3V 235.9495ms,3.3
+ 235.9496ms,0.0V 235.9599ms,0.0
+ 235.9600ms,3.3V 235.9695ms,3.3
+ 235.9696ms,0.0V 235.9799ms,0.0
+ 235.9800ms,3.3V 235.9895ms,3.3
+ 235.9896ms,0.0V 235.9999ms,0.0
+ 236.0000ms,3.3V 236.0095ms,3.3
+ 236.0096ms,0.0V 236.0199ms,0.0
+ 236.0200ms,3.3V 236.0295ms,3.3
+ 236.0296ms,0.0V 236.0399ms,0.0
+ 236.0400ms,3.3V 236.0495ms,3.3
+ 236.0496ms,0.0V 236.0599ms,0.0
+ 236.0600ms,3.3V 236.0695ms,3.3
+ 236.0696ms,0.0V 236.0799ms,0.0
+ 236.0800ms,3.3V 236.0895ms,3.3
+ 236.0896ms,0.0V 236.0999ms,0.0
+ 236.1000ms,3.3V 236.1095ms,3.3
+ 236.1096ms,0.0V 236.1199ms,0.0
+ 236.1200ms,3.3V 236.1295ms,3.3
+ 236.1296ms,0.0V 236.1399ms,0.0
+ 236.1400ms,3.3V 236.1495ms,3.3
+ 236.1496ms,0.0V 236.1599ms,0.0
+ 236.1600ms,3.3V 236.1695ms,3.3
+ 236.1696ms,0.0V 236.1799ms,0.0
+ 236.1800ms,3.3V 236.1895ms,3.3
+ 236.1896ms,0.0V 236.1999ms,0.0
+ 236.2000ms,3.3V 236.2095ms,3.3
+ 236.2096ms,0.0V 236.2199ms,0.0
+ 236.2200ms,3.3V 236.2295ms,3.3
+ 236.2296ms,0.0V 236.2399ms,0.0
+ 236.2400ms,3.3V 236.2495ms,3.3
+ 236.2496ms,0.0V 236.2599ms,0.0
+ 236.2600ms,3.3V 236.2695ms,3.3
+ 236.2696ms,0.0V 236.2799ms,0.0
+ 236.2800ms,3.3V 236.2895ms,3.3
+ 236.2896ms,0.0V 236.2999ms,0.0
+ 236.3000ms,3.3V 236.3095ms,3.3
+ 236.3096ms,0.0V 236.3199ms,0.0
+ 236.3200ms,3.3V 236.3295ms,3.3
+ 236.3296ms,0.0V 236.3399ms,0.0
+ 236.3400ms,3.3V 236.3495ms,3.3
+ 236.3496ms,0.0V 236.3599ms,0.0
+ 236.3600ms,3.3V 236.3695ms,3.3
+ 236.3696ms,0.0V 236.3799ms,0.0
+ 236.3800ms,3.3V 236.3895ms,3.3
+ 236.3896ms,0.0V 236.3999ms,0.0
+ 236.4000ms,3.3V 236.4095ms,3.3
+ 236.4096ms,0.0V 236.4199ms,0.0
+ 236.4200ms,3.3V 236.4295ms,3.3
+ 236.4296ms,0.0V 236.4399ms,0.0
+ 236.4400ms,3.3V 236.4495ms,3.3
+ 236.4496ms,0.0V 236.4599ms,0.0
+ 236.4600ms,3.3V 236.4695ms,3.3
+ 236.4696ms,0.0V 236.4799ms,0.0
+ 236.4800ms,3.3V 236.4895ms,3.3
+ 236.4896ms,0.0V 236.4999ms,0.0
+ 236.5000ms,3.3V 236.5095ms,3.3
+ 236.5096ms,0.0V 236.5199ms,0.0
+ 236.5200ms,3.3V 236.5295ms,3.3
+ 236.5296ms,0.0V 236.5399ms,0.0
+ 236.5400ms,3.3V 236.5495ms,3.3
+ 236.5496ms,0.0V 236.5599ms,0.0
+ 236.5600ms,3.3V 236.5695ms,3.3
+ 236.5696ms,0.0V 236.5799ms,0.0
+ 236.5800ms,3.3V 236.5895ms,3.3
+ 236.5896ms,0.0V 236.5999ms,0.0
+ 236.6000ms,3.3V 236.6095ms,3.3
+ 236.6096ms,0.0V 236.6199ms,0.0
+ 236.6200ms,3.3V 236.6295ms,3.3
+ 236.6296ms,0.0V 236.6399ms,0.0
+ 236.6400ms,3.3V 236.6495ms,3.3
+ 236.6496ms,0.0V 236.6599ms,0.0
+ 236.6600ms,3.3V 236.6695ms,3.3
+ 236.6696ms,0.0V 236.6799ms,0.0
+ 236.6800ms,3.3V 236.6895ms,3.3
+ 236.6896ms,0.0V 236.6999ms,0.0
+ 236.7000ms,3.3V 236.7095ms,3.3
+ 236.7096ms,0.0V 236.7199ms,0.0
+ 236.7200ms,3.3V 236.7295ms,3.3
+ 236.7296ms,0.0V 236.7399ms,0.0
+ 236.7400ms,3.3V 236.7495ms,3.3
+ 236.7496ms,0.0V 236.7599ms,0.0
+ 236.7600ms,3.3V 236.7695ms,3.3
+ 236.7696ms,0.0V 236.7799ms,0.0
+ 236.7800ms,3.3V 236.7895ms,3.3
+ 236.7896ms,0.0V 236.7999ms,0.0
+ 236.8000ms,3.3V 236.8095ms,3.3
+ 236.8096ms,0.0V 236.8199ms,0.0
+ 236.8200ms,3.3V 236.8295ms,3.3
+ 236.8296ms,0.0V 236.8399ms,0.0
+ 236.8400ms,3.3V 236.8495ms,3.3
+ 236.8496ms,0.0V 236.8599ms,0.0
+ 236.8600ms,3.3V 236.8695ms,3.3
+ 236.8696ms,0.0V 236.8799ms,0.0
+ 236.8800ms,3.3V 236.8895ms,3.3
+ 236.8896ms,0.0V 236.8999ms,0.0
+ 236.9000ms,3.3V 236.9095ms,3.3
+ 236.9096ms,0.0V 236.9199ms,0.0
+ 236.9200ms,3.3V 236.9295ms,3.3
+ 236.9296ms,0.0V 236.9399ms,0.0
+ 236.9400ms,3.3V 236.9495ms,3.3
+ 236.9496ms,0.0V 236.9599ms,0.0
+ 236.9600ms,3.3V 236.9695ms,3.3
+ 236.9696ms,0.0V 236.9799ms,0.0
+ 236.9800ms,3.3V 236.9895ms,3.3
+ 236.9896ms,0.0V 236.9999ms,0.0
+ 237.0000ms,3.3V 237.0095ms,3.3
+ 237.0096ms,0.0V 237.0199ms,0.0
+ 237.0200ms,3.3V 237.0295ms,3.3
+ 237.0296ms,0.0V 237.0399ms,0.0
+ 237.0400ms,3.3V 237.0495ms,3.3
+ 237.0496ms,0.0V 237.0599ms,0.0
+ 237.0600ms,3.3V 237.0695ms,3.3
+ 237.0696ms,0.0V 237.0799ms,0.0
+ 237.0800ms,3.3V 237.0895ms,3.3
+ 237.0896ms,0.0V 237.0999ms,0.0
+ 237.1000ms,3.3V 237.1095ms,3.3
+ 237.1096ms,0.0V 237.1199ms,0.0
+ 237.1200ms,3.3V 237.1295ms,3.3
+ 237.1296ms,0.0V 237.1399ms,0.0
+ 237.1400ms,3.3V 237.1495ms,3.3
+ 237.1496ms,0.0V 237.1599ms,0.0
+ 237.1600ms,3.3V 237.1695ms,3.3
+ 237.1696ms,0.0V 237.1799ms,0.0
+ 237.1800ms,3.3V 237.1895ms,3.3
+ 237.1896ms,0.0V 237.1999ms,0.0
+ 237.2000ms,3.3V 237.2095ms,3.3
+ 237.2096ms,0.0V 237.2199ms,0.0
+ 237.2200ms,3.3V 237.2295ms,3.3
+ 237.2296ms,0.0V 237.2399ms,0.0
+ 237.2400ms,3.3V 237.2495ms,3.3
+ 237.2496ms,0.0V 237.2599ms,0.0
+ 237.2600ms,3.3V 237.2695ms,3.3
+ 237.2696ms,0.0V 237.2799ms,0.0
+ 237.2800ms,3.3V 237.2895ms,3.3
+ 237.2896ms,0.0V 237.2999ms,0.0
+ 237.3000ms,3.3V 237.3095ms,3.3
+ 237.3096ms,0.0V 237.3199ms,0.0
+ 237.3200ms,3.3V 237.3295ms,3.3
+ 237.3296ms,0.0V 237.3399ms,0.0
+ 237.3400ms,3.3V 237.3495ms,3.3
+ 237.3496ms,0.0V 237.3599ms,0.0
+ 237.3600ms,3.3V 237.3695ms,3.3
+ 237.3696ms,0.0V 237.3799ms,0.0
+ 237.3800ms,3.3V 237.3895ms,3.3
+ 237.3896ms,0.0V 237.3999ms,0.0
+ 237.4000ms,3.3V 237.4095ms,3.3
+ 237.4096ms,0.0V 237.4199ms,0.0
+ 237.4200ms,3.3V 237.4295ms,3.3
+ 237.4296ms,0.0V 237.4399ms,0.0
+ 237.4400ms,3.3V 237.4495ms,3.3
+ 237.4496ms,0.0V 237.4599ms,0.0
+ 237.4600ms,3.3V 237.4695ms,3.3
+ 237.4696ms,0.0V 237.4799ms,0.0
+ 237.4800ms,3.3V 237.4895ms,3.3
+ 237.4896ms,0.0V 237.4999ms,0.0
+ 237.5000ms,3.3V 237.5095ms,3.3
+ 237.5096ms,0.0V 237.5199ms,0.0
+ 237.5200ms,3.3V 237.5295ms,3.3
+ 237.5296ms,0.0V 237.5399ms,0.0
+ 237.5400ms,3.3V 237.5495ms,3.3
+ 237.5496ms,0.0V 237.5599ms,0.0
+ 237.5600ms,3.3V 237.5695ms,3.3
+ 237.5696ms,0.0V 237.5799ms,0.0
+ 237.5800ms,3.3V 237.5895ms,3.3
+ 237.5896ms,0.0V 237.5999ms,0.0
+ 237.6000ms,3.3V 237.6095ms,3.3
+ 237.6096ms,0.0V 237.6199ms,0.0
+ 237.6200ms,3.3V 237.6295ms,3.3
+ 237.6296ms,0.0V 237.6399ms,0.0
+ 237.6400ms,3.3V 237.6495ms,3.3
+ 237.6496ms,0.0V 237.6599ms,0.0
+ 237.6600ms,3.3V 237.6695ms,3.3
+ 237.6696ms,0.0V 237.6799ms,0.0
+ 237.6800ms,3.3V 237.6895ms,3.3
+ 237.6896ms,0.0V 237.6999ms,0.0
+ 237.7000ms,3.3V 237.7095ms,3.3
+ 237.7096ms,0.0V 237.7199ms,0.0
+ 237.7200ms,3.3V 237.7295ms,3.3
+ 237.7296ms,0.0V 237.7399ms,0.0
+ 237.7400ms,3.3V 237.7495ms,3.3
+ 237.7496ms,0.0V 237.7599ms,0.0
+ 237.7600ms,3.3V 237.7695ms,3.3
+ 237.7696ms,0.0V 237.7799ms,0.0
+ 237.7800ms,3.3V 237.7895ms,3.3
+ 237.7896ms,0.0V 237.7999ms,0.0
+ 237.8000ms,3.3V 237.8095ms,3.3
+ 237.8096ms,0.0V 237.8199ms,0.0
+ 237.8200ms,3.3V 237.8295ms,3.3
+ 237.8296ms,0.0V 237.8399ms,0.0
+ 237.8400ms,3.3V 237.8495ms,3.3
+ 237.8496ms,0.0V 237.8599ms,0.0
+ 237.8600ms,3.3V 237.8695ms,3.3
+ 237.8696ms,0.0V 237.8799ms,0.0
+ 237.8800ms,3.3V 237.8895ms,3.3
+ 237.8896ms,0.0V 237.8999ms,0.0
+ 237.9000ms,3.3V 237.9095ms,3.3
+ 237.9096ms,0.0V 237.9199ms,0.0
+ 237.9200ms,3.3V 237.9295ms,3.3
+ 237.9296ms,0.0V 237.9399ms,0.0
+ 237.9400ms,3.3V 237.9495ms,3.3
+ 237.9496ms,0.0V 237.9599ms,0.0
+ 237.9600ms,3.3V 237.9695ms,3.3
+ 237.9696ms,0.0V 237.9799ms,0.0
+ 237.9800ms,3.3V 237.9895ms,3.3
+ 237.9896ms,0.0V 237.9999ms,0.0
+ 238.0000ms,3.3V 238.0095ms,3.3
+ 238.0096ms,0.0V 238.0199ms,0.0
+ 238.0200ms,3.3V 238.0295ms,3.3
+ 238.0296ms,0.0V 238.0399ms,0.0
+ 238.0400ms,3.3V 238.0495ms,3.3
+ 238.0496ms,0.0V 238.0599ms,0.0
+ 238.0600ms,3.3V 238.0695ms,3.3
+ 238.0696ms,0.0V 238.0799ms,0.0
+ 238.0800ms,3.3V 238.0895ms,3.3
+ 238.0896ms,0.0V 238.0999ms,0.0
+ 238.1000ms,3.3V 238.1095ms,3.3
+ 238.1096ms,0.0V 238.1199ms,0.0
+ 238.1200ms,3.3V 238.1295ms,3.3
+ 238.1296ms,0.0V 238.1399ms,0.0
+ 238.1400ms,3.3V 238.1495ms,3.3
+ 238.1496ms,0.0V 238.1599ms,0.0
+ 238.1600ms,3.3V 238.1695ms,3.3
+ 238.1696ms,0.0V 238.1799ms,0.0
+ 238.1800ms,3.3V 238.1895ms,3.3
+ 238.1896ms,0.0V 238.1999ms,0.0
+ 238.2000ms,3.3V 238.2095ms,3.3
+ 238.2096ms,0.0V 238.2199ms,0.0
+ 238.2200ms,3.3V 238.2295ms,3.3
+ 238.2296ms,0.0V 238.2399ms,0.0
+ 238.2400ms,3.3V 238.2495ms,3.3
+ 238.2496ms,0.0V 238.2599ms,0.0
+ 238.2600ms,3.3V 238.2695ms,3.3
+ 238.2696ms,0.0V 238.2799ms,0.0
+ 238.2800ms,3.3V 238.2895ms,3.3
+ 238.2896ms,0.0V 238.2999ms,0.0
+ 238.3000ms,3.3V 238.3095ms,3.3
+ 238.3096ms,0.0V 238.3199ms,0.0
+ 238.3200ms,3.3V 238.3295ms,3.3
+ 238.3296ms,0.0V 238.3399ms,0.0
+ 238.3400ms,3.3V 238.3495ms,3.3
+ 238.3496ms,0.0V 238.3599ms,0.0
+ 238.3600ms,3.3V 238.3695ms,3.3
+ 238.3696ms,0.0V 238.3799ms,0.0
+ 238.3800ms,3.3V 238.3895ms,3.3
+ 238.3896ms,0.0V 238.3999ms,0.0
+ 238.4000ms,3.3V 238.4095ms,3.3
+ 238.4096ms,0.0V 238.4199ms,0.0
+ 238.4200ms,3.3V 238.4295ms,3.3
+ 238.4296ms,0.0V 238.4399ms,0.0
+ 238.4400ms,3.3V 238.4495ms,3.3
+ 238.4496ms,0.0V 238.4599ms,0.0
+ 238.4600ms,3.3V 238.4695ms,3.3
+ 238.4696ms,0.0V 238.4799ms,0.0
+ 238.4800ms,3.3V 238.4895ms,3.3
+ 238.4896ms,0.0V 238.4999ms,0.0
+ 238.5000ms,3.3V 238.5095ms,3.3
+ 238.5096ms,0.0V 238.5199ms,0.0
+ 238.5200ms,3.3V 238.5295ms,3.3
+ 238.5296ms,0.0V 238.5399ms,0.0
+ 238.5400ms,3.3V 238.5495ms,3.3
+ 238.5496ms,0.0V 238.5599ms,0.0
+ 238.5600ms,3.3V 238.5695ms,3.3
+ 238.5696ms,0.0V 238.5799ms,0.0
+ 238.5800ms,3.3V 238.5895ms,3.3
+ 238.5896ms,0.0V 238.5999ms,0.0
+ 238.6000ms,3.3V 238.6095ms,3.3
+ 238.6096ms,0.0V 238.6199ms,0.0
+ 238.6200ms,3.3V 238.6295ms,3.3
+ 238.6296ms,0.0V 238.6399ms,0.0
+ 238.6400ms,3.3V 238.6495ms,3.3
+ 238.6496ms,0.0V 238.6599ms,0.0
+ 238.6600ms,3.3V 238.6695ms,3.3
+ 238.6696ms,0.0V 238.6799ms,0.0
+ 238.6800ms,3.3V 238.6895ms,3.3
+ 238.6896ms,0.0V 238.6999ms,0.0
+ 238.7000ms,3.3V 238.7095ms,3.3
+ 238.7096ms,0.0V 238.7199ms,0.0
+ 238.7200ms,3.3V 238.7295ms,3.3
+ 238.7296ms,0.0V 238.7399ms,0.0
+ 238.7400ms,3.3V 238.7495ms,3.3
+ 238.7496ms,0.0V 238.7599ms,0.0
+ 238.7600ms,3.3V 238.7695ms,3.3
+ 238.7696ms,0.0V 238.7799ms,0.0
+ 238.7800ms,3.3V 238.7895ms,3.3
+ 238.7896ms,0.0V 238.7999ms,0.0
+ 238.8000ms,3.3V 238.8095ms,3.3
+ 238.8096ms,0.0V 238.8199ms,0.0
+ 238.8200ms,3.3V 238.8295ms,3.3
+ 238.8296ms,0.0V 238.8399ms,0.0
+ 238.8400ms,3.3V 238.8495ms,3.3
+ 238.8496ms,0.0V 238.8599ms,0.0
+ 238.8600ms,3.3V 238.8695ms,3.3
+ 238.8696ms,0.0V 238.8799ms,0.0
+ 238.8800ms,3.3V 238.8895ms,3.3
+ 238.8896ms,0.0V 238.8999ms,0.0
+ 238.9000ms,3.3V 238.9095ms,3.3
+ 238.9096ms,0.0V 238.9199ms,0.0
+ 238.9200ms,3.3V 238.9295ms,3.3
+ 238.9296ms,0.0V 238.9399ms,0.0
+ 238.9400ms,3.3V 238.9495ms,3.3
+ 238.9496ms,0.0V 238.9599ms,0.0
+ 238.9600ms,3.3V 238.9695ms,3.3
+ 238.9696ms,0.0V 238.9799ms,0.0
+ 238.9800ms,3.3V 238.9895ms,3.3
+ 238.9896ms,0.0V 238.9999ms,0.0
+ 239.0000ms,3.3V 239.0095ms,3.3
+ 239.0096ms,0.0V 239.0199ms,0.0
+ 239.0200ms,3.3V 239.0295ms,3.3
+ 239.0296ms,0.0V 239.0399ms,0.0
+ 239.0400ms,3.3V 239.0495ms,3.3
+ 239.0496ms,0.0V 239.0599ms,0.0
+ 239.0600ms,3.3V 239.0695ms,3.3
+ 239.0696ms,0.0V 239.0799ms,0.0
+ 239.0800ms,3.3V 239.0895ms,3.3
+ 239.0896ms,0.0V 239.0999ms,0.0
+ 239.1000ms,3.3V 239.1095ms,3.3
+ 239.1096ms,0.0V 239.1199ms,0.0
+ 239.1200ms,3.3V 239.1295ms,3.3
+ 239.1296ms,0.0V 239.1399ms,0.0
+ 239.1400ms,3.3V 239.1495ms,3.3
+ 239.1496ms,0.0V 239.1599ms,0.0
+ 239.1600ms,3.3V 239.1695ms,3.3
+ 239.1696ms,0.0V 239.1799ms,0.0
+ 239.1800ms,3.3V 239.1895ms,3.3
+ 239.1896ms,0.0V 239.1999ms,0.0
+ 239.2000ms,3.3V 239.2095ms,3.3
+ 239.2096ms,0.0V 239.2199ms,0.0
+ 239.2200ms,3.3V 239.2295ms,3.3
+ 239.2296ms,0.0V 239.2399ms,0.0
+ 239.2400ms,3.3V 239.2495ms,3.3
+ 239.2496ms,0.0V 239.2599ms,0.0
+ 239.2600ms,3.3V 239.2695ms,3.3
+ 239.2696ms,0.0V 239.2799ms,0.0
+ 239.2800ms,3.3V 239.2895ms,3.3
+ 239.2896ms,0.0V 239.2999ms,0.0
+ 239.3000ms,3.3V 239.3095ms,3.3
+ 239.3096ms,0.0V 239.3199ms,0.0
+ 239.3200ms,3.3V 239.3295ms,3.3
+ 239.3296ms,0.0V 239.3399ms,0.0
+ 239.3400ms,3.3V 239.3495ms,3.3
+ 239.3496ms,0.0V 239.3599ms,0.0
+ 239.3600ms,3.3V 239.3695ms,3.3
+ 239.3696ms,0.0V 239.3799ms,0.0
+ 239.3800ms,3.3V 239.3895ms,3.3
+ 239.3896ms,0.0V 239.3999ms,0.0
+ 239.4000ms,3.3V 239.4095ms,3.3
+ 239.4096ms,0.0V 239.4199ms,0.0
+ 239.4200ms,3.3V 239.4295ms,3.3
+ 239.4296ms,0.0V 239.4399ms,0.0
+ 239.4400ms,3.3V 239.4495ms,3.3
+ 239.4496ms,0.0V 239.4599ms,0.0
+ 239.4600ms,3.3V 239.4695ms,3.3
+ 239.4696ms,0.0V 239.4799ms,0.0
+ 239.4800ms,3.3V 239.4895ms,3.3
+ 239.4896ms,0.0V 239.4999ms,0.0
+ 239.5000ms,3.3V 239.5095ms,3.3
+ 239.5096ms,0.0V 239.5199ms,0.0
+ 239.5200ms,3.3V 239.5295ms,3.3
+ 239.5296ms,0.0V 239.5399ms,0.0
+ 239.5400ms,3.3V 239.5495ms,3.3
+ 239.5496ms,0.0V 239.5599ms,0.0
+ 239.5600ms,3.3V 239.5695ms,3.3
+ 239.5696ms,0.0V 239.5799ms,0.0
+ 239.5800ms,3.3V 239.5895ms,3.3
+ 239.5896ms,0.0V 239.5999ms,0.0
+ 239.6000ms,3.3V 239.6095ms,3.3
+ 239.6096ms,0.0V 239.6199ms,0.0
+ 239.6200ms,3.3V 239.6295ms,3.3
+ 239.6296ms,0.0V 239.6399ms,0.0
+ 239.6400ms,3.3V 239.6495ms,3.3
+ 239.6496ms,0.0V 239.6599ms,0.0
+ 239.6600ms,3.3V 239.6695ms,3.3
+ 239.6696ms,0.0V 239.6799ms,0.0
+ 239.6800ms,3.3V 239.6895ms,3.3
+ 239.6896ms,0.0V 239.6999ms,0.0
+ 239.7000ms,3.3V 239.7095ms,3.3
+ 239.7096ms,0.0V 239.7199ms,0.0
+ 239.7200ms,3.3V 239.7295ms,3.3
+ 239.7296ms,0.0V 239.7399ms,0.0
+ 239.7400ms,3.3V 239.7495ms,3.3
+ 239.7496ms,0.0V 239.7599ms,0.0
+ 239.7600ms,3.3V 239.7695ms,3.3
+ 239.7696ms,0.0V 239.7799ms,0.0
+ 239.7800ms,3.3V 239.7895ms,3.3
+ 239.7896ms,0.0V 239.7999ms,0.0
+ 239.8000ms,3.3V 239.8095ms,3.3
+ 239.8096ms,0.0V 239.8199ms,0.0
+ 239.8200ms,3.3V 239.8295ms,3.3
+ 239.8296ms,0.0V 239.8399ms,0.0
+ 239.8400ms,3.3V 239.8495ms,3.3
+ 239.8496ms,0.0V 239.8599ms,0.0
+ 239.8600ms,3.3V 239.8695ms,3.3
+ 239.8696ms,0.0V 239.8799ms,0.0
+ 239.8800ms,3.3V 239.8895ms,3.3
+ 239.8896ms,0.0V 239.8999ms,0.0
+ 239.9000ms,3.3V 239.9095ms,3.3
+ 239.9096ms,0.0V 239.9199ms,0.0
+ 239.9200ms,3.3V 239.9295ms,3.3
+ 239.9296ms,0.0V 239.9399ms,0.0
+ 239.9400ms,3.3V 239.9495ms,3.3
+ 239.9496ms,0.0V 239.9599ms,0.0
+ 239.9600ms,3.3V 239.9695ms,3.3
+ 239.9696ms,0.0V 239.9799ms,0.0
+ 239.9800ms,3.3V 239.9895ms,3.3
+ 239.9896ms,0.0V 239.9999ms,0.0
+ 240.0000ms,3.3V 240.0095ms,3.3
+ 240.0096ms,0.0V 240.0199ms,0.0
+ 240.0200ms,3.3V 240.0295ms,3.3
+ 240.0296ms,0.0V 240.0399ms,0.0
+ 240.0400ms,3.3V 240.0495ms,3.3
+ 240.0496ms,0.0V 240.0599ms,0.0
+ 240.0600ms,3.3V 240.0695ms,3.3
+ 240.0696ms,0.0V 240.0799ms,0.0
+ 240.0800ms,3.3V 240.0895ms,3.3
+ 240.0896ms,0.0V 240.0999ms,0.0
+ 240.1000ms,3.3V 240.1095ms,3.3
+ 240.1096ms,0.0V 240.1199ms,0.0
+ 240.1200ms,3.3V 240.1295ms,3.3
+ 240.1296ms,0.0V 240.1399ms,0.0
+ 240.1400ms,3.3V 240.1495ms,3.3
+ 240.1496ms,0.0V 240.1599ms,0.0
+ 240.1600ms,3.3V 240.1695ms,3.3
+ 240.1696ms,0.0V 240.1799ms,0.0
+ 240.1800ms,3.3V 240.1895ms,3.3
+ 240.1896ms,0.0V 240.1999ms,0.0
+ 240.2000ms,3.3V 240.2095ms,3.3
+ 240.2096ms,0.0V 240.2199ms,0.0
+ 240.2200ms,3.3V 240.2295ms,3.3
+ 240.2296ms,0.0V 240.2399ms,0.0
+ 240.2400ms,3.3V 240.2495ms,3.3
+ 240.2496ms,0.0V 240.2599ms,0.0
+ 240.2600ms,3.3V 240.2695ms,3.3
+ 240.2696ms,0.0V 240.2799ms,0.0
+ 240.2800ms,3.3V 240.2895ms,3.3
+ 240.2896ms,0.0V 240.2999ms,0.0
+ 240.3000ms,3.3V 240.3095ms,3.3
+ 240.3096ms,0.0V 240.3199ms,0.0
+ 240.3200ms,3.3V 240.3295ms,3.3
+ 240.3296ms,0.0V 240.3399ms,0.0
+ 240.3400ms,3.3V 240.3495ms,3.3
+ 240.3496ms,0.0V 240.3599ms,0.0
+ 240.3600ms,3.3V 240.3697ms,3.3
+ 240.3698ms,0.0V 240.3799ms,0.0
+ 240.3800ms,3.3V 240.3897ms,3.3
+ 240.3898ms,0.0V 240.3999ms,0.0
+ 240.4000ms,3.3V 240.4097ms,3.3
+ 240.4098ms,0.0V 240.4199ms,0.0
+ 240.4200ms,3.3V 240.4297ms,3.3
+ 240.4298ms,0.0V 240.4399ms,0.0
+ 240.4400ms,3.3V 240.4497ms,3.3
+ 240.4498ms,0.0V 240.4599ms,0.0
+ 240.4600ms,3.3V 240.4697ms,3.3
+ 240.4698ms,0.0V 240.4799ms,0.0
+ 240.4800ms,3.3V 240.4897ms,3.3
+ 240.4898ms,0.0V 240.4999ms,0.0
+ 240.5000ms,3.3V 240.5097ms,3.3
+ 240.5098ms,0.0V 240.5199ms,0.0
+ 240.5200ms,3.3V 240.5297ms,3.3
+ 240.5298ms,0.0V 240.5399ms,0.0
+ 240.5400ms,3.3V 240.5497ms,3.3
+ 240.5498ms,0.0V 240.5599ms,0.0
+ 240.5600ms,3.3V 240.5697ms,3.3
+ 240.5698ms,0.0V 240.5799ms,0.0
+ 240.5800ms,3.3V 240.5897ms,3.3
+ 240.5898ms,0.0V 240.5999ms,0.0
+ 240.6000ms,3.3V 240.6097ms,3.3
+ 240.6098ms,0.0V 240.6199ms,0.0
+ 240.6200ms,3.3V 240.6297ms,3.3
+ 240.6298ms,0.0V 240.6399ms,0.0
+ 240.6400ms,3.3V 240.6497ms,3.3
+ 240.6498ms,0.0V 240.6599ms,0.0
+ 240.6600ms,3.3V 240.6697ms,3.3
+ 240.6698ms,0.0V 240.6799ms,0.0
+ 240.6800ms,3.3V 240.6897ms,3.3
+ 240.6898ms,0.0V 240.6999ms,0.0
+ 240.7000ms,3.3V 240.7097ms,3.3
+ 240.7098ms,0.0V 240.7199ms,0.0
+ 240.7200ms,3.3V 240.7297ms,3.3
+ 240.7298ms,0.0V 240.7399ms,0.0
+ 240.7400ms,3.3V 240.7497ms,3.3
+ 240.7498ms,0.0V 240.7599ms,0.0
+ 240.7600ms,3.3V 240.7697ms,3.3
+ 240.7698ms,0.0V 240.7799ms,0.0
+ 240.7800ms,3.3V 240.7897ms,3.3
+ 240.7898ms,0.0V 240.7999ms,0.0
+ 240.8000ms,3.3V 240.8097ms,3.3
+ 240.8098ms,0.0V 240.8199ms,0.0
+ 240.8200ms,3.3V 240.8297ms,3.3
+ 240.8298ms,0.0V 240.8399ms,0.0
+ 240.8400ms,3.3V 240.8497ms,3.3
+ 240.8498ms,0.0V 240.8599ms,0.0
+ 240.8600ms,3.3V 240.8697ms,3.3
+ 240.8698ms,0.0V 240.8799ms,0.0
+ 240.8800ms,3.3V 240.8897ms,3.3
+ 240.8898ms,0.0V 240.8999ms,0.0
+ 240.9000ms,3.3V 240.9097ms,3.3
+ 240.9098ms,0.0V 240.9199ms,0.0
+ 240.9200ms,3.3V 240.9297ms,3.3
+ 240.9298ms,0.0V 240.9399ms,0.0
+ 240.9400ms,3.3V 240.9497ms,3.3
+ 240.9498ms,0.0V 240.9599ms,0.0
+ 240.9600ms,3.3V 240.9697ms,3.3
+ 240.9698ms,0.0V 240.9799ms,0.0
+ 240.9800ms,3.3V 240.9897ms,3.3
+ 240.9898ms,0.0V 240.9999ms,0.0
+ 241.0000ms,3.3V 241.0097ms,3.3
+ 241.0098ms,0.0V 241.0199ms,0.0
+ 241.0200ms,3.3V 241.0297ms,3.3
+ 241.0298ms,0.0V 241.0399ms,0.0
+ 241.0400ms,3.3V 241.0497ms,3.3
+ 241.0498ms,0.0V 241.0599ms,0.0
+ 241.0600ms,3.3V 241.0697ms,3.3
+ 241.0698ms,0.0V 241.0799ms,0.0
+ 241.0800ms,3.3V 241.0897ms,3.3
+ 241.0898ms,0.0V 241.0999ms,0.0
+ 241.1000ms,3.3V 241.1097ms,3.3
+ 241.1098ms,0.0V 241.1199ms,0.0
+ 241.1200ms,3.3V 241.1297ms,3.3
+ 241.1298ms,0.0V 241.1399ms,0.0
+ 241.1400ms,3.3V 241.1497ms,3.3
+ 241.1498ms,0.0V 241.1599ms,0.0
+ 241.1600ms,3.3V 241.1697ms,3.3
+ 241.1698ms,0.0V 241.1799ms,0.0
+ 241.1800ms,3.3V 241.1897ms,3.3
+ 241.1898ms,0.0V 241.1999ms,0.0
+ 241.2000ms,3.3V 241.2097ms,3.3
+ 241.2098ms,0.0V 241.2199ms,0.0
+ 241.2200ms,3.3V 241.2297ms,3.3
+ 241.2298ms,0.0V 241.2399ms,0.0
+ 241.2400ms,3.3V 241.2497ms,3.3
+ 241.2498ms,0.0V 241.2599ms,0.0
+ 241.2600ms,3.3V 241.2697ms,3.3
+ 241.2698ms,0.0V 241.2799ms,0.0
+ 241.2800ms,3.3V 241.2897ms,3.3
+ 241.2898ms,0.0V 241.2999ms,0.0
+ 241.3000ms,3.3V 241.3097ms,3.3
+ 241.3098ms,0.0V 241.3199ms,0.0
+ 241.3200ms,3.3V 241.3297ms,3.3
+ 241.3298ms,0.0V 241.3399ms,0.0
+ 241.3400ms,3.3V 241.3497ms,3.3
+ 241.3498ms,0.0V 241.3599ms,0.0
+ 241.3600ms,3.3V 241.3697ms,3.3
+ 241.3698ms,0.0V 241.3799ms,0.0
+ 241.3800ms,3.3V 241.3897ms,3.3
+ 241.3898ms,0.0V 241.3999ms,0.0
+ 241.4000ms,3.3V 241.4097ms,3.3
+ 241.4098ms,0.0V 241.4199ms,0.0
+ 241.4200ms,3.3V 241.4297ms,3.3
+ 241.4298ms,0.0V 241.4399ms,0.0
+ 241.4400ms,3.3V 241.4497ms,3.3
+ 241.4498ms,0.0V 241.4599ms,0.0
+ 241.4600ms,3.3V 241.4697ms,3.3
+ 241.4698ms,0.0V 241.4799ms,0.0
+ 241.4800ms,3.3V 241.4897ms,3.3
+ 241.4898ms,0.0V 241.4999ms,0.0
+ 241.5000ms,3.3V 241.5097ms,3.3
+ 241.5098ms,0.0V 241.5199ms,0.0
+ 241.5200ms,3.3V 241.5297ms,3.3
+ 241.5298ms,0.0V 241.5399ms,0.0
+ 241.5400ms,3.3V 241.5497ms,3.3
+ 241.5498ms,0.0V 241.5599ms,0.0
+ 241.5600ms,3.3V 241.5697ms,3.3
+ 241.5698ms,0.0V 241.5799ms,0.0
+ 241.5800ms,3.3V 241.5897ms,3.3
+ 241.5898ms,0.0V 241.5999ms,0.0
+ 241.6000ms,3.3V 241.6097ms,3.3
+ 241.6098ms,0.0V 241.6199ms,0.0
+ 241.6200ms,3.3V 241.6297ms,3.3
+ 241.6298ms,0.0V 241.6399ms,0.0
+ 241.6400ms,3.3V 241.6497ms,3.3
+ 241.6498ms,0.0V 241.6599ms,0.0
+ 241.6600ms,3.3V 241.6697ms,3.3
+ 241.6698ms,0.0V 241.6799ms,0.0
+ 241.6800ms,3.3V 241.6897ms,3.3
+ 241.6898ms,0.0V 241.6999ms,0.0
+ 241.7000ms,3.3V 241.7097ms,3.3
+ 241.7098ms,0.0V 241.7199ms,0.0
+ 241.7200ms,3.3V 241.7297ms,3.3
+ 241.7298ms,0.0V 241.7399ms,0.0
+ 241.7400ms,3.3V 241.7497ms,3.3
+ 241.7498ms,0.0V 241.7599ms,0.0
+ 241.7600ms,3.3V 241.7697ms,3.3
+ 241.7698ms,0.0V 241.7799ms,0.0
+ 241.7800ms,3.3V 241.7897ms,3.3
+ 241.7898ms,0.0V 241.7999ms,0.0
+ 241.8000ms,3.3V 241.8097ms,3.3
+ 241.8098ms,0.0V 241.8199ms,0.0
+ 241.8200ms,3.3V 241.8297ms,3.3
+ 241.8298ms,0.0V 241.8399ms,0.0
+ 241.8400ms,3.3V 241.8497ms,3.3
+ 241.8498ms,0.0V 241.8599ms,0.0
+ 241.8600ms,3.3V 241.8697ms,3.3
+ 241.8698ms,0.0V 241.8799ms,0.0
+ 241.8800ms,3.3V 241.8897ms,3.3
+ 241.8898ms,0.0V 241.8999ms,0.0
+ 241.9000ms,3.3V 241.9097ms,3.3
+ 241.9098ms,0.0V 241.9199ms,0.0
+ 241.9200ms,3.3V 241.9297ms,3.3
+ 241.9298ms,0.0V 241.9399ms,0.0
+ 241.9400ms,3.3V 241.9497ms,3.3
+ 241.9498ms,0.0V 241.9599ms,0.0
+ 241.9600ms,3.3V 241.9697ms,3.3
+ 241.9698ms,0.0V 241.9799ms,0.0
+ 241.9800ms,3.3V 241.9897ms,3.3
+ 241.9898ms,0.0V 241.9999ms,0.0
+ 242.0000ms,3.3V 242.0097ms,3.3
+ 242.0098ms,0.0V 242.0199ms,0.0
+ 242.0200ms,3.3V 242.0297ms,3.3
+ 242.0298ms,0.0V 242.0399ms,0.0
+ 242.0400ms,3.3V 242.0497ms,3.3
+ 242.0498ms,0.0V 242.0599ms,0.0
+ 242.0600ms,3.3V 242.0697ms,3.3
+ 242.0698ms,0.0V 242.0799ms,0.0
+ 242.0800ms,3.3V 242.0897ms,3.3
+ 242.0898ms,0.0V 242.0999ms,0.0
+ 242.1000ms,3.3V 242.1097ms,3.3
+ 242.1098ms,0.0V 242.1199ms,0.0
+ 242.1200ms,3.3V 242.1297ms,3.3
+ 242.1298ms,0.0V 242.1399ms,0.0
+ 242.1400ms,3.3V 242.1497ms,3.3
+ 242.1498ms,0.0V 242.1599ms,0.0
+ 242.1600ms,3.3V 242.1697ms,3.3
+ 242.1698ms,0.0V 242.1799ms,0.0
+ 242.1800ms,3.3V 242.1897ms,3.3
+ 242.1898ms,0.0V 242.1999ms,0.0
+ 242.2000ms,3.3V 242.2097ms,3.3
+ 242.2098ms,0.0V 242.2199ms,0.0
+ 242.2200ms,3.3V 242.2297ms,3.3
+ 242.2298ms,0.0V 242.2399ms,0.0
+ 242.2400ms,3.3V 242.2497ms,3.3
+ 242.2498ms,0.0V 242.2599ms,0.0
+ 242.2600ms,3.3V 242.2697ms,3.3
+ 242.2698ms,0.0V 242.2799ms,0.0
+ 242.2800ms,3.3V 242.2897ms,3.3
+ 242.2898ms,0.0V 242.2999ms,0.0
+ 242.3000ms,3.3V 242.3097ms,3.3
+ 242.3098ms,0.0V 242.3199ms,0.0
+ 242.3200ms,3.3V 242.3297ms,3.3
+ 242.3298ms,0.0V 242.3399ms,0.0
+ 242.3400ms,3.3V 242.3497ms,3.3
+ 242.3498ms,0.0V 242.3599ms,0.0
+ 242.3600ms,3.3V 242.3697ms,3.3
+ 242.3698ms,0.0V 242.3799ms,0.0
+ 242.3800ms,3.3V 242.3897ms,3.3
+ 242.3898ms,0.0V 242.3999ms,0.0
+ 242.4000ms,3.3V 242.4097ms,3.3
+ 242.4098ms,0.0V 242.4199ms,0.0
+ 242.4200ms,3.3V 242.4297ms,3.3
+ 242.4298ms,0.0V 242.4399ms,0.0
+ 242.4400ms,3.3V 242.4497ms,3.3
+ 242.4498ms,0.0V 242.4599ms,0.0
+ 242.4600ms,3.3V 242.4697ms,3.3
+ 242.4698ms,0.0V 242.4799ms,0.0
+ 242.4800ms,3.3V 242.4897ms,3.3
+ 242.4898ms,0.0V 242.4999ms,0.0
+ 242.5000ms,3.3V 242.5097ms,3.3
+ 242.5098ms,0.0V 242.5199ms,0.0
+ 242.5200ms,3.3V 242.5297ms,3.3
+ 242.5298ms,0.0V 242.5399ms,0.0
+ 242.5400ms,3.3V 242.5497ms,3.3
+ 242.5498ms,0.0V 242.5599ms,0.0
+ 242.5600ms,3.3V 242.5697ms,3.3
+ 242.5698ms,0.0V 242.5799ms,0.0
+ 242.5800ms,3.3V 242.5897ms,3.3
+ 242.5898ms,0.0V 242.5999ms,0.0
+ 242.6000ms,3.3V 242.6097ms,3.3
+ 242.6098ms,0.0V 242.6199ms,0.0
+ 242.6200ms,3.3V 242.6297ms,3.3
+ 242.6298ms,0.0V 242.6399ms,0.0
+ 242.6400ms,3.3V 242.6497ms,3.3
+ 242.6498ms,0.0V 242.6599ms,0.0
+ 242.6600ms,3.3V 242.6697ms,3.3
+ 242.6698ms,0.0V 242.6799ms,0.0
+ 242.6800ms,3.3V 242.6897ms,3.3
+ 242.6898ms,0.0V 242.6999ms,0.0
+ 242.7000ms,3.3V 242.7097ms,3.3
+ 242.7098ms,0.0V 242.7199ms,0.0
+ 242.7200ms,3.3V 242.7297ms,3.3
+ 242.7298ms,0.0V 242.7399ms,0.0
+ 242.7400ms,3.3V 242.7497ms,3.3
+ 242.7498ms,0.0V 242.7599ms,0.0
+ 242.7600ms,3.3V 242.7697ms,3.3
+ 242.7698ms,0.0V 242.7799ms,0.0
+ 242.7800ms,3.3V 242.7897ms,3.3
+ 242.7898ms,0.0V 242.7999ms,0.0
+ 242.8000ms,3.3V 242.8097ms,3.3
+ 242.8098ms,0.0V 242.8199ms,0.0
+ 242.8200ms,3.3V 242.8297ms,3.3
+ 242.8298ms,0.0V 242.8399ms,0.0
+ 242.8400ms,3.3V 242.8497ms,3.3
+ 242.8498ms,0.0V 242.8599ms,0.0
+ 242.8600ms,3.3V 242.8697ms,3.3
+ 242.8698ms,0.0V 242.8799ms,0.0
+ 242.8800ms,3.3V 242.8897ms,3.3
+ 242.8898ms,0.0V 242.8999ms,0.0
+ 242.9000ms,3.3V 242.9097ms,3.3
+ 242.9098ms,0.0V 242.9199ms,0.0
+ 242.9200ms,3.3V 242.9297ms,3.3
+ 242.9298ms,0.0V 242.9399ms,0.0
+ 242.9400ms,3.3V 242.9497ms,3.3
+ 242.9498ms,0.0V 242.9599ms,0.0
+ 242.9600ms,3.3V 242.9697ms,3.3
+ 242.9698ms,0.0V 242.9799ms,0.0
+ 242.9800ms,3.3V 242.9897ms,3.3
+ 242.9898ms,0.0V 242.9999ms,0.0
+ 243.0000ms,3.3V 243.0097ms,3.3
+ 243.0098ms,0.0V 243.0199ms,0.0
+ 243.0200ms,3.3V 243.0297ms,3.3
+ 243.0298ms,0.0V 243.0399ms,0.0
+ 243.0400ms,3.3V 243.0497ms,3.3
+ 243.0498ms,0.0V 243.0599ms,0.0
+ 243.0600ms,3.3V 243.0697ms,3.3
+ 243.0698ms,0.0V 243.0799ms,0.0
+ 243.0800ms,3.3V 243.0897ms,3.3
+ 243.0898ms,0.0V 243.0999ms,0.0
+ 243.1000ms,3.3V 243.1097ms,3.3
+ 243.1098ms,0.0V 243.1199ms,0.0
+ 243.1200ms,3.3V 243.1297ms,3.3
+ 243.1298ms,0.0V 243.1399ms,0.0
+ 243.1400ms,3.3V 243.1497ms,3.3
+ 243.1498ms,0.0V 243.1599ms,0.0
+ 243.1600ms,3.3V 243.1697ms,3.3
+ 243.1698ms,0.0V 243.1799ms,0.0
+ 243.1800ms,3.3V 243.1897ms,3.3
+ 243.1898ms,0.0V 243.1999ms,0.0
+ 243.2000ms,3.3V 243.2097ms,3.3
+ 243.2098ms,0.0V 243.2199ms,0.0
+ 243.2200ms,3.3V 243.2297ms,3.3
+ 243.2298ms,0.0V 243.2399ms,0.0
+ 243.2400ms,3.3V 243.2497ms,3.3
+ 243.2498ms,0.0V 243.2599ms,0.0
+ 243.2600ms,3.3V 243.2697ms,3.3
+ 243.2698ms,0.0V 243.2799ms,0.0
+ 243.2800ms,3.3V 243.2897ms,3.3
+ 243.2898ms,0.0V 243.2999ms,0.0
+ 243.3000ms,3.3V 243.3097ms,3.3
+ 243.3098ms,0.0V 243.3199ms,0.0
+ 243.3200ms,3.3V 243.3297ms,3.3
+ 243.3298ms,0.0V 243.3399ms,0.0
+ 243.3400ms,3.3V 243.3497ms,3.3
+ 243.3498ms,0.0V 243.3599ms,0.0
+ 243.3600ms,3.3V 243.3697ms,3.3
+ 243.3698ms,0.0V 243.3799ms,0.0
+ 243.3800ms,3.3V 243.3897ms,3.3
+ 243.3898ms,0.0V 243.3999ms,0.0
+ 243.4000ms,3.3V 243.4097ms,3.3
+ 243.4098ms,0.0V 243.4199ms,0.0
+ 243.4200ms,3.3V 243.4297ms,3.3
+ 243.4298ms,0.0V 243.4399ms,0.0
+ 243.4400ms,3.3V 243.4497ms,3.3
+ 243.4498ms,0.0V 243.4599ms,0.0
+ 243.4600ms,3.3V 243.4697ms,3.3
+ 243.4698ms,0.0V 243.4799ms,0.0
+ 243.4800ms,3.3V 243.4897ms,3.3
+ 243.4898ms,0.0V 243.4999ms,0.0
+ 243.5000ms,3.3V 243.5097ms,3.3
+ 243.5098ms,0.0V 243.5199ms,0.0
+ 243.5200ms,3.3V 243.5297ms,3.3
+ 243.5298ms,0.0V 243.5399ms,0.0
+ 243.5400ms,3.3V 243.5497ms,3.3
+ 243.5498ms,0.0V 243.5599ms,0.0
+ 243.5600ms,3.3V 243.5697ms,3.3
+ 243.5698ms,0.0V 243.5799ms,0.0
+ 243.5800ms,3.3V 243.5897ms,3.3
+ 243.5898ms,0.0V 243.5999ms,0.0
+ 243.6000ms,3.3V 243.6097ms,3.3
+ 243.6098ms,0.0V 243.6199ms,0.0
+ 243.6200ms,3.3V 243.6297ms,3.3
+ 243.6298ms,0.0V 243.6399ms,0.0
+ 243.6400ms,3.3V 243.6497ms,3.3
+ 243.6498ms,0.0V 243.6599ms,0.0
+ 243.6600ms,3.3V 243.6697ms,3.3
+ 243.6698ms,0.0V 243.6799ms,0.0
+ 243.6800ms,3.3V 243.6897ms,3.3
+ 243.6898ms,0.0V 243.6999ms,0.0
+ 243.7000ms,3.3V 243.7097ms,3.3
+ 243.7098ms,0.0V 243.7199ms,0.0
+ 243.7200ms,3.3V 243.7297ms,3.3
+ 243.7298ms,0.0V 243.7399ms,0.0
+ 243.7400ms,3.3V 243.7497ms,3.3
+ 243.7498ms,0.0V 243.7599ms,0.0
+ 243.7600ms,3.3V 243.7697ms,3.3
+ 243.7698ms,0.0V 243.7799ms,0.0
+ 243.7800ms,3.3V 243.7897ms,3.3
+ 243.7898ms,0.0V 243.7999ms,0.0
+ 243.8000ms,3.3V 243.8097ms,3.3
+ 243.8098ms,0.0V 243.8199ms,0.0
+ 243.8200ms,3.3V 243.8297ms,3.3
+ 243.8298ms,0.0V 243.8399ms,0.0
+ 243.8400ms,3.3V 243.8497ms,3.3
+ 243.8498ms,0.0V 243.8599ms,0.0
+ 243.8600ms,3.3V 243.8697ms,3.3
+ 243.8698ms,0.0V 243.8799ms,0.0
+ 243.8800ms,3.3V 243.8897ms,3.3
+ 243.8898ms,0.0V 243.8999ms,0.0
+ 243.9000ms,3.3V 243.9097ms,3.3
+ 243.9098ms,0.0V 243.9199ms,0.0
+ 243.9200ms,3.3V 243.9297ms,3.3
+ 243.9298ms,0.0V 243.9399ms,0.0
+ 243.9400ms,3.3V 243.9497ms,3.3
+ 243.9498ms,0.0V 243.9599ms,0.0
+ 243.9600ms,3.3V 243.9697ms,3.3
+ 243.9698ms,0.0V 243.9799ms,0.0
+ 243.9800ms,3.3V 243.9897ms,3.3
+ 243.9898ms,0.0V 243.9999ms,0.0
+ 244.0000ms,3.3V 244.0097ms,3.3
+ 244.0098ms,0.0V 244.0199ms,0.0
+ 244.0200ms,3.3V 244.0297ms,3.3
+ 244.0298ms,0.0V 244.0399ms,0.0
+ 244.0400ms,3.3V 244.0497ms,3.3
+ 244.0498ms,0.0V 244.0599ms,0.0
+ 244.0600ms,3.3V 244.0697ms,3.3
+ 244.0698ms,0.0V 244.0799ms,0.0
+ 244.0800ms,3.3V 244.0897ms,3.3
+ 244.0898ms,0.0V 244.0999ms,0.0
+ 244.1000ms,3.3V 244.1097ms,3.3
+ 244.1098ms,0.0V 244.1199ms,0.0
+ 244.1200ms,3.3V 244.1297ms,3.3
+ 244.1298ms,0.0V 244.1399ms,0.0
+ 244.1400ms,3.3V 244.1497ms,3.3
+ 244.1498ms,0.0V 244.1599ms,0.0
+ 244.1600ms,3.3V 244.1697ms,3.3
+ 244.1698ms,0.0V 244.1799ms,0.0
+ 244.1800ms,3.3V 244.1897ms,3.3
+ 244.1898ms,0.0V 244.1999ms,0.0
+ 244.2000ms,3.3V 244.2097ms,3.3
+ 244.2098ms,0.0V 244.2199ms,0.0
+ 244.2200ms,3.3V 244.2297ms,3.3
+ 244.2298ms,0.0V 244.2399ms,0.0
+ 244.2400ms,3.3V 244.2497ms,3.3
+ 244.2498ms,0.0V 244.2599ms,0.0
+ 244.2600ms,3.3V 244.2697ms,3.3
+ 244.2698ms,0.0V 244.2799ms,0.0
+ 244.2800ms,3.3V 244.2897ms,3.3
+ 244.2898ms,0.0V 244.2999ms,0.0
+ 244.3000ms,3.3V 244.3097ms,3.3
+ 244.3098ms,0.0V 244.3199ms,0.0
+ 244.3200ms,3.3V 244.3297ms,3.3
+ 244.3298ms,0.0V 244.3399ms,0.0
+ 244.3400ms,3.3V 244.3497ms,3.3
+ 244.3498ms,0.0V 244.3599ms,0.0
+ 244.3600ms,3.3V 244.3697ms,3.3
+ 244.3698ms,0.0V 244.3799ms,0.0
+ 244.3800ms,3.3V 244.3897ms,3.3
+ 244.3898ms,0.0V 244.3999ms,0.0
+ 244.4000ms,3.3V 244.4097ms,3.3
+ 244.4098ms,0.0V 244.4199ms,0.0
+ 244.4200ms,3.3V 244.4297ms,3.3
+ 244.4298ms,0.0V 244.4399ms,0.0
+ 244.4400ms,3.3V 244.4497ms,3.3
+ 244.4498ms,0.0V 244.4599ms,0.0
+ 244.4600ms,3.3V 244.4697ms,3.3
+ 244.4698ms,0.0V 244.4799ms,0.0
+ 244.4800ms,3.3V 244.4897ms,3.3
+ 244.4898ms,0.0V 244.4999ms,0.0
+ 244.5000ms,3.3V 244.5097ms,3.3
+ 244.5098ms,0.0V 244.5199ms,0.0
+ 244.5200ms,3.3V 244.5297ms,3.3
+ 244.5298ms,0.0V 244.5399ms,0.0
+ 244.5400ms,3.3V 244.5497ms,3.3
+ 244.5498ms,0.0V 244.5599ms,0.0
+ 244.5600ms,3.3V 244.5697ms,3.3
+ 244.5698ms,0.0V 244.5799ms,0.0
+ 244.5800ms,3.3V 244.5897ms,3.3
+ 244.5898ms,0.0V 244.5999ms,0.0
+ 244.6000ms,3.3V 244.6097ms,3.3
+ 244.6098ms,0.0V 244.6199ms,0.0
+ 244.6200ms,3.3V 244.6297ms,3.3
+ 244.6298ms,0.0V 244.6399ms,0.0
+ 244.6400ms,3.3V 244.6497ms,3.3
+ 244.6498ms,0.0V 244.6599ms,0.0
+ 244.6600ms,3.3V 244.6697ms,3.3
+ 244.6698ms,0.0V 244.6799ms,0.0
+ 244.6800ms,3.3V 244.6897ms,3.3
+ 244.6898ms,0.0V 244.6999ms,0.0
+ 244.7000ms,3.3V 244.7097ms,3.3
+ 244.7098ms,0.0V 244.7199ms,0.0
+ 244.7200ms,3.3V 244.7297ms,3.3
+ 244.7298ms,0.0V 244.7399ms,0.0
+ 244.7400ms,3.3V 244.7497ms,3.3
+ 244.7498ms,0.0V 244.7599ms,0.0
+ 244.7600ms,3.3V 244.7697ms,3.3
+ 244.7698ms,0.0V 244.7799ms,0.0
+ 244.7800ms,3.3V 244.7897ms,3.3
+ 244.7898ms,0.0V 244.7999ms,0.0
+ 244.8000ms,3.3V 244.8097ms,3.3
+ 244.8098ms,0.0V 244.8199ms,0.0
+ 244.8200ms,3.3V 244.8297ms,3.3
+ 244.8298ms,0.0V 244.8399ms,0.0
+ 244.8400ms,3.3V 244.8497ms,3.3
+ 244.8498ms,0.0V 244.8599ms,0.0
+ 244.8600ms,3.3V 244.8697ms,3.3
+ 244.8698ms,0.0V 244.8799ms,0.0
+ 244.8800ms,3.3V 244.8897ms,3.3
+ 244.8898ms,0.0V 244.8999ms,0.0
+ 244.9000ms,3.3V 244.9097ms,3.3
+ 244.9098ms,0.0V 244.9199ms,0.0
+ 244.9200ms,3.3V 244.9297ms,3.3
+ 244.9298ms,0.0V 244.9399ms,0.0
+ 244.9400ms,3.3V 244.9497ms,3.3
+ 244.9498ms,0.0V 244.9599ms,0.0
+ 244.9600ms,3.3V 244.9697ms,3.3
+ 244.9698ms,0.0V 244.9799ms,0.0
+ 244.9800ms,3.3V 244.9897ms,3.3
+ 244.9898ms,0.0V 244.9999ms,0.0
+ 245.0000ms,3.3V 245.0097ms,3.3
+ 245.0098ms,0.0V 245.0199ms,0.0
+ 245.0200ms,3.3V 245.0297ms,3.3
+ 245.0298ms,0.0V 245.0399ms,0.0
+ 245.0400ms,3.3V 245.0497ms,3.3
+ 245.0498ms,0.0V 245.0599ms,0.0
+ 245.0600ms,3.3V 245.0697ms,3.3
+ 245.0698ms,0.0V 245.0799ms,0.0
+ 245.0800ms,3.3V 245.0897ms,3.3
+ 245.0898ms,0.0V 245.0999ms,0.0
+ 245.1000ms,3.3V 245.1097ms,3.3
+ 245.1098ms,0.0V 245.1199ms,0.0
+ 245.1200ms,3.3V 245.1297ms,3.3
+ 245.1298ms,0.0V 245.1399ms,0.0
+ 245.1400ms,3.3V 245.1497ms,3.3
+ 245.1498ms,0.0V 245.1599ms,0.0
+ 245.1600ms,3.3V 245.1697ms,3.3
+ 245.1698ms,0.0V 245.1799ms,0.0
+ 245.1800ms,3.3V 245.1897ms,3.3
+ 245.1898ms,0.0V 245.1999ms,0.0
+ 245.2000ms,3.3V 245.2097ms,3.3
+ 245.2098ms,0.0V 245.2199ms,0.0
+ 245.2200ms,3.3V 245.2297ms,3.3
+ 245.2298ms,0.0V 245.2399ms,0.0
+ 245.2400ms,3.3V 245.2497ms,3.3
+ 245.2498ms,0.0V 245.2599ms,0.0
+ 245.2600ms,3.3V 245.2697ms,3.3
+ 245.2698ms,0.0V 245.2799ms,0.0
+ 245.2800ms,3.3V 245.2897ms,3.3
+ 245.2898ms,0.0V 245.2999ms,0.0
+ 245.3000ms,3.3V 245.3097ms,3.3
+ 245.3098ms,0.0V 245.3199ms,0.0
+ 245.3200ms,3.3V 245.3297ms,3.3
+ 245.3298ms,0.0V 245.3399ms,0.0
+ 245.3400ms,3.3V 245.3497ms,3.3
+ 245.3498ms,0.0V 245.3599ms,0.0)
* ANALYSIS
.TRAN 250m 250m 1u
.PROBE
.END
